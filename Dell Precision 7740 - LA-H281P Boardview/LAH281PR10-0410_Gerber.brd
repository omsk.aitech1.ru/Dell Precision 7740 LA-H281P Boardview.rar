# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RJ45_MDIN1: length 37.3
  IN4 w0.241: JLOM1.6 147.28,162.46 146.52,161.7 146.52,158.87 147.83,157.56 161.81,157.56 163.6,159.35 163.6,165.79 162.5,166.88 160.82,166.88 160.71,166.77 160.71,166.56 v2(160.96,166.3)
  BOTTOM w0.267: v2(160.96,166.3) 161.21,166.56 161.21,166.74 161.07,166.89 160.98,166.89 160.97,166.87 160.18,166.87 159.69,166.38 158.98,166.38
RJ45_MDIN2: length 34
  IN3 w0.229: v2(160.96,163.76) 160.65,164.07 160.65,164.23 160.79,164.36 162.04,164.36 162.86,163.55 162.86,159.48 161.12,157.75 146.83,157.75 145.43,159.15 145.43,163.02 145.69,163.29 145.9,163.29 JLOM1.5
  BOTTOM w0.267: 158.98,163.84 159.64,163.84 160.14,164.35 161.08,164.35 161.21,164.23 161.21,164.02 v2(160.96,163.76)
RJ45_MDIN3: length 27
  IN2 w0.229: JLOM1.8 148.96,163.66 148.96,163.48 149.65,162.78 149.65,162.1 148.41,160.85 148.41,158.74 149.78,157.37 161.88,157.37 162.41,157.9 162.41,158.72 161.85,159.28 161.16,159.28 161.03,159.15 161.03,158.89 v2(161.24,158.68)
  BOTTOM w0.267: v2(161.24,158.68) 161.24,159.04 161,159.28 160.35,159.28 159.84,158.76 158.98,158.76
RJ45_MDIP0: length 42.5
  BOTTOM w0.267: TL1.24 160.37,172.73 160.39,172.75 161.27,172.75 162.57,171.44 162.57,158.33 161.29,157.05 v3(156.14,157.05) 144.86,157.05 143.91,158 143.91,159.29 142.17,161.03 142.17,162.92 JLOM1.1
RJ45_MDIP1: length 37.4
  IN4 w0.241: v2(161.01,167.45) 161.19,167.27 162.66,167.27 163.98,165.95 163.98,159.19 161.97,157.18 147.67,157.18 146.14,158.71 146.14,161.72 144.94,162.92 JLOM1.3
  BOTTOM w0.267: TL1.20 159.61,167.65 160.01,167.25 160.81,167.25 v2(161.01,167.45)
RJ45_MDIP2: length 34.1
  IN3 w0.229: JLOM1.4 145.24,163.41 145.06,163.22 145.06,159 146.68,157.38 161.28,157.38 163.22,159.33 163.22,163.7 162.19,164.73 161.14,164.73 v2(160.96,164.91)
  BOTTOM w0.267: v2(160.96,164.91) 160.78,164.73 160.12,164.73 159.74,165.11 TL1.18
RJ45_MDIP3: length 26.9
  IN2 w0.229: v2(161.24,159.83) 161.42,159.64 162,159.64 162.77,158.87 162.77,157.74 162.03,157 149.63,157 148.04,158.59 148.04,161.01 149.29,162.25 149.29,162.63 148.99,162.92 JLOM1.7
  BOTTOM w0.267: v2(161.24,159.83) 161.07,159.66 160.19,159.66 159.81,160.03 TL1.14
RREF: length 2.4
  BOTTOM w0.254: UR1.44 18.1,20.3 v1(18.16,20.36) 18.16,21.18 RR205.1
RTC_DET#: length 256.6
  TOP w0.109: UH1.BF18 123.34,40.31 123.17,40.31 123.1,40.37 122.83,40.37 122.79,40.38 122.75,40.4 122.72,40.42 122.7,40.43 122.66,40.47 122.63,40.56 122.63,40.73 122.48,40.88 122.17,40.88 122.02,40.73 v2(122.02,40.7) ; v1(152.85,58.51) 154.19,58.51 v2(154.29,58.41)
  IN2 w0.081: v2(303.73,28.97) 303.73,26.91 303.38,26.56 303.38,17.34 301.68,15.64 294.66,15.64 292.06,13.04 291.04,13.04 289.63,11.62 266.49,11.62 263.1,15.02 260.02,15.02 257,18.04 248.1,18.04 247.14,18.99 243,18.99 241.56,17.55 240.48,17.55 239.72,16.8 237.31,16.8 233.01,12.49 231.61,12.49 231.19,12.92 214.12,12.92 212.69,11.49 176.15,11.49 174.23,13.4 172.46,13.4 168.05,17.81 168.05,23.36 166.98,24.43 166.98,41.27 165.56,42.69 165.56,45.97 v2(163.27,48.26)
  IN3 w0.081: v2(154.29,58.41) 152.38,58.41 150.8,56.83 148.9,56.83 148.32,56.25 147.22,56.25 145.16,54.18 143.67,54.18 142.14,52.65 139.17,52.65 138.88,52.94 136.55,52.94 134.68,51.07 134.68,50.08 132.39,47.78 130.39,47.78 130.05,47.45 127.77,47.45 127.33,47 127.33,45.29 127.58,45.04 127.58,44.15 127.01,43.58 126.33,43.58 125.5,42.75 124.04,42.75 122.02,40.73 v2(122.02,40.7)
  BOTTOM w0.109: v2(154.29,58.41) 154.29,57.53 158.24,53.58 158.24,52.04 162.03,48.26 v2(163.27,48.26) 163.32,48.32 RH734.2 ; v2(303.73,28.97) 304.56,29.8 304.56,32.02 304.27,32.3 PQ26.1
RTCRST_ON: length 16.7
  TOP w0.254: UE1.F11 140.89,75.25 v2(141.24,75.6)
  BOTTOM w0.254: RE93.1 154.81,75.54 154.45,75.9 QE12.2 154.14,75.9 153.17,74.93 151.3,74.93 v1(150.99,75.25) 150.64,75.6 148.93,75.6 147.22,73.89 144.88,73.89 144.69,73.7 143.93,73.7 142.03,75.6 v2(141.24,75.6)
RTCRST_ON_POWER: length 7.3
  TOP w0.109: UE1.B13 142.92,78.45 v2(142.99,78.52) ; v2(145.21,82.06) 144.83,81.68 RE747.2
  IN1 w0.102: v2(145.21,82.06) 144.5,82.06 142.31,79.87 142.31,79.2 v2(142.99,78.52)
  BOTTOM w0.109: v2(145.21,82.06) v1(144.63,82.06)
RTCRST_ON_R: length 9.3
  TOP w0.109: CE65.1 145.81,82.95 145.74,83.01 145.74,83.09 145.7,83.13 DE2.2 145.7,84.05 146.25,84.6 146.25,85.31 RE543.1 145.94,86.02 146.51,86.02 146.79,85.74 QE17.2 149.51,85.11 v1(148.87,84.47)
RTCRST_ON_R1: length 9.9
  TOP w0.109: QE15.2 142.37,86.73 143.46,85.64 145,85.64 RE543.2 145.68,84.84 RE541.2 144,84.24 DE2.1 ; DE2.1 144,82.67 CE64.1 143.7,82.36 RE747.1 ; DE2.1 143.19,83.71 v1(142.99,83.5)
RTD3_CIO_PWR_EN: length 148.5
  TOP w0.109: v2(132.34,27.7) 132.76,28.12 UH1.AE43 ; v2(41.73,57.89) 37.75,57.89 37.18,58.46 35.95,58.46 35.63,58.14 35.63,56.8 37.17,55.26 38.95,55.26 39.34,54.87 RT392.2
  IN1 w0.102: v2(129.14,39.29) 129.58,38.86 129.58,36.78 130.82,35.54 130.82,30.97 130.35,30.49 130.09,30.49 129.66,30.06 129.66,28.84 129.92,28.58 130.49,28.58 130.97,29.05 131.56,29.05 132.34,28.27 v2(132.34,27.7)
  IN2 w0.081: v2(125.5,46.37) 125.5,46.65 126.19,47.34 126.81,47.34 126.95,47.2 126.95,46.34 127.63,45.66 127.63,44.88 127.97,44.55 127.97,44.08 128.62,43.43 128.62,39.81 v2(129.14,39.29)
  IN4 w0.102: v2(41.73,57.89) 43.71,55.91 45.97,55.91 47.23,54.65 53.18,54.65 53.47,54.94 58.76,54.94 59.31,54.4 66.14,54.4 67.01,55.26 68.77,55.26 69.56,56.05 76.91,56.05 77.58,55.37 79.45,55.37 79.86,55.78 86.05,55.78 86.42,56.15 90.93,56.15 95.51,60.73 102.86,60.73 106.39,57.21 107.39,57.21 109.43,55.17 110.64,55.17 113.34,52.47 113.34,51.79 114.41,50.71 114.41,47.82 115.36,46.87 116.6,46.87 117.43,47.7 120.88,47.7 123.48,45.1 124.6,45.1 125.5,45.99 v2(125.5,46.37)
  BOTTOM w0.109: v2(132.34,27.7) 132.5,27.85 133.35,27.85 133.57,27.63 133.57,26.05 133.24,25.73 132.6,25.73 131.72,24.85 131.72,24.16 132.61,23.27 RH730.2
RTD3_CIO_PWR_EN_R: length 8.5
  TOP w0.109: v2(39.04,50.44) 38.6,50.88 38.6,52.01 RT392.1 RT372.1 ; RT372.1 40.23,52.55 39.65,51.97 v1(39.65,51.73) ; RT372.1 40.23,52.87 39.77,53.32 RT614.1 39.79,54.83 RT643.1
  BOTTOM w0.109: v2(39.04,50.44) UT1.T5
RTD3_SELECT: length 64.4
  TOP w0.109: v2(112.52,66.09) 112.93,65.67 118.02,65.67 118.15,65.55 RT447.2 117.91,65.05 UT32.6
  IN3 w0.081: v2(112.52,66.09) 112.83,65.77 113.8,65.77 114.37,66.34 114.37,67.34 116.06,69.02 116.06,69.27 116.49,69.71 117.65,69.71 119.31,71.36 119.31,72.04 119.61,72.34 122.51,72.34 125.11,74.95 125.99,74.95 126.39,74.55 127.2,74.55 128.04,73.71 129.3,73.71 130.93,75.34 132.34,75.34 133,76 134.21,76 134.43,76.21 134.43,76.65 134.61,76.82 135.79,76.82 136.09,77.13 136.09,77.36 136.34,77.61 137.46,77.61 138.67,78.82 140.6,78.82 141.05,79.27 141.94,79.27 142.33,78.88 143.32,78.88 143.52,78.68 143.52,78.17 143.81,77.88 145.76,77.88 147.51,76.13 v2(147.51,75.77)
  BOTTOM w0.109: UE12.21 157.28,76.37 156.26,77.4 154.29,77.4 153.93,77.04 152.74,77.04 152.04,76.34 151.72,76.34 151.52,76.13 v1(149.69,76.13) 148.88,76.13 148.51,75.77 v2(147.51,75.77)
RTD3_USB_PWR_EN: length 15.4
  TOP w0.109: v2(43.76,52.47) 43.76,52.49 44.07,52.8 RT591.1 44.81,54.49 v1(44.9,54.59) ; RT26.1 39.7,50.43 v2(39.69,50.44)
  IN2 w0.081: v2(43.76,52.47) 43.38,52.08 41.65,52.08 41.17,52.57 38.53,52.57 38.3,52.34 38.3,50.92 37.89,50.51 37.89,50.23 38.4,49.72 38.4,49.65 38.71,49.34 39.29,49.34 39.49,49.54 39.49,50.05 39.69,50.25 v2(39.69,50.44)
  BOTTOM w0.109: v2(39.69,50.44) UT1.V5
RUN_ON: length 727.2
  TOP w0.109: v2(276.86,75.51) 276.86,76.04 276.57,76.33 UZ35.2 ; UZ60.2 358.8,12.84 v2(358.49,12.54) ; UZ45.3 332.86,13.19 332.65,12.98 332.65,12.6 333.39,11.85 v2(333.55,11.85) ; UZ43.3 94.67,57.67 95.25,58.24 95.25,62.64 95.02,62.86 95.02,67.82 96.63,69.42 98.69,69.42 100.73,71.47 110.86,71.47 111.14,71.19 112.04,71.19 112.61,71.76 119.37,71.76 119.72,71.41 123.19,71.41 123.74,71.97 123.74,75 123.84,75.1 124.73,75.1 124.9,74.93 QE2.2 124.9,73.64 v2(126.57,71.97) ; v2(364.54,32.3) 365.15,31.69 RZ510.1
  TOP w0.254: PR304.1 310.68,63.78 313.19,66.3 v2(313.19,66.99)
  IN1 w0.102: v2(55.15,16.87) 55.19,16.87 55.4,17.08 55.4,19.52 57.61,21.74 58.19,21.74 58.67,22.22 58.67,22.52 60.55,24.4 65.11,24.4 66.16,25.44 71.79,25.44 72.36,24.87 74.21,24.87 74.71,24.37 77.83,24.37 80.85,27.4 82.45,27.4 84.12,29.06 85.92,29.06 87.89,31.03 87.96,31.03 90.23,33.3 90.23,33.78 91.01,34.56 92.35,34.56 92.4,34.51 95.5,34.51 96.09,33.92 v2(96.21,33.92) ; v2(333.55,11.85) 333.55,11.72 334.66,10.62 338.17,10.62 340.93,7.85 340.93,4.51 340.61,4.18 v2(339.75,4.18) 338.92,3.35 335.82,3.35 333.89,1.41 331.56,1.41 331.04,1.94 v2(330.61,1.94) ; v2(358.49,12.54) 357.97,13.06 357.46,13.06 356.03,14.49 356.03,16.11 356.85,16.93 360.56,16.93 361.44,17.81 365.15,17.81 366.1,18.76 369.31,18.76 373.26,22.71 373.26,23.56 373.75,24.05 373.75,25.61 372.37,26.99 371.42,26.99 370.31,28.11 370.31,32.97 369.65,33.63 365.87,33.63 v2(364.54,32.3) 364.14,32.69 363.33,32.69 362.43,33.59 354.42,33.59 353.07,34.94 353.07,36.53 351.42,38.18 351.42,39.19 350.47,40.15 350.47,52.4 349.58,53.29 340.12,53.29 v2(337.45,55.96)
  IN2 w0.081: v2(358.49,12.54) 358.65,12.38 358.65,8.56 355.96,5.88 351.47,5.88 350.11,4.52 346.2,4.52 345.28,3.6 343.26,3.6 342.81,3.15 340.78,3.15 v2(339.75,4.18) ; v2(30.27,17.54) 30.27,17.52 29.73,16.97 29.73,15.08 28.93,14.27 28.93,13.01 28.47,12.55 v2(28.47,12.03) ; v2(166.3,1.42) 166.3,5.87 153.61,18.57 153.61,20.93 151.34,23.19 151.34,25.25 v2(151.12,25.48)
  VCC w0.086: v2(330.61,1.94) 330.61,1.45 330.35,1.19 320.08,1.19 319.51,1.76 318.43,1.76 317.77,1.1 256.02,1.1 251.59,5.53 248.42,5.53 244,1.11 166.61,1.11 v2(166.3,1.42)
  IN3 w0.081: v2(151.12,25.48) 151.12,26.58 157.81,33.27 157.81,44.26 158.14,44.59 158.14,53.19 158.95,54 158.95,60.61 v2(158.63,60.92) ; v2(28.47,12.03) 30.5,14.06 31.75,14.06 31.98,14.29 33.33,14.29 33.89,14.85 36.55,14.85 37.6,13.79 39.13,13.79 39.36,13.57 41.38,13.57 42.38,14.56 44.55,14.56 44.63,14.49 47.67,14.49 47.9,14.26 49.86,14.26 50.62,15.03 53.21,15.03 55.06,16.87 v2(55.15,16.87) ; v2(337.45,55.96) 337.45,56.28 336.21,57.52 326.22,57.52 325.63,56.93 322.27,56.93 315.97,63.22 315.97,64.21 v2(313.19,66.99) 312.37,67.82 312.37,73.05 307.99,77.42 305.69,77.42 303.85,79.26 294.35,79.26 292.85,80.76 289.71,80.76 v2(288.9,79.95) ; v2(96.21,33.92) 96.87,34.58 96.87,35.72 97.52,36.37 97.52,44.46 98.47,45.41 98.47,51.25 100.21,53 102.16,53 103.12,53.95 103.5,53.95 107.28,57.73 111.45,57.73 112.05,58.33 112.05,60.02 112.4,60.37 112.4,62.27 112.63,62.51 113.05,62.51 113.14,62.6 114.06,62.6 115.18,63.72 115.18,64.62 117.47,66.9 117.47,67.7 120.02,70.25 121.1,70.25 121.51,69.85 122.29,69.85 124.41,71.97 v2(126.57,71.97)
  IN4 w0.102: v2(276.86,75.51) 276.86,75.47 278.46,73.87 286.14,73.87 288.87,76.6 288.87,79.92 v2(288.9,79.95)
  BOTTOM w0.109: v2(126.57,71.97) 126.57,71.97 127.07,71.46 127.07,71.2 126.95,71.07 126.95,68.97 127.91,68.01 129.23,68.01 130.38,66.86 138.66,66.86 140.46,65.06 147.03,65.06 148.02,66.05 149.19,66.05 150.14,67 150.14,68.62 150.65,69.13 151.12,69.13 152.41,67.83 152.41,67.19 UE5.4 153.66,66.39 154.38,65.67 156.89,65.67 v1(157.18,65.39) 157.68,64.89 RE292.1 157.68,62.06 RE280.2 158.63,61.11 v2(158.63,60.92) ; UR4.4 30.25,17.51 30.27,17.54 v2(30.27,17.54) ; RZ549.1 299.78,64.91 305.7,64.91 306.78,65.99 312.19,65.99 v2(313.19,66.99)
RUN_ON#: length 295.9
  TOP w0.109: QZ21.2 349,52.87 v2(348.61,52.49) ; v2(126.97,75.78) 126.58,76.17 RE68.1 126.32,76.53 125.5,75.71 125.17,75.71 124.9,75.98 QE2.5 124.9,76.79 124.74,76.95 124.35,76.95 124.25,76.85 QE2.6 ; v2(149.41,94.39) 149.41,96.27 148.99,96.69 148.99,97.07 149.28,97.35 149.88,97.35 149.99,97.24 151.69,97.24 152.09,97.65 152.09,98.9 152.63,99.43 160.73,99.43 161.75,98.4 180.02,98.4 184.71,93.72 201.93,93.72 202.77,92.88 225.28,92.88 v2(225.44,92.72)
  IN1 w0.102: v2(254.12,80.81) 254.12,79.97 252.47,78.32 251.94,78.32 251.66,78.6 251.66,80.51 251.51,80.66 245.08,80.66 244.55,81.19 244.55,82.36 244.14,82.77 242.85,82.77 241.98,83.63 235.71,83.63 233.69,85.66 233.69,86.9 233.32,87.26 232.76,87.26 231.57,88.46 231.57,91.96 231.18,92.36 229.27,92.36 228.24,93.39 226.1,93.39 v2(225.44,92.72)
  IN3 w0.081: v2(254.12,80.81) 254.12,79.56 262.42,71.26 266.2,71.26 271.37,76.43 279.11,76.43 281.05,74.49 286.1,74.49 286.81,75.2 301.93,75.2 302.46,74.67 304,74.67 305.14,73.52 305.94,73.52 306.47,72.99 306.47,71.69 308.91,69.26 310.54,69.26 311.45,68.34 311.45,65.12 314.38,62.18 315.7,62.18 320.7,57.19 320.7,56.63 321.08,56.25 326.69,56.25 327.3,56.86 332.7,56.86 333.5,56.06 334.65,56.06 335.15,55.56 335.15,49.88 334.36,49.09 v2(334.24,49.09)
  BOTTOM w0.109: v2(348.61,52.49) 346.73,50.61 v1(343.7,50.61) 340.46,50.61 340.13,50.95 338.02,50.95 336.17,49.09 v2(334.24,49.09) ; v2(126.97,75.78) 126.97,76.8 125.91,77.87 125.91,78.42 126.23,78.75 126.39,78.75 127.39,77.75 128.59,77.75 128.8,77.97 129.49,77.97 130.76,79.24 130.76,81.17 130.4,81.52 130.4,83.02 130.93,83.56 135.18,83.56 135.49,83.86 136.52,83.86 138.24,85.58 141.72,85.58 141.77,85.63 144.13,85.63 146.02,87.52 147.9,87.52 148.61,88.23 148.61,88.91 149.68,89.98 149.68,93.9 149.38,94.2 149.38,94.35 v2(149.41,94.39)
RUN_ON_EC: length 30.3
  TOP w0.109: UE1.E8 v2(138.81,76.42) ; v2(154.05,63.6) 154.05,66.34 151.68,68.71 151.68,69.21 151.29,69.6 148.59,69.6 148.21,69.98 148.21,71.11 v2(148.04,71.28)
  IN4 w0.102: v2(138.81,76.42) 138.38,75.99 138.38,75.25 138.64,74.98 142.14,74.98 145.21,71.91 147.41,71.91 v2(148.04,71.28)
  BOTTOM w0.109: v2(138.81,76.42) 138.69,76.55 RE738.2 ; v2(154.05,63.6) 153.86,63.79 UE5.2 153.86,64.78 154.18,65.09 v1(155.65,65.09) 156.08,65.09 RE292.2
RUN_ON_R: length 5
  TOP w0.109: UZ40.5 366.11,34.16 366.05,34.1 365.57,34.1 365.56,34.1 ; 365.56,34.1 365.47,34.01 365.47,33.66 v1(365.59,33.53) 365.59,32.74 RZ510.2 ; 365.56,34.1 365.25,34.41 365.25,34.73 365.59,35.07 366.06,35.07 366.17,34.96 UZ40.3
RUNPWROK: length 12.3
  TOP w0.109: v2(125.58,73.85) 125.55,73.88 QE2.3 125.65,74.68 RE67.1 ; UE1.G3 v2(134.07,74.08)
  IN3 w0.081: v2(125.58,73.85) 126.01,73.42 127.01,73.42 127.59,72.84 128.52,72.84 128.68,72.67 132.48,72.67 132.88,73.07 132.88,73.64 132.95,73.72 133.71,73.72 v2(134.07,74.08)
S3_1.2V: length 1.9
  TOP w0.203: PU200.7 110.86,13.6 v2(110.72,13.74) 110.23,14.23 PR210.2
S3_OVP: length 3.9
  BOTTOM w0.109: v1(36.38,8.84) 36.9,9.37 PR2154.1
  BOTTOM w0.508: v2(35.56,16.27) 35.25,16.58 PR2054.2 ; PR2153.1 32.37,13.36 v2(32.15,13.15) ; PR2154.1 36.37,9.91 v2(36.04,10.23)
  vias: v2(36.45,13.81) v2(38.12,14.47)
S5_1.2V: length 2.5
  TOP w0.203: PC213.1 110.03,12.66 PR208.2 110.33,13.47 110.6,13.2 PU200.8
S5_OVP: length 16.7
  IN1 w0.508: v2(45.66,17.15) 45.66,13.02 v2(45.63,12.98)
  IN2 w0.508: v2(45.63,12.98) 44.07,12.98 43.11,12.03 42.49,12.03 41.4,13.12 v2(41.2,13.12) 40.56,12.49 40.56,11.9 41.13,11.34 41.13,10.14 v2(41.48,9.79)
  BOTTOM w0.109: v1(40.71,9.01) PR2157.1
  BOTTOM w0.254: PR2157.1 41.26,10.01 v2(41.48,9.79)
  BOTTOM w0.508: PR2055.2 v2(45.66,17.15) ; v2(41.2,13.12) 40.69,12.61 PR2156.1
SA_SW: length 2.2
  TOP w0.109: 284.42,64.44 v1(284.42,63.37)
  BOTTOM w0.508: PC1809.1 282.57,63.77 v2(283.22,64.42)
SATAGP5: length 13.2
  TOP w0.102: v2(129.81,28.02) 129.89,28.1 UH1.AM43
  TOP w0.109: v1(135.65,20.14) 135.99,20.49 v2(135.99,20.69) 136.47,20.69 RH325.2
  IN2 w0.081: v2(129.81,28.02) 130.22,27.61 130.22,26.65 131.37,25.5 132.47,25.5 133.23,24.74 133.23,23.35 133.71,22.87 135.07,22.87 135.68,22.27 135.68,21 v2(135.99,20.69)
SATAGP6: length 3.8
  TOP w0.109: RH326.2 129.3,22.94 130.28,23.93 130.28,24.17 129.92,24.53 129.92,24.7 129.84,24.78 129.84,25.62 130.11,25.89 UH1.AM47
SATALED#: length 476.9
  TOP w0.109: UH1.AK48 132.06,25.05 132.06,24.57 v2(132.12,24.51) ; v2(329.88,54.47) 329.88,46.03 327.77,43.92 326.67,43.92 324.99,42.24 324.99,40.48 325.3,40.17 325.3,37.45 325.19,37.35 325.19,35.3 329.64,30.85 329.64,30.2 331.21,28.63 v2(331.21,28.37) ; v2(370.79,13.86) 371.32,13.86 RN218.2 ; v2(110.77,83.32) 110.8,83.29 113.19,83.29 113.53,83.63 116.62,83.63 118.08,82.17 124.11,82.17 125.54,83.59 125.54,86.93 125.69,87.09 128.18,87.09 129.14,86.12 129.14,85.37 129.37,85.14 130.76,85.14 131.06,85.45 134.81,85.45 135.74,86.38 RN474.2
  IN1 w0.102: v2(132.12,24.51) 132.12,23.25 131.71,22.84 131.13,22.84 130.91,23.05 128.65,23.05 128.04,22.44 128.04,21.26 127.42,20.64 126.32,20.64 124.29,18.61 120.21,18.61 118.69,20.13 118.69,20.64 117.26,22.07 116.67,22.07 116.46,22.15 115.47,23.14 114.26,23.14 113.26,24.14 112.47,24.14 111.69,24.92 111.69,25.63 110.62,26.69 110.62,29.7 110.89,29.97 110.89,31.4 111.08,31.58 111.08,38.8 110.72,39.16 110.72,44.16 110.9,44.34 110.9,49.69 109.09,51.5 109.09,57.01 108.54,57.56 108.54,63.59 108.07,64.06 108.07,67.1 110.37,69.4 110.37,75.07 111.26,75.96 111.26,82.83 v2(110.77,83.32)
  IN3 w0.081: v2(132.12,24.51) 131.7,24.93 130.59,24.93 130.35,24.69 130.35,23.54 131.4,22.48 131.4,21.24 133.53,19.11 134.37,19.11 135.59,20.33 136.14,20.33 136.92,21.11 136.92,22.05 137.04,22.18 139.01,22.18 140.93,20.26 143.02,20.26 143.17,20.1 145.11,20.1 145.31,20.31 146.76,20.31 148.89,18.18 150.9,18.18 151.27,17.81 156.92,17.81 160.86,13.87 163.24,13.87 169.44,7.67 231.14,7.67 234.84,11.36 237.87,11.36 238.17,11.66 240.56,11.66 241.14,12.25 244.49,12.25 244.73,12.49 256.18,12.49 257.73,10.94 266.72,10.94 269.73,7.92 275.92,7.92 276.92,6.92 302.53,6.92 302.75,6.7 307.54,6.7 307.55,6.69 v2(307.56,6.69) 309.08,8.22 317.51,8.22 323.19,13.9 325.16,13.9 327.76,11.3 337.16,11.3 338.38,12.51 340.52,12.51 341.37,11.66 344.94,11.66 347.45,14.18 349.04,14.18 350.1,13.12 353.45,13.12 355.06,11.51 358.33,11.51 358.95,10.89 360.97,10.89 362.21,12.13 362.67,12.13 363.84,13.3 370.23,13.3 v2(370.79,13.86)
  BOTTOM w0.109: v2(329.88,54.47) 330.35,54.94 RN216.2 331.08,55.13 RH380.2 ; RN217.2 331.21,28.68 v2(331.21,28.37) 331.21,26.52 331.16,26.48 331.16,25.5 331.36,25.3 331.36,22.15 330.9,21.69 329.07,21.69 328.53,21.15 328.53,17.26 327.48,16.21 318.15,16.21 317.26,17.1 v1(316.47,17.1) 313.08,17.1 312.68,17.5 310.88,17.5 310.41,17.97 304.17,17.97 303.53,17.33 303.53,12.26 307.56,8.23 v2(307.56,6.69)
SBIOS_TX: length 32.5
  TOP w0.109: v2(121.98,59.82) 121.8,60 v1(121.47,60) ; v2(125.81,38.14) 125.75,38.14 125.68,38.07 125.68,37.65 UH1.BB24
  IN1 w0.102: v2(125.81,38.14) 125.97,38.14 126.18,38.35 126.18,39.14 125.76,39.56 125.05,39.56 124.86,39.76 124.86,40.86 124.01,41.7 124.01,42.94 123.63,43.33 123.63,45.58 122.84,46.37 122.84,47.27 123.28,47.71 123.28,51.84 123.09,52.03 123.09,54.1 122.81,54.38 122.81,55.21 122.22,55.79 122.22,59.58 v2(121.98,59.82)
  BOTTOM w0.109: v2(121.98,59.82) 122.08,59.72 122.08,58.43 120.02,56.37 118.1,56.37 RE306.1
SCK: length 12.1
  IN2 w0.081: v2(15.91,4.92) 15.95,4.92 18.35,7.32 18.35,10.74 18.54,10.93 v2(18.77,10.93)
  BOTTOM w0.109: UR1.17 18.1,12.11 v1(18.56,11.65) 18.56,11.14 v2(18.77,10.93) ; UR3.6 15.49,3.44 15.73,3.69 15.73,4.52 15.91,4.7 v2(15.91,4.92)
SCS: length 29.3
  IN2 w0.081: v2(18.87,4.22) 18.22,3.57 15.82,3.57 15.01,4.38 15.01,8.46 14.42,9.04 14.42,10.05 13.41,11.06 13.41,17.95 v2(13.05,18.3)
  BOTTOM w0.109: UR1.34 13.85,17.43 13.05,18.23 v2(13.05,18.3) ; RR236.1 RR239.2 23.71,4.02 23.18,4.55 23.18,5.23 22.43,5.98 UR3.1 19.81,5.98 18.87,5.04 v2(18.87,4.22)
SD_1_CD#: length 18.3
  TOP w0.109: JSD1.17 31.44,29.11 31.44,29.53 v2(31.34,29.63)
  IN4 w0.102: v2(31.34,29.63) 30.78,29.63 28.52,27.37 28.52,26.56 26.74,24.78 26.42,24.78 23.32,21.68 22.47,21.68 21.64,20.84 v2(21.64,20.28)
  BOTTOM w0.109: UR1.47 19.3,19.52 19.71,19.93 21.28,19.93 v2(21.64,20.28)
SD_1_CLK: length 42.3
  TOP w0.109: JSD1.5 31.22,27.4 30.63,27.4 30.25,27.02 v2(30.25,26.71)
  IN4 w0.102: v2(30.25,26.71) 30.16,26.62 30.16,25.48 29.39,24.71 29.39,22.77 29.28,22.66 28.37,22.66 28.29,22.58 28.29,22.33 28.37,22.25 29.3,22.25 29.39,22.16 29.39,21.96 29.28,21.84 28.26,21.84 28.18,21.77 28.18,21.51 28.26,21.44 29.3,21.44 29.39,21.35 29.39,20.96 29.64,20.71 29.64,18.05 29.29,17.7 25.35,17.7 25.25,17.8 25.25,18.89 25.17,18.96 24.92,18.96 24.84,18.89 24.84,17.8 24.74,17.7 23.24,17.7 23.14,17.8 23.14,18.94 23.06,19.01 22.81,19.01 22.73,18.94 22.73,17.8 22.63,17.7 22.42,17.7 22.32,17.8 22.32,18.96 22.25,19.04 21.99,19.04 21.92,18.96 21.92,17.8 21.82,17.7 20.39,17.7 18.25,15.56 18.25,14.15 15.49,11.39 v2(15.49,11.08)
  BOTTOM w0.109: v2(15.49,11.08) 15.27,10.86 15.27,10.21 15.02,9.96 CR200.1 14.88,10.3 14.78,10.4 RR213.2
SD_1_CLK_R: length 2
  BOTTOM w0.109: UR1.23 15.7,12.02 15.36,11.69 RR213.1
SD_1_CMD: length 38.4
  TOP w0.109: JSD1.2 31.98,18.4 32.93,17.45 v2(32.93,16.46)
  IN1 w0.102: v2(13.23,9.42) 13.23,8.75 12.75,8.27 12.75,7.05 14.42,5.37 23.95,5.37 24.21,5.12 25.74,5.12 26.67,6.04 27.93,6.04 28.56,6.67 28.56,9.02 28.66,9.12 29.09,9.12 29.2,9.22 29.2,9.43 29.09,9.53 28.66,9.53 28.56,9.63 28.56,10.09 28.65,10.17 29.09,10.17 29.21,10.29 29.21,14.37 31.67,16.83 32.56,16.83 v2(32.93,16.46)
  BOTTOM w0.109: v2(13.23,9.42) 13.44,9.64 RR230.2
SD_1_CMD_R: length 2.9
  BOTTOM w0.109: RR230.1 13.44,11.58 v1(13.44,12.55) 13.44,13.28 13.99,13.83 UR1.25
SD_1_D0: length 40.5
  TOP w0.109: JSD1.7 31.22,32.05 31.12,32.16 30.26,32.16 29.45,32.97 29.45,33.96 v2(29.36,34.05)
  IN4 w0.102: v2(15.71,8.9) 15.84,9.04 15.84,9.5 15.59,9.75 14.96,9.75 13.55,11.16 13.55,12.22 14.35,13.02 15.15,13.02 15.94,13.8 15.94,15.98 16.91,16.96 16.91,17.12 16.45,17.58 16.45,18.26 17.05,18.86 17.72,18.86 18.19,18.38 18.34,18.38 18.94,18.98 18.94,20.09 21.88,23.03 21.88,23.31 22.84,24.27 23.24,24.27 24.54,25.57 25.02,25.57 26.87,27.42 26.87,29.57 27.52,30.22 27.52,31.96 28.65,33.09 29.12,33.09 29.51,33.49 29.51,33.9 v2(29.36,34.05)
  BOTTOM w0.109: RR234.1 15.89,9.37 15.89,9.08 v2(15.71,8.9)
SD_1_D0_R: length 2.9
  BOTTOM w0.076: UR1.22 16.1,12.59 16.23,12.46 16.23,12.37 16.03,12.17 16.03,11.93 15.96,11.86 15.96,11.27 16.03,11.2 16.03,10.74 RR234.2
SD_1_D1: length 40.5
  TOP w0.109: v2(30.07,34.05) 29.96,33.94 29.96,33.18 30.47,32.67 31.5,32.67 31.66,32.84 31.66,32.96 JSD1.8
  IN4 w0.102: v2(16.44,8.9) 16.4,8.95 16.4,9.73 15.82,10.31 15.19,10.31 14.11,11.39 14.11,11.99 14.59,12.46 15.38,12.46 16.5,13.57 16.5,15.75 17.47,16.73 17.47,17.35 17.01,17.81 17.01,18.03 17.28,18.3 17.49,18.3 17.96,17.82 18.57,17.82 19.49,18.75 19.49,19.86 22.44,22.8 22.44,23.08 23.07,23.71 23.47,23.71 24.77,25.02 25.25,25.02 27.43,27.19 27.43,29.34 28.08,29.99 28.08,31.73 28.89,32.53 29.35,32.53 30.07,33.25 v2(30.07,34.05)
  BOTTOM w0.109: RR233.1 16.4,9.42 16.4,8.95 v2(16.44,8.9)
SD_1_D1_R: length 2.8
  BOTTOM w0.076: RR233.2 16.18,10.77 v3(16.18,11.56) 16.18,12.11 16.38,12.31 16.38,12.44 16.5,12.55 UR1.21
SD_1_D2: length 2.6
  BOTTOM w0.109: RR228.1 12.52,13.39 v1(13.32,14.18) 13.76,14.63 UR1.27
SD_1_D2_R: length 38.9
  TOP w0.109: v2(31.54,14.54) 31.54,14.7 31.44,14.79 31.44,15.18 JSD1.9
  IN1 w0.102: v2(12.36,9.59) 11.75,9.59 11.53,9.37 11.53,6.52 13.81,4.25 16.7,2.94 21.45,2.94 21.79,3.28 24.37,3.28 24.71,2.94 26.17,2.94 28.41,3.93 31.36,6.88 32.03,9.34 32.03,11.5 31.03,12.49 31.03,14.03 v2(31.54,14.54)
  BOTTOM w0.109: v2(12.36,9.59) 12.19,9.76 12.19,12.01 RR228.2
SD_1_D3: length 3.7
  BOTTOM w0.109: RR229.1 12.67,11.59 13.02,11.93 13.02,13.41 13.84,14.23 UR1.26
SD_1_D3_R: length 37.7
  TOP w0.109: JSD1.1 31.9,16.9 32.2,16.6 32.2,16.24 v2(32.34,16.1)
  IN1 w0.102: v2(32.34,16.1) 32.23,16.1 30.42,14.29 30.42,12.08 31.42,11.09 31.42,9.42 30.33,8.33 30.33,6.71 28.08,4.46 25.63,3.55 24.97,3.55 24.62,3.89 21.54,3.89 21.19,3.55 16.83,3.55 14.15,4.76 12.14,6.78 12.14,8.57 12.77,9.2 12.77,9.84 v2(12.89,9.96)
  BOTTOM w0.109: v2(12.89,9.96) 12.67,10.18 RR229.2
SD_1_N0: length 43.4
  TOP w0.109: v2(9.07,20.96) 9.48,20.96 9.5,20.98 10.33,20.98 10.33,20.97 JSD1.12
  IN1 w0.102: v2(12.76,16.67) 11.74,16.67 11.06,17.36 11.06,18.03 11.5,18.48 11.5,19.39 11.74,19.63 11.74,21.23 12.22,21.7 12.67,21.7 13.01,22.04 13.01,22.52 12.87,22.67 11.38,22.67 10.87,23.17 10.87,23.79 8.9,25.76 8.24,25.76 7.95,25.47 7.95,25.04 8.48,24.5 8.48,23.65 7.86,23.03 7.86,22.76 8.1,22.52 9.27,22.52 10.64,21.15 10.64,19.19 9.78,18.33 9.78,17.7 10.99,16.49 10.99,15.59 10.3,14.91 9.56,14.91 9.25,14.6 8.23,14.6 7.18,15.65 7.18,20.06 8.09,20.96 v2(9.07,20.96)
  BOTTOM w0.109: UR1.32 13.56,16.63 13.38,16.8 12.89,16.8 v2(12.76,16.67)
SD_1_N1: length 43.4
  TOP w0.109: JSD1.15 10.45,26.97 10.3,27.13 10.3,27.87 10.2,27.96 9.65,27.96 9.55,27.85 v2(9.55,27.42)
  IN1 w0.102: v2(9.55,27.42) 9.55,27.83 9.46,27.92 7.86,27.92 7.42,28.35 7.42,29.49 7.2,29.71 6.74,29.71 6.56,29.53 6.56,27.79 7.29,27.06 7.29,26.48 6.56,25.75 6.56,22.4 7.24,21.72 7.24,21.04 6.56,20.36 6.56,15.33 7.26,14.63 7.26,12.28 7.43,12.12 8.16,12.12 8.56,12.52 8.56,13.19 9.04,13.67 9.81,13.67 10.83,12.65 10.83,11.73 11.31,11.25 12.53,11.25 13.02,11.75 13.02,12.63 12.67,12.98 11.67,12.98 10.94,13.71 10.94,14.49 11.7,15.25 12.74,15.25 v2(12.9,15.41)
  BOTTOM w0.109: UR1.29 13.46,15.43 13.26,15.22 13.08,15.22 v2(12.9,15.41)
SD_1_P0: length 43.3
  TOP w0.109: v2(9.09,19.88) 9.09,20.31 9.24,20.46 10.25,20.46 10.36,20.35 10.36,19.7 10.59,19.47 JSD1.11
  IN1 w0.102: v2(9.09,19.88) 9.09,20.28 8.97,20.4 8.32,20.4 7.74,19.82 7.74,15.89 8.46,15.16 9.02,15.16 9.33,15.47 10.07,15.47 10.43,15.83 10.43,16.26 9.22,17.47 9.22,18.56 10.08,19.42 10.08,20.92 9.04,21.96 7.87,21.96 7.31,22.53 7.31,23.27 7.92,23.88 7.92,24.27 7.39,24.8 7.39,25.71 8,26.32 9.13,26.32 11.43,24.02 11.43,23.41 11.61,23.23 13.1,23.23 13.57,22.75 13.57,21.81 12.9,21.14 12.45,21.14 12.3,20.99 12.3,19.4 12.06,19.15 12.06,18.25 11.61,17.8 11.61,17.59 11.97,17.23 12.61,17.23 v2(12.76,17.39)
  BOTTOM w0.109: UR1.33 13.89,17.03 13.6,17.32 12.83,17.32 v2(12.76,17.39)
SD_1_P1: length 43.4
  TOP w0.109: JSD1.16 10.33,28.47 10.33,28.48 v2(9.55,28.48)
  IN1 w0.102: v2(12.9,14.69) 11.94,14.69 11.5,14.25 11.5,13.94 11.9,13.54 12.9,13.54 13.58,12.86 13.58,11.52 12.76,10.69 11.08,10.69 10.27,11.5 10.27,12.42 9.58,13.11 9.27,13.11 9.12,12.96 9.12,12.29 8.39,11.56 7.2,11.56 6.7,12.05 6.7,14.4 6,15.1 6,20.59 6.68,21.27 6.68,21.49 6,22.17 6,25.98 6.73,26.71 6.73,26.83 6,27.56 6,29.76 6.51,30.27 7.43,30.27 7.98,29.72 7.98,28.58 8.09,28.48 v2(9.55,28.48)
  BOTTOM w0.109: UR1.28 13.79,15.03 13.47,14.71 12.92,14.71 v2(12.9,14.69)
SD_RCOMP_1P8: length 5.8
  TOP w0.109: v2(124.07,46.23) 124,46.3 UH1.BE5
  BOTTOM w0.109: v1(125.04,50.89) 125.04,49.62 RH611.2 123.76,48.34 123.76,47.01 123.88,46.89 123.88,46.41 v2(124.07,46.23)
SD_RCOMP_3P3: length 3.2
  TOP w0.109: v2(123.4,46.64) 123.72,46.96 UH1.BE4
  BOTTOM w0.109: v1(122.3,47.91) 122.53,48.14 RH610.2 123.28,46.77 v2(123.4,46.64)
SDVDD1: length 2.5
  BOTTOM w0.109: 30.62,25.58 30.2,25.58 29.74,25.12 v1(29.74,23.66)
  vias: v2(17.27,11.68) v2(17.32,11.09) v2(30.82,24.83) v2(31.42,24.75)
SDVDD2: length 12.3
  IN2 w1.016: 13.03,23.08 13.03,22.75 14.12,21.66 14.12,18.12 14.6,17.63 14.6,13.72 15.81,12.51 15.81,11.98
  vias: v1(11.87,26.65) v2(12.12,26.17) v2(12.35,26.85) v2(12.75,23.95) v2(13.38,23.95) v2(16.67,11.86) v2(16.69,11.27)
SDWP: length 21.1
  BOTTOM w0.109: UR1.43 17.7,20.85 17.5,21.04 17.5,23.54 17.9,23.94 19.78,23.94 20.07,24.23 21.54,24.23 v1(22.07,24.76) 22.38,25.08 25.15,25.08 25.49,24.73 25.49,24.37 26.54,23.32 30.17,23.32 31.77,21.72 QR1.1
SDWP_Q: length 13.4
  TOP w0.109: v2(32.13,24.65) 32.59,25.1 32.59,28.59 33.16,29.16 33.16,31.57 32.46,32.27 32.46,34.83 32.39,34.9 32.18,34.9 JSD1.18
  BOTTOM w0.109: QR1.3 32.42,24.36 v2(32.13,24.65)
SIM_DET: length 76.1
  BOTTOM w0.109: RZ522.2 131.2,160.23 130.25,159.27 130.25,152.73 128.6,151.08 128.6,142.18 129.86,140.92 139.52,140.92 146.16,134.28 158.4,134.28 159.9,132.78 159.9,129.49 160.98,128.41 162.12,128.41 163.52,127.01 v1(163.52,123.71) 163.52,118.44 162.84,117.76 162.84,116.78 161.49,115.43 JNGFF2.58
SIM_DET_R: length 6.3
  BOTTOM w0.109: v1(130.29,161.84) RZ522.1 130.29,160.57 129.68,159.96 126.87,159.96 126.3,159.39 JSIM1.2
SIO_EXT_SCI#: length 20.7
  TOP w0.109: v2(127.61,35.57) 127.61,36.14 UH1.AU26
  IN1 w0.102: v2(127.61,35.57) 127.61,35.03 127.38,34.8 127.38,34.01 127.63,33.76 127.63,32.73 127.9,32.46 128.22,32.46 128.87,31.82 128.87,29.67 129.22,29.32 129.22,28.79 129.62,28.39 130,28.39 130.5,27.89 130.5,27.38 130.82,27.07 131.71,27.07 131.86,26.91 132.97,26.91 133.29,27.23 133.29,27.9 132.64,28.55 v2(132.64,29.26)
  BOTTOM w0.109: v2(132.64,29.26) 132.64,28.8 132.99,28.45 133.75,28.45 134.18,28.03 134.18,27.95 134.29,27.84 134.3,27.84 134.53,27.61 RC561.1 ; v1(127.95,35.92) 127.87,35.92 127.61,35.65 v2(127.61,35.57) 127.73,35.44 RH339.2
SIO_EXT_SMI#: length 5.2
  TOP w0.102: UH1.AL47 130.82,25.93 131.05,25.7 131.05,25.39 131.56,24.89 131.56,24.13 131.71,23.97 131.71,23.33 131.34,22.96
  TOP w0.109: v1(131.57,21.45) 131.32,21.71 RH310.2 131.32,22.94 131.34,22.96
SIO_EXT_WAKE#: length 34.7
  TOP w0.102: v2(127.46,37.91) 127.46,37.48 UH1.AU24
  TOP w0.109: v1(121.32,66.47) 121.46,66.33 v2(121.85,66.33) 122.63,65.56 RE703.1
  IN1 w0.102: v2(127.46,37.91) 127.46,38.44 126.82,39.08 126.82,40.05 126.19,40.68 125.99,40.68 125.79,40.88 125.79,41.71 124.01,43.49 124.01,45.75 123.7,46.06 123.7,46.4 123.8,46.5 123.8,47.96 123.66,48.1 123.66,52.06 124.18,52.58 124.18,53.59 123.86,53.91 123.86,54.8 122.68,55.98 122.68,61.21 122.12,61.77 122.12,66.07 v2(121.85,66.33)
  BOTTOM w0.109: RH309.2 126.87,37.32 v2(127.46,37.91)
SIO_PWRBTN#: length 231
  TOP w0.109: v2(123.35,26.74) 123.72,26.37 UH1.BE46 ; v2(241.6,11.16) 241.57,11.18 241.57,12.52 240.25,13.85 240.25,14.26 239.26,15.25 237.88,15.25 v1(237.82,15.19) 237.44,14.81 CC269.1 RC241.2 ; UE1.K11 v2(141.21,71.68)
  IN1 w0.102: v2(116.36,72.44) 116.05,72.14 116.05,68.82 116.8,68.07 116.8,67.2 116.44,66.85 116.44,63.18 117.32,62.3 117.32,55.91 118.73,54.5 118.73,51.58 119.94,50.37 119.94,31.13 123.35,27.71 v2(123.35,26.74)
  IN3 w0.081: v2(241.6,11.16) 241.02,10.57 239.86,10.57 235.82,6.53 168.97,6.53 162.77,12.73 160.32,12.73 158.5,14.56 149.83,14.56 149.57,14.29 145.81,14.29 143.91,16.19 136.83,16.19 136.54,16.49 135.42,16.49 135.2,16.27 130.3,16.27 129.9,16.68 129.9,19.41 129.27,20.03 125.17,20.03 124.65,19.51 123.38,19.51 123.14,19.75 123.14,21.4 123.7,21.96 123.7,22.37 124.74,23.42 124.74,24.84 125.19,25.29 125.19,26.52 124.63,27.08 124.63,27.35 124.3,27.68 123.88,27.68 123.35,27.15 v2(123.35,26.74)
  IN4 w0.102: v2(141.21,71.68) 140.8,72.09 140.8,72.66 140.61,72.86 132.8,72.86 132.61,72.67 128.6,72.67 127.57,73.7 126.35,73.7 125.39,72.74 116.65,72.74 v2(116.36,72.44)
  BOTTOM w0.109: JXDP1.41 244.28,13.4 242.04,11.16 v2(241.6,11.16)
SIO_RCIN#: length 5.3
  TOP w0.102: T317.1 119.3,29.24 120.5,29.24 120.99,29.73 121.55,29.73 121.85,30.02 123.15,30.02 123.16,30.04 124.02,30.04 UH1.BE39
SIO_SLP_A#: length 84.3
  TOP w0.102: UH1.BE40 123.84,29.45 123.76,29.37 123.45,29.37 123.37,29.45 122.09,29.45 121.6,28.96 121.31,28.96 v2(121.31,28.97)
  TOP w0.109: v1(142.44,67.62) 142.06,68 v2(142.06,68.15)
  IN1 w0.102: v2(121.31,28.97) 121.31,29.22 119.56,30.97 119.56,50.11 118.27,51.39 118.27,54.1 116.86,55.51 116.86,62.11 115.99,62.99 v2(115.99,67.34)
  IN4 w0.102: v2(142.06,68.15) 141.83,67.92 141.83,67.03 141.62,66.81 141.62,66 140.66,65.04 133.68,65.04 133.38,64.74 129.74,64.74 129.28,65.2 128.02,65.2 127.2,64.38 125.98,64.38 125.68,64.69 125.68,65.15 124.8,66.03 122.8,66.03 122.06,66.76 116.56,66.76 v2(115.99,67.34)
  BOTTOM w0.109: v2(121.31,28.97) 120.58,29.69 RH638.1 120.17,29.69 CH343.1 ; JAPS1.6 110.98,68.51 111.96,68.51 112.36,68.11 113.5,68.11 115.01,66.6 115.82,66.6 116.08,66.86 116.08,67.25 v2(115.99,67.34) ; RE746.2 141.4,68.81 v2(142.06,68.15)
SIO_SLP_LAN#: length 217.1
  TOP w0.102: UH1.BF40 123.48,29.61 123.45,29.64 122.01,29.64 121.71,29.34 121.16,29.34 120.84,29.03 120.84,28.51 120.32,27.98 120.32,27.6 119.35,26.64 v2(118.88,26.64)
  TOP w0.109: RH204.1 115.39,27.08 115.47,27.16 116.67,27.16 RH631.1 117.51,27.31 CH346.1 118.12,27.37 118.27,27.52 118.83,27.52 119,27.36 119,26.75 v2(118.88,26.64)
  IN1 w0.102: v2(143.2,138.89) 142.38,139.71 140.54,139.71 137.04,143.21 128.86,143.21 124.98,147.09 121.68,147.09 114.58,139.99 114.58,122.73 114.34,122.5 114.34,115.72 113.5,114.87 113.5,107.48 113.3,107.28 112.23,107.28 111.16,106.21 111.16,100.15 113.43,97.88 113.43,96.64 114.57,95.5 115.73,95.5 116.34,94.89 116.34,83.87 114.7,82.23 114.7,76.58 v2(115.01,76.28) 114.7,75.97 114.7,75.02 113.31,73.63 113.31,70.9 112.7,70.28 112.7,69.4 113.33,68.77 113.33,68.49 113.86,67.96 113.86,67.26 113.15,66.55 113.15,65.54 112.74,65.13 112.74,63.46 114.08,62.12 114.08,60.85 113.38,60.15 113.38,52.34 114.53,51.2 114.53,48.63 117.09,46.07 117.09,37.9 117.7,37.29 117.7,29.21 118.02,28.9 118.02,27.18 118.56,26.64 v2(118.88,26.64)
  BOTTOM w0.109: RE743.2 116.06,75.22 v2(115.01,76.28) ; v2(143.2,138.89) 143.33,138.76 145.37,138.76 149.25,134.89 158.44,134.89 161.07,132.25 168.84,132.25 170.76,134.17 170.76,141.24 170,142 168.73,142 v1(168.39,141.66) 168.18,141.45 R128.1 168.13,140.26 UZ7.3
SIO_SLP_S0#: length 88.9
  TOP w0.102: v2(122.62,35.39) 123.21,35.39 123.32,35.29 124.09,35.29 124.21,35.17 124.53,35.17 124.57,35.13 UH1.BC28
  TOP w0.109: v2(119.74,65.33) 119.74,64.9 120.23,64.41 120.23,64 120.71,63.52 121.59,63.52 123.53,61.58 RH446.1
  IN1 w0.102: v2(119.74,65.33) 120,65.08 120,62.39 120.09,62.29 120.09,58.27 120.9,57.46 120.9,55.5 121.28,55.12 121.28,52.41 121.62,52.07 121.62,47.42 121.89,47.15 121.89,45.97 122.68,45.19 122.68,42.93 123.06,42.55 123.06,41.24 123.36,40.94 123.36,38.36 123.32,38.32 123.32,36.09 v2(122.62,35.39) 123.11,34.9 123.11,32.99 124.15,31.94 124.15,31.16 124.68,30.63 124.87,30.63 125.21,30.28 128.01,30.28 128.16,30.44 128.56,30.44 128.67,30.32 128.67,29.59 129.03,29.24 129.03,28.44 128.52,27.93 128.52,27.08 129.61,25.99 133.17,25.99 133.49,26.31 133.49,29.22 v2(133.07,29.64)
  IN2 w0.081: v2(143.71,20.46) 143.4,20.46 142.18,21.68 141.35,21.68 v2(140.79,22.24)
  BOTTOM w0.109: RZ363.1 143.91,20.46 v2(143.71,20.46) ; JAPS1.15 112.41,64.02 113.56,65.17 117.49,65.17 117.65,65.33 v2(119.74,65.33) ; v2(140.79,22.24) 140.47,22.57 RZ112.1 139.72,22.62 RZ362.2 v1(138.75,24.61) 136.15,27.21 135.49,27.21 134.97,27.73 134.97,28.87 134.57,29.28 133.44,29.28 v2(133.07,29.64)
SIO_SLP_S3#: length 234
  TOP w0.109: v2(155.98,58.95) 155.61,59.32 153.57,59.32 149.15,63.74 149.15,65.65 148.33,66.46 v2(148.13,66.46) ; UH1.BF42 123.39,28.21 122.97,27.79 122.56,27.79 121.93,27.16 121.65,27.16 121.41,26.92 v2(121.41,26.48) ; RH634.1 111.59,37.44 111.63,37.4 CH341.1 113.01,37 v2(113.64,37.62) ; RT593.1 41.66,55.54 v2(41.29,55.17)
  IN1 w0.102: v2(121.41,26.48) 121.74,26.15 121.74,25.95 121.42,25.63 118.69,25.63 117.29,27.02 114.98,27.02 114.6,27.4 114.6,28.14 114.71,28.25 114.71,28.98 114.96,29.23 114.96,31.72 114.66,32.03 114.66,35.39 114.4,35.65 114.4,36.71 113.64,37.47 v2(113.64,37.62) 113.64,38.65 113.11,39.18 113.11,42.57 112.93,42.75 112.93,50.53 111.5,51.96 111.5,57.16 110.54,58.12 110.54,60.57 110.94,60.97 110.94,61.58 v2(110.49,62.04)
  IN2 w0.081: v2(41.29,55.17) 41.47,55.35 46.17,55.35 47.14,54.38 50.11,54.38 50.56,54.83 52.02,54.83 53.79,53.05 53.79,44.41 51.41,42.03 51.41,39.38 54.68,36.11 64.39,36.11 66.28,38 85.62,38 86.74,39.12 90.16,39.12 91.6,40.55 91.6,42.23 93.75,44.38 93.75,51.01 96.12,53.39 96.95,53.39 101.19,57.64 103.35,57.64 106.6,60.88 109.33,60.88 v2(110.49,62.04) 112.34,63.9 112.79,63.9 114.07,65.18 116.12,65.18 v2(118.7,67.77)
  IN4 w0.102: v2(118.7,67.77) 118.82,67.77 119.52,67.07 119.78,67.07 119.85,67 119.91,67 119.91,66.99 122.16,66.99 122.63,66.52 125.7,66.52 126.49,65.72 129.49,65.72 129.88,66.11 131.44,66.11 131.99,66.66 137,66.66 137.33,66.99 140.59,66.99 v2(140.79,67.2)
  BOTTOM w0.109: v2(41.29,55.17) 40.98,55.17 39.7,53.89 39.7,52.59 UT1.U1 ; UE5.1 155.64,64.49 v1(157.05,63.09) 157.05,61.81 156.82,61.59 156.55,61.59 UE3.2 156.56,61.08 RE280.1 157.75,60.91 156.78,59.94 QE11.2 156.44,59.17 156.2,59.17 v2(155.98,58.95) ; v2(148.13,66.46) 147.61,66.46 147.2,66.05 145.69,66.05 145.06,65.42 142.57,65.42 v2(140.79,67.2) ; v2(118.7,67.77) 118.43,67.77 116.59,69.61 113.97,69.61 113.64,69.94 113.34,69.94 112.76,70.52 JAPS1.2
SIO_SLP_S4#: length 568.4
  TOP w0.109: PR208.1 108.93,13.47 108.49,13.91 v2(108.49,14.11) ; UH1.BE42 123.75,28.24 123.11,27.59 122.64,27.59 122.11,27.05 122.11,27.01 v2(121.87,26.77) ; v2(266.53,5.37) 265.76,4.6 262.77,4.6 262.2,5.17 259.83,5.17 258.94,6.06 258.94,8.99 255.84,12.09 244.61,12.09 241.92,9.4 241.06,9.4 239.57,10.9 v2(238.78,10.9) ; PR401.2 159.46,98.54 158.98,99.02 v1(156.45,99.02) 152.89,99.02 152.39,98.51 152.39,97.37 151.68,96.66 149.91,96.66 v2(149.65,96.92)
  IN1 w0.102: v2(142.01,69.28) 142.29,69.28 142.68,69.67 142.96,69.67 143.98,70.69 143.98,72.87 145.34,74.23 145.34,79.26 148.23,82.16 148.23,96.32 148.83,96.92 v2(149.65,96.92) ; v2(321.22,56.72) 319.89,56.72 317.79,54.62 317.79,49 315.79,46.99 314.15,46.99 313.61,46.45 313.61,39.7 314.68,38.63 v2(314.68,36.95) ; v2(115.49,67.01) 115.49,66.76 115.76,66.49 115.76,61.5 116.01,61.24 116.01,56.04 118.04,54 118.04,51.29 119.37,49.97 119.37,30.89 120.7,29.56 120.7,28.77 121.04,28.42 121.52,28.42 121.98,27.97 121.98,26.88 v2(121.87,26.77)
  IN2 w0.081: v2(152.53,17.4) 154.48,17.4 165.12,6.76 v2(165.12,1.42) ; v2(121.87,26.77) 121.84,26.75 121.84,26.27 121.69,26.12 121.69,25.63 118.18,22.13 118.18,21.07 116.78,19.66 112.6,19.66 112.09,19.15 111.34,19.15 111.05,18.86 110.77,18.86 110.51,18.6 110.51,17.81 109.76,17.06 109.38,17.06 108.82,16.5 108.82,14.44 v2(108.49,14.11)
  IN3 w0.081: v2(112.47,1.67) 117.21,1.67 119.71,4.17 124.62,4.17 127.57,1.22 164.92,1.22 v2(165.12,1.42) ; v2(282.29,75.16) 282.73,74.73 286,74.73 286.7,75.43 302.07,75.43 302.54,74.96 305.01,74.96 308.02,71.95 309.78,71.95 311.68,70.04 311.68,65.28 314.55,62.41 316,62.41 321,57.41 321,56.93 v2(321.22,56.72)
  IN3 w0.102: v2(165.12,1.42) 165.66,1.96 166.35,1.96 166.88,1.42 244.64,1.42 248.74,5.52 252.55,5.52 255.52,2.55 264.87,2.55 266.53,4.22 v2(266.53,5.37)
  IN4 w0.102: v2(108.49,14.11) 108.42,14.04 108.42,11.94 110.06,10.3 110.06,6.49 112.47,4.08 v2(112.47,1.67) ; v2(142.01,69.28) 142.47,68.82 142.47,67.34 141.84,66.72 141.84,65.9 140.75,64.81 137.36,64.81 136.7,64.15 125.89,64.15 125.45,64.59 125.45,65.06 124.71,65.8 120.51,65.8 119.77,66.54 115.96,66.54 v2(115.49,67.01) ; v2(238.78,10.9) 238.79,10.9 238.96,11.07 238.96,12.37 240.16,13.57 240.16,13.95 240.26,14.05 240.26,17.03 241,17.78 241.98,17.78 242.9,18.7 247.24,18.7 247.8,18.14 256.6,18.14 257.72,17.03 257.96,17.03 258.81,16.18 261.55,16.18 262.63,15.1 269.51,15.1 270.51,16.1 ; v2(314.68,36.95) 313.76,36.04 313.76,34.2 312.1,32.54 310.35,32.54 304.85,27.04
  IN4 w0.109: 270.51,16.1 270.51,19.04 273.54,22.07 285.74,22.07 286.8,23.14 288.8,23.14 289.48,23.83 301.63,23.83 302.6,24.8 302.6,24.8 304.85,27.04
  BOTTOM w0.109: v2(152.53,17.4) 151.5,18.43 150.96,18.43 150.66,18.13 UZ34.2 ; RH635.1 109.32,13.36 CH342.1 108.62,13.98 v2(108.49,14.11) ; UZ21.4 277.37,71.41 277.73,71.05 280.35,71.05 282.29,72.99 v2(282.29,75.16) ; JAPS1.5 111.79,69.02 112.46,68.34 114.16,68.34 v2(115.49,67.01)
SIO_SLP_S5#: length 54.1
  TOP w0.102: v2(122.09,28.39) 122.54,28.84 122.66,28.84 122.69,28.87 123.1,28.87 123.13,28.84 123.17,28.84 123.34,28.68 124.11,28.68 124.23,28.56 124.83,28.56 UH1.BC42
  IN1 w0.102: v2(116.39,67.78) 116.52,67.66 116.52,67.25 116.22,66.94 116.22,63.08 117.09,62.21 117.09,55.6 118.5,54.19 118.5,51.48 119.75,50.24 119.75,31.05 122.09,28.71 v2(122.09,28.39)
  BOTTOM w0.109: v2(116.39,67.78) 115.41,68.77 113.34,68.77 112.59,69.52 JAPS1.4 ; CH347.1 121.89,29.69 RH632.1 122.15,28.45 v2(122.09,28.39) 121.28,28.39 v1(121.21,28.46)
SIO_SLP_SUS#: length 74.5
  TOP w0.102: 121.07,29.53 121.63,29.53 121.93,29.83 123.47,29.83 123.47,29.84 123.8,29.84 123.92,29.72 124.27,29.72 UH1.BD39
  TOP w0.109: v2(130.74,62.63) 130.74,62.95 132.26,64.47 v1(133.06,64.47) 133.64,64.47 134.51,65.34 134.52,65.34 135.07,65.89 135.07,66.16 RE349.1 ; v2(118.41,27.92) 118.55,27.78 118.64,27.78 118.68,27.74 119.64,27.74 119.91,28.01 RH441.1 120.22,28.16 120.65,28.59 120.65,29.11 121.07,29.53
  IN1 w0.102: v2(118.41,27.92) 118.43,27.94 118.43,28.13 118.79,28.49 118.79,49.57 117.36,51.01 117.36,53.72 115.95,55.13 115.2,55.13 114.48,55.85 114.48,58.64 115.07,59.24 115.07,62.78 v2(113.93,63.92)
  IN4 w0.102: v2(113.93,63.92) 114.59,63.92 115.31,64.64 123.92,64.64 126.26,62.3 128.16,62.3 128.53,61.93 130.11,61.93 130.74,62.56 v2(130.74,62.63)
  BOTTOM w0.109: RH639.1 117.16,29.44 CH345.1 118.41,28.18 v2(118.41,27.92)
SIO_SLP_SUS#_R: length 4.1
  TOP w0.109: RE349.2 135.38,67.66 v2(134.82,68.22) 134.82,69.23 UE1.N4
  BOTTOM w0.109: RE561.1 134.52,67.92 v2(134.82,68.22) 135.23,68.22 v1(135.44,68.01)
SIO_SLP_WLAN#: length 177.1
  TOP w0.102: UH1.BD42 124.2,28.32 124.03,28.48 123.26,28.48 123.13,28.61 123.09,28.61 123.02,28.68 122.77,28.68 122.7,28.61 122.7,28.61 122.62,28.53 122.62,28.4 121.78,27.55 121.07,27.55 120.95,27.67 120.95,27.8 v2(120.94,27.81)
  TOP w0.109: v2(108,88.97) 107.54,88.51 107.54,87.75 107.17,87.38 107.17,85.9 108.85,84.22 108.85,82.96 106.47,80.58 105.73,80.58 103.05,77.89 103.05,75.93 105.69,73.29 109.53,73.29 111.28,71.54 112.06,71.54 112.69,72.17 v2(113.95,72.17) ; v2(107.49,96.82) 107.27,97.04 107.27,107.68 108.66,109.07 110.18,109.07 111.17,110.06 117.64,110.06 118.32,109.37 121.49,109.37 121.96,109.84 123.48,109.84 124.97,108.36 130.71,108.36 131.55,107.52 134.54,107.52 135.31,106.74 135.31,104.62 136.22,103.7 141.83,103.7 142.61,102.92 142.61,102.08 144.67,100.02 QZ15.1 145.31,99.95 145.31,97.88 144.92,97.49 144.68,97.49 144.53,97.34 144.53,96.43 149.35,91.61 v1(149.35,90.75) 153.11,86.99 RE569.1
  IN1 w0.102: v2(113.95,72.17) 113.95,71.62 114.56,71.01 114.56,68.66 114.85,68.37 114.85,66.75 115.3,66.3 115.3,59.14 114.71,58.55 114.71,55.95 115.29,55.36 116.04,55.36 117.59,53.81 117.59,51.1 118.98,49.71 118.98,28.55 119.72,27.81 v2(120.94,27.81)
  IN2 w0.081: v2(107.49,96.82) 107.49,96.79 108.29,95.99 111.29,95.99 112.42,94.86 112.42,91.73 110.83,90.15 109.38,90.15 108.2,88.97 v2(108,88.97)
  BOTTOM w0.109: v2(120.94,27.81) 119.12,27.81 117.83,29.1 117.83,30.46 CH344.1 117.4,30.89 RH629.1
SIO_SLP_WLAN#_Q: length 5.5
  TOP w0.109: v1(148.6,96.53) 148.54,96.47 147.18,96.47 146.71,96.94 RZ71.1 RZ1385.2 145.88,96.97 QZ15.3 147.23,98.13 DZ9.3
SKL_CNL#: length 7.9
  TOP w0.109: v1(226.79,24.02) RC171.2 228.67,24.73 228.67,26.68 231.33,29.34 UC1.BN1
SLEEVE: length 10.4
  IN2 w1.016: 389.07,16.88 388.77,17.19 388.77,19.62 389.53,20.39 389.53,22.94 388.55,23.92 386.99,23.92
  BOTTOM w0.381: v2(385.72,23.23) 385.66,23.29 RA6.2
  vias: v1(388.57,16.35) v2(386.17,23.62) v2(388.39,15.71) v2(388.92,15.97)
SLEEVE_R: length 17.4
  TOP w0.109: v4(394.79,14.77) 394.79,14.9 v2(394.28,15.41)
  IN1 w1.016: 395.32,15.92 397.79,15.92 399.74,17.87 399.74,19.17 401.97,21.39 404.07,21.39 406.45,19.01 JHP1.4
  vias: v2(390.83,16.86) v2(391.34,16.56) v2(393.59,15.41)
SLOT3_DEVSLP: length 269.1
  TOP w0.109: v2(131.74,31.65) 132.03,31.94 UH1.AH35
  IN3 w0.081: v2(307.02,4.84) 303.31,4.84 301.22,2.75 277.55,2.75 274.54,5.75 268.84,5.75 265.78,8.82 256.61,8.82 255.09,10.33 246.03,10.33 241.36,5.67 168.64,5.67 163.53,10.77 157.28,10.77 156.44,11.61 153.66,11.61 152.81,10.77 150.1,10.77 148.91,11.95 142.01,11.95 140.36,13.6 137.25,13.6 136.58,12.94 134.21,12.94 133.74,13.4 132.08,13.4 129.91,15.57 124.16,15.57 121.8,17.92 121.8,18.77 120.68,19.9 120.68,20.46 121.79,21.57 121.79,23.21 121.56,23.43 121.56,24.41 122.77,25.62 122.77,27.22 123.96,28.41 124.99,28.41 125.8,29.22 125.8,29.69 126.11,30 127.71,30 128.15,30.44 128.42,30.44 128.63,30.65 129.87,30.65 129.97,30.75 129.97,31.23 130.22,31.49 131.57,31.49 v2(131.74,31.65)
  BOTTOM w0.109: JNGFF3.38 327.97,22.79 328.13,22.95 RN37.1 329.23,22.28 328.29,21.34 328.29,17.36 327.38,16.45 318.42,16.45 317.43,17.44 v1(314.5,17.44) 313.08,17.44 312.78,17.73 310.98,17.73 310.5,18.21 304.07,18.21 303.29,17.43 303.29,12.17 306.6,8.85 306.6,5.26 v2(307.02,4.84)
SLOT3_SSD_PWR_EN: length 263.7
  TOP w0.109: UE1.G5 v2(135.67,74.08) ; UZ9.3 334.74,19.43 334.95,19.22 v2(334.95,19.09)
  IN2 w0.081: v2(135.67,74.08) 136.07,73.67 136.66,73.67 136.85,73.48 136.85,69.99 137.93,68.91 137.93,67.24 138.19,66.98 140.14,66.98 142.98,64.14 147.58,64.14 149.62,62.1 150.33,62.1 151.55,60.89 151.55,59.8 153.36,57.99 159,57.99 162.31,54.68 162.31,53.09 163.75,51.65 164.23,51.65 164.85,51.03 164.85,50.84 165.33,50.36 165.52,50.36 166.46,49.42 166.95,49.42 v2(167.42,48.95)
  IN3 w0.081: v2(167.42,48.95) 167.38,48.92 167.38,42.37 167.69,42.06 167.69,39.93 168.59,39.03 168.59,25.65 169.08,25.16 169.08,17.04 171.81,14.31 173.88,14.31 175.6,12.58 199.64,12.58 200.81,13.76 228.69,13.76 232.96,18.02 237.73,18.02 238.62,18.91 239.81,18.91 242.15,21.26 259.29,21.26 262.77,17.78 266.84,17.78 271.75,12.87 278.34,12.87 279.38,11.83 297.15,11.83 298.24,12.92 307.09,12.92 307.79,13.63 314.62,13.63 321.8,20.8 327.48,20.8 328.01,20.27 330.35,20.27 330.86,20.78 333.34,20.78 334.63,19.49 334.63,19.4 v2(334.95,19.09)
  BOTTOM w0.109: RZ539.1 v1(334.08,19.96) v2(334.95,19.09)
SLOT4_DEVSLP: length 286.8
  TOP w0.109: v2(129.87,24.05) 129.52,24.05 129.07,24.5 129.07,25.23 128.95,25.35 128.95,25.71 UH1.AR47
  IN2 w0.081: v2(129.87,24.05) 129.87,23.99 127.96,22.09 127.96,20.86 128.61,20.21 129.46,20.21 130.04,19.63 130.04,17.37 130.59,16.82 132.76,16.82 v2(133.07,17.13)
  IN4 w0.102: v2(365.08,13.99) 365.08,14.13 364.82,14.39 364.26,14.39 363.99,14.12 363.99,13.82 363.62,13.46 363.62,12.08 353.97,2.43 334.26,2.43 333.35,1.51 319.53,1.51 319.12,1.92 306.94,1.92 306.21,1.18 255.5,1.18 251.16,5.52 248.68,5.52 244.23,1.07 167.48,1.07 166.13,2.42 156.22,2.42 146.99,11.65 146.99,13.36 147.62,14 147.62,15.61 147.09,16.15 145.57,16.15 144.03,17.69 137.55,17.69 137.12,17.26 135.43,17.26 134.9,16.73 133.47,16.73 v2(133.07,17.13)
  BOTTOM w0.076: JNGFF4.38 375,8.66 374.68,8.98 373.58,8.98
  BOTTOM w0.109: v2(365.08,13.99) 365.02,13.93 365.02,13.25 RN202.1 365.85,13.22 367.12,14.49 v1(369.33,14.49) 369.77,14.49 370.19,14.07 370.19,12.17 369.57,11.55 369.57,9.51 370.1,8.98 373.58,8.98
SLOT4_SSD_PWR_EN: length 286.3
  TOP w0.109: UE1.K3 v2(134.04,71.65)
  IN2 w0.081: v2(165.28,49.91) 164.57,50.62 164.57,50.89 164.04,51.42 163.65,51.42 162.08,52.99 162.08,54.59 158.89,57.78 153.27,57.78 151.34,59.71 151.34,60.8 150.25,61.89 149.53,61.89 147.49,63.93 142.9,63.93 140.06,66.78 133.4,66.78 133.11,67.07 133.11,68.79 133.74,69.42 133.74,70.12 133.55,70.31 133.55,71.13 134.04,71.62 v2(134.04,71.65)
  IN3 w0.081: v2(342.67,14.82) 342.44,14.82 342.28,14.99 333.58,14.99 332.34,16.22 319.88,16.22 314.87,11.21 310.95,11.21 310.54,10.8 301.01,10.8 300.38,10.17 278.5,10.17 277.46,11.22 271.07,11.22 266.65,15.64 263.77,15.64 263.28,16.13 261.83,16.13 260.43,17.52 256.6,17.52 256.4,17.31 245.75,17.31 245.59,17.14 244.38,17.14 243.69,16.45 240.24,16.45 240.17,16.38 233.74,16.38 229.27,11.91 215.71,11.91 214.72,10.92 175.03,10.92 173.63,12.32 171.02,12.32 166.97,16.37 166.97,22.03 165.81,23.19 165.81,26.28 166.67,27.14 166.67,35 163.06,38.61 163.06,46.81 164.63,48.38 164.63,49.13 165.21,49.71 165.21,49.84 v2(165.28,49.91)
  BOTTOM w0.109: RZ537.1 130.43,73.27 130.43,71.85 131.16,71.11 131.54,71.11 131.8,71.37 132.12,71.37 132.27,71.22 133.38,71.22 133.81,71.65 v2(134.04,71.65) ; UZ58.3 v1(349.82,12.83) 349.67,12.68 347.74,12.68 346.63,13.78 343.71,13.78 v2(342.67,14.82)
SLOT5_SSD_PWR_EN: length 261.9
  TOP w0.109: v2(335.15,20.18) 335.11,20.23 UZ9.5
  IN2 w0.081: v2(157.43,77.54) 158.18,78.29 160.51,78.29 160.98,77.82 164.56,77.82 165.96,76.42 167.82,76.42 169.9,74.34 169.9,66.03 168.93,65.06 167.03,65.06 163.47,61.51 163.47,57.78 167.72,53.53 v2(167.76,53.53)
  IN3 w0.081: v2(167.76,53.53) 167.17,52.94 167.17,52.56 168,51.72 168,48.14 167.84,47.98 167.84,45.76 168.37,45.23 168.37,41.67 167.98,41.27 167.98,40.22 169,39.19 169,25.94 169.67,25.27 169.67,17 170.96,15.71 172.78,15.71 175.67,12.81 199.35,12.81 200.53,14 228.61,14 232.84,18.23 237.63,18.23 238.54,19.14 239.67,19.14 242.02,21.49 259.62,21.49 263.1,18.01 266.94,18.01 271.85,13.1 278.47,13.1 279.52,12.05 296.95,12.05 298.04,13.15 302.61,13.15 303.46,13.99 314.66,13.99 321.9,21.23 334.11,21.23 v2(335.15,20.18)
  BOTTOM w0.109: UE12.22 157.98,77.06 157.5,77.54 v2(157.43,77.54) ; RZ538.1 334.87,20.46 v2(335.15,20.18)
SLOT6_DEVSLP: length 90.9
  TOP w0.109: v2(131.34,23.5) 131.36,23.53 131.36,24.7 130.82,25.24 UH1.AL48
  IN1 w0.102: v2(117.4,79.85) 116.66,79.11 116.66,75.68 116.52,75.54 116.52,73.53 117.49,72.56 117.49,68.6 117.61,68.47 117.61,66.87 117.26,66.51 117.26,63.51 118.13,62.64 118.13,56.94 118.65,56.42 119.05,56.42 119.61,55.86 119.61,55.15 120.14,54.62 120.14,54.29 119.56,53.7 119.56,51.35 120.32,50.59 120.32,38.59 120.72,38.18 120.72,37.21 121.31,36.62 121.31,36.41 120.32,35.42 120.32,31.29 123.47,28.13 125.1,28.13 125.95,27.29 125.95,26.36 126.54,25.77 127.09,25.77 127.54,25.32 131.12,25.32 131.75,24.68 131.75,23.79 131.46,23.5 v2(131.34,23.5)
  IN4 w0.102: v2(130.58,86.55) 130.27,86.25 123.82,86.25 117.42,79.85 v2(117.4,79.85)
  BOTTOM w0.109: v2(130.58,86.55) 129.99,87.13 RN210.1 130.04,87.58 JNGFF6.38 ; v2(117.4,79.85) v1(117.4,79.29)
SLOT6_SSD_PWR_EN: length 46.5
  TOP w0.109: v2(161.62,78.25) 160.22,76.85 156.41,76.85 155.67,77.59 151.46,77.59 v1(150.66,76.79) 150.04,76.16 149.25,76.16 v2(148.87,76.55)
  IN4 w0.102: v2(148.87,76.55) 147.95,77.46 147.95,77.64 145.95,79.64 145.95,80.53 145.29,81.19 143.3,81.19 142.89,81.61 133.31,81.61 132.57,82.36 130.61,82.36 129.53,83.44 128.59,83.44 128.08,82.93 128.08,81.14 127.56,80.63 v2(127.56,80.26)
  BOTTOM w0.109: v2(161.62,78.25) 161.57,78.3 RZ540.1 160.86,77.8 160.35,77.29 159.9,77.29 159.33,76.72 UE12.25 ; UZ59.3 127.33,80.49 v2(127.56,80.26)
SLP_WLAN#_GATE: length 16.9
  TOP w0.109: RE570.1 RE552.2 151.58,88.05 v1(150.76,88.87) 147.88,91.75 147.88,92.74 144.3,96.33 144.3,97.44 144.58,97.73 QZ15.2 144.58,98.38 RZ375.2
SLP_WLAN#_GATE_R: length 23.1
  TOP w0.109: RE570.2 RE569.2 153.11,84.72 152.6,84.22 152.6,80.46 v2(149.58,77.43) ; UE1.D9 v2(139.61,77.22)
  BOTTOM w0.102: v2(139.61,77.22) 139.98,76.85 141.41,76.85
  BOTTOM w0.109: v2(149.58,77.43) 149.2,77.05 148.68,77.05 148.07,76.44 v1(147.84,76.44) 147.47,76.44 145.87,78.04 142.61,78.04 141.41,76.85
SMART_SPK_DET0#: length 272.2
  TOP w0.109: v4(339.74,9.66) RA224.2 v2(341.82,9.66) JSPK1.5 ; UH1.AV13 127.45,42.71 v2(127.22,42.94)
  IN3 w0.081: v2(127.22,42.94) 125.93,42.94 123.9,40.91 123.9,39.49 125.02,38.37 125.28,38.37 125.42,38.23 125.42,37.39 125.28,37.25 124.94,37.25 123.85,36.16 123.85,35.55 122.02,33.72 120.64,33.72 120.11,33.2 120.11,32.12 120.89,31.35 120.89,28.48 120.44,28.03 120.44,25.17 119.73,24.46 119.73,21.15 119.65,21.06 119.65,18.55 123.46,14.74 128.67,14.74 130.92,12.49 133.36,12.49 133.96,11.89 140.78,11.89 141.63,11.04 148.17,11.04 149.36,9.85 163.16,9.85 168.26,4.75 241.79,4.75 246.46,9.42 254.71,9.42 256.23,7.9 265.4,7.9 268.56,4.75 274.1,4.75 277.1,1.75 301.52,1.75 303.08,3.32 305.78,3.32 306.39,3.93 308.12,3.93 308.66,4.47 310.07,4.47 311.79,6.19 317.96,6.19 322.16,10.38 338.48,10.38 338.86,10 341.48,10 v2(341.82,9.66)
