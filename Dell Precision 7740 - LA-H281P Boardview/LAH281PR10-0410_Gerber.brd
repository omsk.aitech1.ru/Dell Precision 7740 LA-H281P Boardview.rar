# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N65693710: length 6.1
  TOP w0.254: UT9.12 38.72,27.13 v2(38.13,27.72)
  BOTTOM w0.254: v2(38.13,27.72) 37.46,27.06 35.99,27.06 35.43,26.51 35.43,26.19 v1(35.82,25.8) 35.91,25.71 RT571.2
N65693770: length 2.1
  TOP w0.254: UT9.10 39.72,27.62 v2(39.74,27.64)
  BOTTOM w0.33: CT378.2 39.23,27.04 39.27,27.04 39.74,27.51 v2(39.74,27.64)
N65693929: length 1.3
  TOP w0.254: v2(40.6,26.62) 40.6,26.15 40.64,26.11 UT9.9
  BOTTOM w0.381: RT573.2 40.42,26.44 v2(40.6,26.62)
N65694167: length 3
  BOTTOM w0.109: RT565.2 28.41,27.8 v1(28.27,27.94)
  BOTTOM w0.508: QT6.1 30.35,28.73 RT565.2
N65694171: length 2
  BOTTOM w0.508: RT566.2 33.74,28.65 33.21,29.19 QT7.1
N65694331: length 2.8
  BOTTOM w0.109: RT580.1 22.08,28.35 22.08,29.3 21.04,30.35 UT5.A8
N65694363: length 3
  BOTTOM w0.109: UT5.A9 21.54,30.39 22.45,29.47 22.45,29.1 23.21,28.35 RT579.1
N65694436: length 9.2
  TOP w0.109: UT11.2 44.02,22.41 v2(44.13,22.29)
  BOTTOM w0.109: UT12.4 44.95,25.68 45.16,25.48 45.16,24.86 45.76,24.26 46.05,24.26 46.61,23.7 46.61,23.08 45.81,22.28 v1(45.81,22.01) 45.81,21.86 45.15,21.2 44.87,21.2 44.51,21.55 44.51,22.02 44.24,22.29 v2(44.13,22.29)
N65694446: length 3.5
  TOP w0.109: UT11.5 46.93,23.96 47.21,24.24 v2(47.21,24.35)
  BOTTOM w0.109: v1(47.47,22.58) 47.6,22.71 CT379.1 47.6,23.59 47.21,23.97 v2(47.21,24.35)
N65694464: length 1.9
  TOP w0.305: UT11.12 44.02,27.69 v2(43.74,27.97)
  BOTTOM w0.305: v2(43.74,27.97) RT575.2
N65694480: length 2.1
  TOP w0.305: v2(45.07,28.08) 45.07,27.74 45.02,27.68 UT11.10
  BOTTOM w0.305: v2(45.07,28.08) CT380.2
N65694514: length 3.8
  TOP w0.109: v2(46.33,26.86) 45.94,26.48 UT11.9
  BOTTOM w0.109: v2(46.33,26.86) 46.33,26.65 RT577.2 45.73,26.16 45.48,25.91 45.48,25.05 v1(45.81,24.72)
N65695146: length 1.7
  BOTTOM w0.109: UT5.J11 22.78,34.68 22.9,34.8 23.39,34.8 RT581.2
N65695150: length 1.6
  BOTTOM w0.109: UT5.H11 22.96,34.6 23.77,34.6 RT582.2
N65695262: length 5.1
  BOTTOM w0.076: 21.94,30.32 21.78,30.47 21.78,30.92 UT5.B10
  BOTTOM w0.203: CT348.2 23.95,27.73 23.58,28.1 23.58,28.61 23.48,28.72 23.17,28.72 22.72,29.16 22.72,29.53 21.94,30.32
N65698424: length 11.7
  TOP w0.109: JKBTP1.11 18.34,2.08 19.2,1.22 26.85,1.22 v2(27.52,1.89) 28,2.38 RZ1484.1
N65699658: length 3.1
  BOTTOM w0.109: RZ371.1 126.52,115.37 v1(126.52,114.52) 126.5,114.51 JNGFF1.56
N65899662: length 3.5
  TOP w0.254: QZ3.1 388.25,11.38 v2(388.25,10.94)
  BOTTOM w0.109: v1(389.3,10.48) 388.71,10.48 v2(388.25,10.94)
  BOTTOM w0.254: RZ25.1 388.17,11.01 v2(388.25,10.94)
N66179590: length 1.5
  TOP w0.254: v2(289.33,53.82) 289.25,53.9 PU1200.17
  BOTTOM w0.254: v2(289.33,53.82) 289.79,53.37 PR1216.2
N66179919: length 2
  TOP w0.109: v2(288.74,53.82) 288.74,53.37 v1(288.68,53.3)
  TOP w0.254: PU1200.16 288.74,54.48 v2(288.74,53.82)
  BOTTOM w0.254: v2(288.74,53.82) 288.29,53.37 PR1217.2
N66180146: length 1.6
  TOP w0.254: v2(289.09,42.92) 288.85,43.16 PU1201.16
  BOTTOM w0.254: v2(289.09,42.92) 289,43.01 PR1219.2
N66180155: length 1.6
  TOP w0.254: v2(289.7,42.92) 289.7,42.99 289.35,43.34 PU1201.17
  BOTTOM w0.254: PR1218.2 289.76,42.98 v2(289.7,42.92)
N66180292: length 3.2
  TOP w0.254: PU1202.16 288.85,33.79 289.29,33.35 289.56,33.35 v2(289.61,33.3)
  BOTTOM w0.254: v2(289.61,33.3) 289.53,33.23 288.49,33.23 288,33.72 PR1221.2
N66180301: length 2.7
  TOP w0.109: v1(290.15,33.14) 290.15,33.44 289.86,33.74 v2(289.86,34.02)
  TOP w0.254: PU1202.17 289.85,34.01 v2(289.86,34.02)
  BOTTOM w0.254: PR1220.2 289.68,33.84 v2(289.86,34.02)
N66180583: length 1.6
  TOP w0.254: PU1203.16 288.83,22.42 v2(289.06,22.18)
  BOTTOM w0.254: PR1223.2 288.74,22.5 v2(289.06,22.18)
N66180592: length 1.7
  TOP w0.254: v2(289.76,22.18) 289.76,22.37 289.33,22.8 PU1203.17
  BOTTOM w0.254: PR1222.2 289.51,22.43 v2(289.76,22.18)
N66458439: length 2.7
  BOTTOM w0.109: QV23.2 136.98,136.02 RV908.1 RV907.2 v1(137.09,134.18)
N66458510: length 4.4
  BOTTOM w0.109: QV23.5 136.98,138.34 137.17,138.15 137.45,138.15 137.63,138.33 QV23.6 137.63,139.16 137.88,139.41 138.18,139.41 RV909.2 139.56,138.9 v1(139.69,138.78)
N66496263: length 7.4
  BOTTOM w0.109: QZ1.2 135.44,129.86 136.41,130.82 CV954.1 136.41,132.03 v1(134.97,133.47) RZ545.2
N66582754: length 3
  TOP w0.109: v1(140.78,138.83) RV5.2 140.78,137.87
  TOP w0.254: QV2.1 139.58,136.98 140.47,137.87 140.78,137.87
N67018687: length 2.3
  BOTTOM w0.109: T46.1 183.55,57.98 JDIMM1.162
N67018696: length 2.5
  BOTTOM w0.109: JDIMM1.165 171.94,58.73 T47.1
N67019568: length 1.8
  BOTTOM w0.109: CD25.2 v1(169.41,59.61)
  BOTTOM w0.254: RD12.1 CD25.2
N67027606: length 1.9
  BOTTOM w0.508: RD36.2 205.54,58.5 RD37.1 RD34.2
N67027671: length 1.9
  BOTTOM w0.109: RD33.1 207.07,55.53 v1(207.33,55.27)
  BOTTOM w0.254: CD87.2 RD33.1
N67554963: length 4.7
  BOTTOM w0.109: QN1.6 305.68,21.92 305.83,21.78 305.83,21.42 305.69,21.27 QN1.5 304.32,21.27 303.96,20.92 RN2.2 v1(302.28,20.92)
N67733464: length 4.1
  BOTTOM w0.109: RV821.2 281.53,78.01 v1(281.53,78.82) 281.43,78.92 280.88,78.92 280.73,78.77 UV68.4 279.77,78.77 279.39,79.15 UV60.1
N67733473: length 5.1
  BOTTOM w0.109: RV820.2 279.82,76.11 UV69.4 ; RV820.2 278.6,76.47 v1(278.33,76.2) ; RV820.2 279.46,76.84 279.14,77.15 279.14,77.88 278.9,78.12 UV68.2
N67734272: length 3.9
  TOP w0.109: v1(167.76,122.29) DV39.2 166.36,124.81 UV65.4
N67938551: length 4.7
  TOP w0.109: RZ381.2 v1(137.6,102.44) 138.32,101.72 138.32,101.11 138.14,100.93 QZ18.6 137.42,100.93 137.3,100.8 137.3,100.41 137.42,100.28 QZ18.5
N67938583: length 4.7
  TOP w0.109: v1(135.53,95.82) 135.63,95.72 RZ377.2 136.85,95.98 136.85,96.73 136.68,96.9 QZ17.6 135.58,96.9 135.47,97.01 135.47,97.38 135.65,97.55 QZ17.5
N69335317: length 7
  TOP w0.109: QH7.2 116.32,22.14 116.66,21.8 117.27,21.8 RH433.1 117.61,22.2 117.23,22.58 117.23,22.89 RH432.2 116.86,23.43 116.51,23.79 CH340.1 116.37,24.31 v1(116.37,25.29)
N69765028: length 1.9
  TOP w0.109: QV44.1 169.32,107.61 RV742.1 169.62,106.53 v1(169.75,106.4)
N69765114: length 4.3
  TOP w0.109: v1(164.73,110.07) 164.68,110.02 164.68,109.43 RV741.1 165.63,109.57 166.17,109.57 166.41,109.33 166.41,108.46 166.61,108.26 QV44.5
N70483327: length 2.8
  TOP w0.109: v1(113.18,60.99) 113.52,60.99 113.76,61.23 114.36,61.23 114.6,61.47 RT499.2 114.68,61.69 UT34.1

## Copper pours and planes (outline as drawn)
+0.6V_DDR_VTT on TOP (solid shape): 177.59,91.34 177.59,86.73 175.09,84.23 175.09,83.6 175.04,83.55 175.04,82.09 174.64,81.69 174.59,81.69 174.57,81.7 174.49,81.75 174.39,81.76 172.95,81.76 172.87,81.76 172.75,81.88 172.75,82.11 172.84,82.2 174.34,82.2 174.35,82.2 174.39,82.2 174.63,82.34 174.64,82.61 174.64,82.63 174.64,84.05 174.34,84.34 174.34,86.67 175.65,87.97 175.65,88.18 175.96,88.49 175.96,90.86 176.61,91.51 177.42,91.51
+0.6V_DDR_VTT on TOP (solid shape): 184.64,93.53 184.67,93.53 184.71,93.49 201.2,93.49 203.53,91.16 203.53,87.08 202.24,85.79 200.73,85.79 199.83,84.89 199.83,82.52 200.44,81.91 200.44,80.58 200.28,80.42 199.27,80.42 198.72,80.97 198.72,81.62 198.71,81.62 198.71,84.98 200.76,87.03 202.03,87.03 202.44,87.44 202.44,90.41 200.75,92.11 190.57,92.11 189.6,91.15 189.6,90.12 189.9,89.82 189.9,89.26 188.8,88.15 188.8,85.69 187.43,84.33 187.43,83.89 186.48,82.94 186.48,82.68 186.39,82.48 186.47,82.28 186.48,82.27 186.48,82.26 186.58,82.15 188.18,82.15 188.28,82.05 188.28,81.89 188.22,81.82 186.47,81.82 186.4,81.76 185.55,81.76 185.23,82.08 185.23,83.26 184.71,83.79 184.71,85.62 185.73,86.65 185.73,90.08 185.79,90.13 188.45,90.13 188.64,90.33 188.64,90.34 188.68,90.37 188.68,91.78 188.37,92.09 184.62,92.09 184.62,92.09 184.35,92.09 182.37,94.07 177.84,94.07 177.36,94.55 177.36,95.23 177.81,95.69 182.48,95.69
+0.6V_DDR_VTT on TOP (solid shape): outline of 125 points within 116.89,11.44 122.81,15.58
+0.6V_DDR_VTT on TOP (solid shape): outline of 259 points within 143.64,12.73 165.83,40.25
+0.6V_DDR_VTT on BOTTOM (solid shape): 194.83,82.2 194.87,82.2 196.32,82.2 196.36,82.2 196.41,82.21 199.09,82.21 200.86,80.45 201.67,80.45 201.67,80.44 203.66,80.44 203.89,80.22 203.89,78.56 203.77,78.44 202.76,78.44 202.65,78.55 200.94,78.55 200.92,78.57 200.92,79.29 200.02,80.2 199.55,80.2 198.02,81.72 196.45,81.72 196.38,81.75 196.32,81.75 194.87,81.75 194.8,81.75 194.74,81.72 194.73,81.72 194.6,81.86 194.6,82.1 194.72,82.21 194.77,82.21
+0.6V_DDR_VTT on BOTTOM (solid shape): outline of 85 points within 173.61,86.99 180.21,95.37
+0.6V_DDR_VTT on IN1 (solid shape): 177.33,87.95 177.33,85.31 176.57,84.54 176.21,84.54 174.96,85.79 174.96,87.33 175.79,88.15 177.13,88.15
+0.6V_DDR_VTT on IN1 (solid shape): 144.79,13.8 144.79,11.91 144,11.12 143.58,11.12 142.85,11.85 142.85,12.05 143.47,12.67 143.47,13.88 143.67,14.08 144.5,14.08
+0.6V_DDR_VTT on IN1 (solid shape): 124.94,11.75 124.94,10.71 124.8,10.57 121.99,10.57 121.12,11.44 121.12,12.06 121.27,12.21 124.48,12.21
+0.6V_DDR_VTT on IN1 (solid shape): outline of 1052 points within 163.21,38.95 174.8,61.85
+0.6V_P on TOP (solid shape): 116.2,16.98 116.18,16.93 116.24,16.52 116.66,16.46 116.7,16.48 116.77,16.4 116.77,14.55 116.79,14.53 117.31,14.53 117.32,14.52 117.32,14.33 117.31,14.31 116.82,14.31 116.81,14.31 116.78,14.31 116.78,14.27 116.77,14.27 116.77,13.92 116.75,13.9 116.5,13.9 116.34,14.09 116.1,14.14 115.59,14.14 115.53,14.14 115.4,14.14 115.37,14.11 115.36,14.1 115.28,14.04 115.21,13.95 115.21,13.94 115.1,13.83 114.38,13.83 114.32,13.83 114.25,13.9 114.25,15.05 114.3,15.15 114.42,15.17 114.85,15.68 114.2,15.54 114.19,15.49 114.11,15.49 113.95,15.32 113.93,15.32 113.81,15.25 113.75,15.14 113.75,15.12 113.71,15.08 113.71,14.31 113.66,14.25 113.5,14.25 113.43,14.32 113.43,15.23 113.57,15.37 113.57,16.76 113.85,17.04 116.14,17.04
+0.9V_LAN on TOP (solid shape): 163.65,139.47 163.65,136.85 163.45,136.66 162.76,136.66 162.63,136.79 162.63,137.46 162.26,137.83 161.37,137.83 160.97,138.23 160.09,138.23 159.96,138.36 159.96,139.7 160.02,139.76 160.99,139.76 161,139.77 163.35,139.77
+0.9V_LAN on IN4 (solid shape): outline of 844 points within 150.21,135.02 162.15,144.64
+0.9V_TBT_PCIE on IN4: 37.13,45.48 36.95,45.48 36.79,45.32 36.79,45.06 36.6,44.86 36.38,44.86 36.24,44.72 36.24,44.47 36.37,44.34 36.67,44.34 36.86,44.14 36.86,43.86 37.01,43.71 37.2,43.71 37.34,43.85 37.34,45.27
+0.9V_TBT_SVR on BOTTOM (solid shape): 34.38,61.71 35.43,61.71 36.27,60.87 36.73,60.87 36.9,60.7 36.9,59.45 36.4,58.94 29.03,58.94 28.9,59.07 28.9,61.23 30.05,62.37 33.72,62.37
+0.9V_TBT_SVR on VCC: 41.92,45.46 41.92,56.72 39.29,59.35 37.15,59.35 34.41,62.09 34.41,62.09 34.38,62.12 31.23,62.12 29.72,60.62 29.72,48.18 33.31,44.59 36.18,44.59 36.63,45.04 41.5,45.04 ; 1 cut-out
+1.0V_ALW_PCH on BOTTOM (solid shape): 150.8,47.87 150.8,46.8 150.61,46.61 149.78,46.61 149.44,46.95 149.44,47.92 149.53,48.01 150.66,48.01
+1.0V_ALW_PCH on BOTTOM (solid shape): 132.44,34.33 132.44,33.83 132.36,33.75 132,33.75 132,32.9 132.13,32.77 134.25,32.77 134.44,32.58 134.44,32.58 135,32.58 135.12,32.7 135.12,32.86 135.17,32.91 135.42,32.91 135.58,32.74 135.58,32.02 135.55,31.99 131.99,31.99 131.89,32.04 131.87,32.15 131.53,32.57 131.3,32.08 131.31,32.07 131.31,31.99 131.21,31.99 131.01,32.18 131.01,33.19 131.09,33.27 131.22,33.27 131.22,33.64 131.28,33.7 131.61,33.7 131.64,33.74 131.65,33.74 131.81,33.96 131.74,34.22 131.73,34.24 131.73,34.36 131.76,34.39 132.38,34.39
+1.0V_ALW_PCH on IN2 (solid shape): outline of 688 points within 124.48,28.84 132.33,33.26
+1.0V_ALW_PCH on IN3 (solid shape): outline of 8448 points within 131.09,31.07 155.67,51.62
+1.0V_ALW_PCH on BOTTOM: 149.02,37.64 149.05,37.68 150.86,37.68 151.32,37.21 151.32,31.64 151.03,31.35 149.42,31.35 149.13,31.64 149.13,33.4 149.02,33.51
+1.0V_AMPHYPLL on TOP (solid shape): 144.22,25.15 144.41,25.08 144.59,25.15 144.75,25.15 144.9,25.01 144.9,24.98 144.93,24.77 145.1,24.65 145.12,24.64 145.19,24.57 145.48,24.57 145.53,24.53 145.59,24.51 145.62,24.48 145.62,23.98 145.58,23.94 144.34,23.94 143.5,24.78 143.5,25.05 143.6,25.15
+1.0V_MPHY on BOTTOM (solid shape): outline of 943 points within 136.58,31.22 148.28,39.61
+1.0V_VCCSFR on TOP (solid shape): 267.72,68.62 267.72,67.21 267.36,66.86 266.32,66.86 266.18,67 266.18,68.52 266.3,68.65 267.69,68.65
+1.0V_VCCSFR_R on TOP (solid shape): 265.7,68.59 265.7,67.47 265.49,67.26 262.46,67.26 262.1,66.91 261.2,66.91 260.98,66.69 260.74,66.69 260.68,66.75 260.68,67.2 261.65,68.17 264.42,68.17 264.97,68.71 265.58,68.71
+1.0V_VCCSFR_R on IN1 (solid shape): outline of 88 points within 250.47,61.56 254.14,63.03
+1.0V_VCCSFR_R on TOP: 251.55,63.49 251.07,63.49 250.42,62.84 250.42,61.66 250.54,61.54 251.02,61.54 251.22,61.74 251.22,62.13 251.65,62.55 251.65,63.39
+1.0V_VCCSFR_R on IN1: 261.61,67.5 261.04,67.5 260.56,67.02 260.56,66.76 260.77,66.55 260.93,66.55 261.37,66.99 261.63,66.99 261.71,67.06 261.71,67.4
+1.0V_VCCST on TOP (solid shape): 271.23,73.66 271.23,71.93 270.58,71.28 270.17,71.28 269.85,70.97 269.85,70.94 269.71,70.65 269.85,70.37 269.85,66.36 269.59,66.11 268.41,66.11 268.12,66.4 268.12,68.55 267.97,68.7 267.97,72.24 269.76,74.02 270.87,74.02
+1.0V_VCCST on BOTTOM (solid shape): 277.91,70.22 277.91,68.98 277.84,68.92 277.41,68.92 276.93,69.4 276.93,70.14 277.23,70.44 277.69,70.44
+1.0V_VCCST on BOTTOM (solid shape): 271.55,74.44 271.55,74.17 270.99,74.17 270.99,73.69 271.55,73.69 271.55,73.42 271.41,73.27 271.41,72.54 271.4,72.53 271.4,70.99 271.41,70.98 271.41,70.87 271.24,70.71 270.43,70.71 270.41,70.75 270.28,70.94 270.05,71.01 269.96,71.05 269.92,71.14 269.92,74.11 270.27,74.45 271.53,74.45
+1.0V_VCCST on IN1 (solid shape): outline of 327 points within 252.32,63.67 254.41,69.01
+1.0V_VCCST_C on BOTTOM (solid shape): 272.68,74.75 272.78,74.77 273.22,74.77 273.22,74.76 273.32,74.75 273.42,74.76 273.42,74.77 274.62,74.77 274.95,74.44 274.95,72.58 274.8,72.43 274.42,72.43 274.04,72.81 271.75,72.81 271.68,72.89 271.68,73.81 271.12,73.81 271.12,74.04 271.68,74.04 271.68,74.54 271.9,74.77 272.59,74.77
+1.0V_VCCSTG on TOP (solid shape): 268.78,82.93 268.78,82.77 268.76,82.75 268.76,82.43 268.2,82.43 268.2,81.95 268.77,81.95 268.77,81.17 267.96,80.36 267.96,77.53 267.97,77.51 267.97,77.36 268.23,77.1 268.38,77.1 268.51,76.97 270.28,76.97 270.61,76.64 270.61,75.08 270.86,74.83 270.86,74.47 270.78,74.39 267.6,74.39 267.4,74.59 267.47,75.3 267.39,76.01 267.39,76.02 267.39,76.17 267.34,76.21 267.34,76.23 267.02,76.98 266.55,77.64 266.55,80.94 266.69,81.08 266.69,82.74 266.97,83.02 268.69,83.02
+1.0V_VCCSTG_C on TOP (solid shape): 269.69,82.39 269.78,82.39 269.79,82.38 269.9,82.37 270.01,82.38 270.02,82.39 271.39,82.39 271.68,82.68 272.35,82.68 272.43,82.6 272.43,82.01 272.23,81.81 272.23,80.96 272.11,80.84 269.31,80.84 269.03,81.12 269.03,81.93 268.88,82.08 268.32,82.08 268.32,82.3 268.88,82.3 268.88,82.69 268.93,82.74 269.34,82.74
+1.0VS_VCCIO on TOP (solid shape): 244.39,63.6 244.72,63.37 245.05,63.6 245.07,63.64 246.03,63.64 246.28,63.4 246.28,62.09 245.99,61.8 244.46,61.8 244.12,62.13 244.12,63.55 244.22,63.64 244.37,63.64
+1.0VS_VCCIO on TOP (solid shape): 241.53,64.28 241.53,64 241.68,63.85 241.77,63.85 241.89,63.78 242.01,63.78 242.04,63.78 242.2,63.62 242.78,63.62 242.83,63.57 242.83,63.56 243.01,63.37 243.01,62.86 243.02,62.85 243.02,61.99 242.9,61.86 241.02,61.86 240.94,61.94 240.94,62.45 240.96,62.46 240.96,63.66 240.94,63.68 240.94,64.15 241.09,64.3 241.5,64.3
+1.0VS_VCCIO on TOP (solid shape): 297.8,58.98 297.8,58.39 297.25,58.39 297.25,57.69 297.8,57.69 297.8,57.19 297.25,57.19 297.25,56.49 297.8,56.49 297.8,55.78 297.72,55.7 295.29,55.7 294.61,56.38 294.61,56.64 294.62,56.65 294.64,56.76 294.62,56.87 294.61,56.88 294.61,59.17 294.74,59.3 297.48,59.3
+1.0VS_VCCIO on IN3 (solid shape): outline of 485 points within 174.3,79.16 196.03,82.69
+1.0VS_VCCIO on BOTTOM: 241.09,61.84 242.58,61.84 242.78,61.64 243.77,61.64 245.55,61.64 245.69,61.51 245.69,60.62 245.8,60.51 250.41,60.51 250.5,60.6 250.5,61.18 250.37,61.31 249.29,61.31 249.14,61.45 249.14,61.64 249.1,61.68 248.03,61.68 247.87,61.84 247.87,62.65 247.6,62.92 241.19,62.92 240.89,62.62 240.89,62.03
+1.0VS_VCCIO on IN2: outline of 176 points within 228.23,59.65 250.75,67.87
+1.0VS_VCCIO on VCC: 239.08,71.48 240.13,72.54 259.91,72.54 261.35,71.1 266.89,71.1 270.36,74.56 277.78,74.56 277.78,74.56 278.62,74.56 280.37,76.3 297.5,76.3 299.41,74.39 299.41,65.17 300.66,63.92 300.66,57.57 299.08,56 295.53,56 294.32,57.2 294.32,66.86 289.2,71.97 282.8,71.97 279.83,69 274.49,69 273.45,67.96 273.45,65.79 273.42,65.79 273.25,65.62 262.16,65.62 259.35,62.8 258.6,62.8 258.6,62.79 252.81,62.79 252.38,62.37 252.38,60.86 251.84,60.31 239.71,60.31 239.08,60.95
+1.0VS_VCCIO on IN4: outline of 440 points within 238.6,48.45 251.99,64.94
+1.0VS_VCCIOP on TOP (solid shape): 302.69,60.04 302.69,56.48 301.83,55.62 298.22,55.62 297.94,55.89 297.94,56.63 297.38,56.63 297.38,57.06 297.94,57.06 297.94,57.8 297.91,57.83 297.41,57.83 297.38,57.85 297.38,58.23 297.41,58.26 297.91,58.26 297.94,58.28 297.94,59.02 297.03,59.93 297.03,61 297.1,61.08 301.65,61.08
+1.0VS_VCCIOP on BOTTOM (solid shape): 299.41,61.13 299.41,60.09 299.43,60.06 299.42,60.05 299.42,59.36 299.3,59.23 297.24,59.23 296.94,59.53 296.94,61.1 297.21,61.37 299.18,61.37
+1.2V_MEM on TOP (solid shape): 95.67,57.03 95.67,55.7 95.37,55.41 94.21,55.41 93.84,55.78 93.84,57.26 93.92,57.35 95.35,57.35
+1.2V_MEM on TOP (solid shape): outline of 224 points within 196.66,42.7 199.67,58.17
+1.2V_MEM on TOP (solid shape): outline of 230 points within 170.24,49.17 172.46,57.94
+1.2V_MEM on TOP (solid shape): outline of 255 points within 165.69,43.09 172.4,48.72
+1.2V_MEM on TOP (solid shape): outline of 500 points within 145.2,3.05 172.53,25.47
+1.2V_MEM on BOTTOM (solid shape): 164.08,92.42 164.08,89.45 163.22,88.58 163.22,88.31 162.68,87.77 160.12,87.77 160.04,87.85 160.04,88.83 162.3,88.83 162.3,88.78 162.3,88.72 162.32,88.67 162.34,88.62 162.37,88.58 162.41,88.54 162.45,88.51 162.5,88.48 162.55,88.46 162.6,88.45 162.65,88.45 162.71,88.45 162.76,88.46 162.81,88.48 162.85,88.51 162.9,88.54 162.93,88.58 162.96,88.62 162.98,88.67 163,88.72 163.01,88.78 163.01,88.83 163,88.88 162.98,88.93 162.96,88.98 162.93,89.03 162.9,89.06 162.85,89.1 162.81,89.12 162.76,89.14 162.71,89.16 162.65,89.16 162.6,89.16 162.55,89.14 162.5,89.12 162.45,89.1 162.41,89.06 162.37,89.03 162.34,88.98 162.32,88.93 162.3,88.88 162.3,88.83 160.04,88.83 160.04,90.21 160.02,90.24 160.02,92.45 160.42,92.85 163.65,92.85
+1.2V_MEM on BOTTOM (solid shape): 172.69,56.11 172.75,56.03 172.83,55.98 172.84,55.98 172.92,55.89 174.44,55.89 174.57,55.77 174.57,55.64 174.46,55.53 172.86,55.53 172.81,55.48 172.75,55.43 172.67,55.34 172.67,55.23 172.67,55.17 172.67,54.8 172.67,54.73 172.67,54.61 172.8,54.48 172.83,54.48 172.89,54.46 172.95,54.45 174.39,54.45 174.45,54.46 174.55,54.37 174.55,54.21 174.38,54.04 172.71,54.04 172.56,53.89 172.56,53.55 172.5,53.54 172.22,53.23 172.5,52.91 172.56,52.91 172.56,51.18 171.72,50.35 170.41,50.35 170.11,50.65 170.11,55.72 171.7,55.72 171.98,56.01 172.02,56.06 172.06,56.11 172.07,56.15 172.68,56.15
+1.2V_MEM on BOTTOM (solid shape): outline of 954 points within 151.43,12.89 172.54,47.16
+1.2V_MEM on BOTTOM (solid shape): outline of 8181 points within 218.47,34.86 239.06,64.06
+1.2V_MEM on IN1 (solid shape): outline of 490 points within 160.05,79.57 169.29,99.15
+1.2V_MEM on IN2 (solid shape): 165.48,100.47 165.48,98.9 165.25,98.67 164.28,98.67 164.08,98.87 164.08,99.91 163.75,100.24 163.75,101.03 163.9,101.18 164.77,101.18
+1.2V_MEM on IN2 (solid shape): outline of 1018 points within 164.31,56.7 174.8,81.14
+1.2V_MEM on IN3 (solid shape): 110.44,98.14 110.44,96.99 110.26,96.81 108.51,96.81 108.2,97.12 108.2,98.82 108.43,99.05 109.52,99.05
+1.2V_MEM on IN3 (solid shape): 108.7,85.17 108.7,84.25 108.71,84.24 108.71,83.3 107.44,82.03 106.96,82.03 106.37,82.62 106.37,84.88 106.96,85.46 108.4,85.46
+1.2V_MEM on IN4 (solid shape): 107.82,82.46 107.49,82.13 106.7,82.13 106.3,82.54 106.3,84.39 106.68,84.77 107.82,84.77
+1.2V_MEM on IN4 (solid shape): 110.74,99.23 110.74,97.3 110.34,96.89 108.48,96.89 108.05,97.32 108.05,99.1 108.46,99.51 110.46,99.51
+1.2V_MEM on TOP: outline of 378 points within 180.88,43.1 188.45,58.48
+1.2V_MEM on BOTTOM: outline of 382 points within 180.91,42.97 188.77,58.46
+1.2V_MEM on IN1: 94.97,55.49 93.9,55.49 93.37,56.02 93.37,59.65 93.4,59.72 93.41,59.78 93.46,59.85 93.54,59.88 93.9,60.26 93.51,60.59 93.41,60.62 93.37,60.72 93.37,64.35 98.02,69.01 98.02,70.44 99.54,71.96 99.54,72.71 103.05,76.22 103.05,78.2 104.82,79.97 104.82,80.13 105.4,80.71 105.4,81.85 106.32,82.77 106.32,83.94 106.7,84.32 107.48,84.32 108.23,83.57 108.23,80.56 106.42,78.75 106.42,73.34 97.43,64.35 97.43,57.95
+1.2V_MEM on IN2: 108.08,97.96 108.08,99.66 108.57,100.15 108.73,100.15 108.76,100.19 112.77,100.19 113.15,99.81 113.15,98.08 112.78,97.71 108.32,97.71
+1.2V_MEM on VCC: 238.4,19.5 231.29,12.38 165.09,12.38 159.24,18.23 159.24,19.87 164.64,25.27 164.64,33.41 163.7,34.36 163.7,57.6 168.55,62.45 168.55,72.38 171.19,75.02 171.19,80.48 171.77,81.06 202.11,81.06 216.48,66.69 237.17,66.69 238.4,65.47 ; 1 cut-out
+1.2V_MEN_P on TOP (solid shape): 116.12,14.01 116.28,13.98 116.38,13.86 116.41,13.77 116.41,13.57 116.34,13.5 115.55,13.5 115.48,13.43 115.24,13.43 115.17,13.49 114.35,13.49 114.29,13.55 114.29,13.65 114.33,13.7 115.15,13.7 115.31,13.86 115.33,13.89 115.37,13.95 115.42,13.99 115.46,14.01 115.53,14.01 115.58,14.01 116.11,14.01
+1.2V_MEN_P on TOP (solid shape): 145.62,12.02 145.62,11.08 145.61,11.07 145.09,11.07 145.07,11.06 145.07,10.37 145.1,10.34 145.6,10.34 145.62,10.32 145.62,9.88 145.6,9.86 145.09,9.86 145.08,9.84 145.08,9.15 145.09,9.14 145.19,9.14 145.59,9.14 145.63,9.1 145.63,5.83 145.61,5.81 145.1,5.81 145.07,5.79 145.07,5.12 145.1,5.1 145.59,5.1 145.62,5.07 145.62,4.64 145.6,4.61 145.11,4.61 145.08,4.59 145.08,4.33 145.07,4.33 145.07,3.89 145.08,3.88 145.61,3.88 145.62,3.87 145.62,3.33 145.58,3.29 145.58,2.44 145.4,2.26 142.81,2.26 142.8,2.25 139.26,2.25 138.5,3.01 138.5,6.52 137.77,7.25 137.77,11.52 138.44,12.2 145.44,12.2
+1.2V_MEN_P on IN2 (solid shape): 117.97,13.69 117.97,13.34 117.51,12.88 117.32,12.88 116.95,13.25 115.4,13.25 115.21,13.44 115.21,13.93 115.43,14.15 117.51,14.15
+1.2V_MEN_P on IN2: 137.89,11.71 139.99,11.71 140.19,11.51 140.19,10.57 140.02,10.39 137.86,10.39 137.73,10.52 137.73,11.55
+1.2V_RUN on TOP (solid shape): outline of 100 points within 85.15,56.18 89.83,60.96
+1.2V_RUN on IN1: 77.11,52.29 70.48,52.29 67.51,49.32 65.35,49.32 61.2,45.16 59.65,45.16 58.64,44.16 55.14,44.16 53.17,42.19 53.17,39.81 53.5,39.49 53.92,39.49 54.3,39.87 54.35,39.87 54.4,39.92 54.4,41.65 55.46,42.7 63.06,42.7 67.61,47.26 67.61,47.31 70.36,50.05 79.5,50.05 79.5,50.06 79.98,50.06 88.95,59.03 88.95,60.18 88.73,60.39 85.22,60.39
+1.2V_RUN on VCC: 48.49,55.46 47.55,56.4 47.55,58.23 48.25,58.94 49.22,58.9 50.19,58.88 69.22,58.88 70.9,58.92 72.57,59.04 79.93,59.04 81.86,60.97 87.93,60.97 88.96,59.95 88.96,59.5 88.6,59.14 87.59,59.14 84.9,56.45 70,56.45 69.02,55.46
+1.2V_RUN on IN4: 89.07,59.88 89.07,59.11 86.96,56.99 68.86,56.99 68.59,56.73 66.98,56.73 66.69,57.02 59.88,57.02 59.4,56.54 57.94,56.54 57.64,56.25 48.64,56.25 47.84,57.05 47.84,58.33 48.43,58.93 49.31,58.89 50.19,58.88 69.22,58.88 74.4,59.27 79.47,60.42 88.54,60.42 ; 1 cut-out
+1.2V_RUN_PWR on TOP (solid shape): 90.97,58.36 90.97,57.56 91.18,57.34 92.38,57.34 92.45,57.27 92.45,56.61 92.5,56.56 92.5,55.23 92.33,55.06 90.57,55.06 89.41,56.23 89.41,56.71 89.43,56.73 89.96,56.73 89.96,57.29 89.41,57.29 89.41,57.52 89.43,57.55 89.96,57.55 89.96,58.08 89.94,58.1 89.43,58.1 89.41,58.13 89.41,58.41 89.43,58.43 89.48,58.43 89.63,58.59 90.74,58.59
+1.05V_PRIM on TOP (solid shape): 273.12,80.53 273.12,79.14 272.95,78.96 271.75,78.96 271.6,78.81 271.6,77.48 271.35,77.23 268.28,77.23 268.1,77.41 268.1,79.03 268.72,79.64 269.57,79.64 270.58,80.66 273,80.66
+1.05V_PRIM on TOP (solid shape): 117.27,54.22 117.27,51.25 116.43,50.41 115.95,50.41 115.39,50.97 115.39,51.53 114.71,52.21 114.67,52.52 114.4,52.68 114.4,53.13 114.48,53.2 114.93,53.2 114.96,53.23 114.96,53.96 114.93,53.99 114.45,53.99 114.42,54.02 114.42,54.4 114.45,54.42 114.93,54.42 114.96,54.45 114.96,55.16 114.93,55.18 114.42,55.18 114.4,55.21 114.4,55.79 114.49,55.88 115.61,55.88
+1.05V_PRIM on BOTTOM (solid shape): 247.23,23.21 247.35,23.08 247.35,22.11 246.33,22.11 246.33,22.72 246.08,22.97 246.08,23.85 246.16,23.93 246.51,23.93
+1.05V_PRIM on BOTTOM (solid shape): 28.78,19.44 29.45,19.44 29.55,19.34 29.55,18.77 29.32,18.54 29.28,18.56 28.87,18.47 28.82,18.06 28.83,18.05 28.83,17.78 28.81,17.72 28.8,17.66 28.8,17.36 28.93,17.13 29.2,17.1 29.62,17.1 29.73,17.08 29.85,17.1 29.92,17.1 30.07,16.95 30.07,15.28 29.99,15.2 27.59,15.2 27.43,15.36 27.43,19.03 27.56,19.15 27.62,19.33 27.66,19.41 27.74,19.45 28.78,19.45
+1.05V_PRIM on BOTTOM (solid shape): 274.23,77.94 274.27,77.83 274.2,77.73 274.09,77.16 274.67,77.26 274.76,77.34 274.87,77.3 275.39,76.79 276.38,76.79 276.63,76.54 276.63,75.78 276.55,75.32 277,75.18 277.04,75.2 278.2,74.03 278.99,74.03 279.27,73.75 279.27,73.22 279.12,73.07 277.24,73.07 276.93,72.76 276.93,71.85 276.68,71.59 275.38,71.59 275.16,71.82 275.16,74.61 274.59,75.18 274.31,75.18 274.3,75.23 274.07,75.47 273.73,75.41 273.65,75.39 273.57,75.42 273.32,75.67 270.21,75.67 268.23,77.65 268.23,79.08 269.06,79.9 272.28,79.9
+1.05V_PRIM on IN1 (solid shape): 220.68,10.84 220.68,9.8 220.47,9.6 218.9,9.6 218.38,10.12 218.38,10.92 218.58,11.12 220.41,11.12
+1.05V_PRIM on IN1 (solid shape): 247,24.8 247,22.61 246.89,22.5 246.16,22.5 246.05,22.61 246.05,24.31 245.89,24.47 245.89,24.83 246.21,25.16 246.64,25.16
+1.05V_PRIM on IN4 (solid shape): 156.06,29.22 156.06,27.93 155.7,27.57 155.37,27.57 155.09,27.85 155.09,29.15 155.39,29.45 155.83,29.45
+1.05V_PRIM on IN4 (solid shape): 276.29,75.1 276.29,73.47 276.09,73.27 275.21,73.27 275,73.48 275,75.09 275.17,75.26 276.13,75.26
+1.05V_PRIM on IN4 (solid shape): 247.71,22.79 247.71,22.31 247.29,21.89 247.01,21.89 246.07,22.83 246.07,23.87 246.11,23.92 246.58,23.92
+1.05V_PRIM on IN4 (solid shape): 218.06,11.37 219.96,11.37 220.09,11.24 220.09,10.48 219.78,10.17 217.14,10.17 216.86,10.45 216.86,11.39 216.96,11.5 217.93,11.5
+1.05V_PRIM on BOTTOM: 146.49,31.57 146.34,31.72 146.34,34.48 146.54,34.69 148.34,34.69 148.55,34.48 148.55,33.63 149,33.18 149,31.65 148.93,31.57
+1.05V_PRIM on VCC: 118.26,52.98 117.35,53.89 115.12,53.89 113.63,52.4 106.61,52.4 85.46,31.24 73.39,31.24 71.59,29.44 71.59,25.96 71.56,25.94 71.56,22.61 68.27,19.32 27.79,19.32 27.41,18.94 27.41,16.5 29.79,14.11 72.97,14.11 87.96,29.1 87.96,30.49 88.72,31.26 96.11,31.26 98.16,33.3 98.16,36.27 99.24,37.35 105.93,37.35 106.03,37.45 111.55,37.45 112.34,38.24 112.34,46.37 112.98,47 116.28,47 117.29,45.99 117.29,44.34 122.12,39.51 126.02,39.51 126.69,38.84 126.69,35.96 127.44,35.21 130.9,35.21 131.9,34.2 131.9,31.64 138.11,25.44 138.17,25.5 156.25,25.5 156.8,26.05 156.8,29.47 156.11,30.16 150.47,30.16 148.99,31.64 148.99,45.2 141.21,52.98
+1.05V_PRIMP on TOP (solid shape): 114.25,55.77 114.25,55.03 114.27,55.01 114.73,55.01 114.78,54.96 114.78,54.6 114.75,54.57 114.25,54.57 114.25,53.81 114.75,53.81 114.78,53.79 114.78,53.41 114.75,53.38 114.25,53.38 114.25,52.66 114.21,52.65 114,52.19 114.45,51.98 114.49,51.99 115.07,51.41 115.07,50.88 115.34,50.61 115.34,47.94 114.52,47.13 114.48,47.14 114.08,47.07 114.01,46.67 114.02,46.63 112.65,45.25 107.61,45.25 106.78,46.08 106.78,50.13 107.15,50.5 109.67,50.5 110.51,51.34 110.51,54.93 111.4,55.81 114.2,55.81
+1.05V_VDD on BOTTOM (solid shape): 12.16,24.49 12.16,21.12 12.82,20.46 12.82,19.27 12.22,18.66 12.22,16.65 12.52,16.35 12.62,16.35 12.63,16.34 12.75,16.32 12.88,16.34 14.85,16.34 14.9,16.29 14.9,15.79 14.84,15.73 13.09,15.73 12.9,15.78 12.71,15.73 12.69,15.73 12.47,15.51 12.47,13.99 12.47,13.96 12.33,13.82 11.39,13.82 11.19,14.02 11.19,17.36 11.26,17.43 11.26,18.12 11.48,18.35 11.48,19.98 9.83,21.62 9.83,24.4 10.02,24.59 12.07,24.59
+1.05V_VDD on BOTTOM (solid shape): 18.6,13.38 18.6,12.43 19.48,11.55 20.27,11.55 20.53,11.29 20.53,10.51 20.35,10.32 20.35,9.33 20.25,9.23 19.42,9.23 19.23,9.41 19.23,9.66 19.24,9.73 19.23,9.8 19.23,10.27 19.23,10.31 19.23,10.35 19.23,10.98 19.06,11.14 19.05,11.14 19.03,11.17 18.99,11.21 18.94,11.24 18.77,11.41 18.77,11.46 18.78,11.48 18.83,11.73 18.65,11.91 18.64,11.92 18.39,12.16 18.39,13.38 18.44,13.43 18.55,13.43
+1.05V_VDD on BOTTOM (solid shape): 25.32,21.94 25.32,21.59 24.77,21.04 24.77,20.49 24.68,20.39 24.32,20.39 24.21,20.29 24.21,19.86 24.14,19.79 23.71,19.79 23.64,19.71 23.63,19.7 23.58,19.66 23.58,19.05 23.47,19.05 22.69,18.28 22.44,18.28 22.2,18.03 22.14,18.03 21.58,17.47 21.58,17.42 21.46,17.3 20.17,17.3 20.08,17.38 20.08,17.5 20.15,17.57 20.98,17.57 22.19,18.77 22.19,19.23 22.68,19.73 22.68,19.85 24.36,21.53 24.36,21.55 24.39,21.57 24.52,21.77 24.5,22 24.51,22.12 24.62,22.18 25.08,22.18
+1.05V_VDD on BOTTOM (solid shape): 25.39,17.4 25.39,16.82 25.47,16.73 26.12,16.73 26.19,16.65 26.19,15.7 26.18,15.69 25.18,15.69 25.12,15.63 25.11,15.62 25.01,15.52 24.29,15.52 24.05,15.76 24.05,16.17 23.87,16.34 23.87,16.35 23.61,16.57 23.29,16.48 22.84,16.48 22.49,16.52 22.27,16.24 22.27,16.21 22.14,16.09 20.16,16.09 20.1,16.15 20.1,16.31 20.16,16.37 21.55,16.37 22.37,17.19 24.53,17.19 24.61,17.26 24.61,17.41 24.71,17.52 24.74,17.52 24.82,17.59 25.2,17.59
+1.05V_VDD on IN3 (solid shape): outline of 2120 points within 9.87,8.82 29.68,24.37
+1.8V_ALW_PCHRES on BOTTOM (solid shape): 123.9,36.35 123.9,35.92 123.97,35.85 125.47,35.85 125.55,35.77 125.55,35.14 125.49,35.14 125.42,35.12 125.36,35.09 125.35,35.08 125.16,35.08 124.95,34.87 123.24,34.87 123.13,34.98 123.13,35.38 123,35.51 122.93,35.51 122.91,35.54 122.8,35.66 122.64,35.71 122.45,35.66 122.33,35.51 122,35.51 121.89,35.62 121.89,36.28 122,36.4 123.85,36.4
+1.8V_ALW_PCHRES on IN4 (solid shape): outline of 367 points within 129.51,26.47 131.28,33.18
+1.8V_ALW_VTR3 on TOP (solid shape): 127.48,70.61 127.57,70.57 127.61,70.47 127.63,70.31 127.73,70.18 127.73,69.33 127.66,69.26 127.66,68.25 127.51,68.09 126.9,68.09 126.84,68.16 126.84,68.6 126.83,68.61 126.73,68.61 126.73,68.61 126.28,68.61 126.28,68.62 126.28,68.8 126.28,68.8 126.84,68.8 126.84,68.8 126.84,69.32 126.73,69.44 126.73,70.56 126.78,70.61
+1.8V_PRIM on TOP (solid shape): 333.82,14.29 333.82,13.56 333.75,13.49 332.83,13.49 332.72,13.6 331.84,13.6 331.67,13.77 331.67,14.74 331.81,14.88 333.23,14.88
+1.8V_PRIM on TOP (solid shape): 110.23,20.75 110.23,19.73 110.56,19.4 110.56,19.39 110.56,18.97 110.16,18.57 109.32,18.57 109.31,18.56 109.07,18.81 109.07,18.84 108.74,19.17 108.74,20.09 108.18,20.09 108.18,20.31 108.2,20.32 108.69,20.32 108.74,20.32 108.74,20.92 108.89,21.07 109.91,21.07
+1.8V_PRIM on TOP (solid shape): 126.6,70.61 126.6,69.33 126.7,69.23 126.7,68.96 126.68,68.94 126.16,68.94 126.15,68.92 126.15,68.5 126.16,68.49 126.67,68.49 126.7,68.46 126.7,68.07 126.64,68.01 125.02,68.01 124.63,68.4 124.63,68.97 124.5,69.1 123.65,69.1 123.53,69.22 123.53,69.7 123.71,69.88 125.88,69.88 125.93,69.93 126.01,69.93 126.01,70.58 126.08,70.66 126.55,70.66
+1.8V_PRIM on BOTTOM (solid shape): outline of 297 points within 122.31,45.09 127.83,54.14
+1.8V_PRIM on IN1 (solid shape): outline of 206 points within 124.23,53.21 128.2,69.55
+1.8V_PRIM on IN2 (solid shape): 122.25,53.95 122.61,53.6 122.96,53.95 122.96,54.01 124.25,54.01 124.43,53.84 126.24,53.84 126.42,54.01 127.14,54.01 127.19,53.97 127.19,53.43 126.62,52.86 122.48,52.86 122.03,53.3 122.03,53.95 122.1,54.01 122.25,54.01
+1.8V_PRIM on IN2 (solid shape): outline of 799 points within 123.31,38.06 127.28,46.18
+1.8V_PRIM on IN2: outline of 98 points within 108.87,18.78 120.82,29.28
+1.8V_PRIM on VCC: 126.41,37.48 126.41,34.39 120.4,28.39 119.25,28.39 118.7,28.94 118.7,32.85 120.41,34.56 120.41,38.26 121.34,39.19 125.86,39.19 126.26,38.8 126.26,37.63
+1.8V_PRIM_PCH on TOP (solid shape): 123.57,68.41 124.44,68.41 124.6,68.25 124.6,67.32 124.49,67.21 121.19,67.21 120.91,67.49 120.91,68.76 121.3,69.14 122.83,69.14
+1.8V_PRIM_PCH on BOTTOM (solid shape): 122.15,67.93 122.15,67 121.83,66.69 121.81,66.69 121.6,66.59 121.5,66.38 121.5,66.35 121.37,66.23 120.62,66.23 120.1,66.75 120.1,67.89 120.37,68.16 121.93,68.16
+1.8V_PRIM_PCH on BOTTOM (solid shape): outline of 943 points within 127.81,39.14 136.14,57.12
+1.8V_PRIMP on TOP (solid shape): 108.61,20.72 108.61,20.49 108.58,20.46 108.05,20.46 108.02,20.44 108.02,19.98 108.05,19.95 108.58,19.95 108.61,19.93 108.61,19.12 108.94,18.79 108.94,17.69 108.91,17.66 107.46,17.66 107.45,17.67 107.14,17.67 107.12,17.66 106.94,17.66 106.65,17.37 106.19,17.28 106.22,16.81 106.26,16.77 105.49,16 102.77,16 102.53,16.23 102.49,16.36 102.41,16.46 102.41,18.49 102.77,18.85 104.21,18.85 104.23,18.87 104.51,18.87 104.61,18.82 104.63,18.72 104.89,18.29 105.32,18.54 105.35,18.58 105.4,18.58 105.7,18.63 105.85,18.9 105.85,18.93 107.7,20.77 108.55,20.77
+1.8V_RUN on TOP (solid shape): 342.34,14.96 342.33,14.93 342.33,14.71 342.47,14.53 342.47,12.16 342.23,11.92 339.55,11.92 339.43,12.04 339.43,12.83 339.42,12.84 338.89,12.84 338.88,12.85 338.88,13.09 338.89,13.1 339.42,13.1 339.43,13.11 339.43,13.62 339.42,13.64 338.89,13.64 338.88,13.65 338.88,13.89 338.9,13.91 339.41,13.91 339.43,13.93 339.43,14.97 339.84,15.38 341.92,15.38
+1.8V_RUN_AUDIO on TOP (solid shape): 382.77,15.6 382.77,15.1 382.59,14.91 382.59,13.37 382.29,13.08 381.9,13.08 381.53,13.45 381.53,15.46 381.77,15.7 382.67,15.7
+1.8V_RUN_PWR on TOP (solid shape): 339.29,15.23 339.29,14.06 339.28,14.05 338.77,14.05 338.73,14.01 338.73,13.5 338.74,13.49 339.29,13.49 339.29,13.25 338.73,13.25 338.73,12.69 339.29,12.69 339.29,12.03 339.09,11.83 337.82,11.83 337.45,12.19 337.45,13.22 337.19,13.48 336.48,13.48 336.27,13.55 336.06,13.48 335.23,13.48 335.1,13.6 335.1,14.62 335.23,14.75 335.23,15.79 335.33,15.89 338.63,15.89
+2.5V_MEM on TOP (solid shape): 195.95,91.43 195.95,87.09 196.46,86.57 196.46,81.67 196.42,81.62 196.42,81.62 196.37,81.57 194.74,81.57 194.64,81.68 194.64,84.84 193.47,86.01 193.47,88.59 193.72,88.84 194.37,88.84 194.51,88.98 194.53,88.98 194.53,89 194.6,89.07 194.6,89.84 194.33,90.11 193.82,90.11 193.76,90.17 193.76,90.59 193.48,90.87 193.48,91.44 193.61,91.57 195.81,91.57
+2.5V_MEM on TOP (solid shape): 184.57,91.59 184.57,85.95 182.79,84.17 182.79,81.77 182.6,81.58 182.4,81.58 182.39,81.57 180.99,81.57 180.94,81.62 180.94,82.53 180.94,82.54 180.94,86.75 181.28,87.09 182.67,87.09 182.95,87.36 182.95,90.59 182.94,90.61 182.94,90.69 182.92,90.71 182.91,90.72 182.77,90.92 182.53,90.98 182.38,90.97 182.24,90.9 182.15,90.87 182.06,90.91 181.54,91.43 181.54,93.33 181.76,93.56 182.6,93.56
+2.5V_MEM on TOP (solid shape): outline of 81 points within 166.15,90.82 174.51,95.35
+2.5V_MEM on BOTTOM (solid shape): 168.61,92.98 168.61,91.21 168.6,91.2 168.6,90.07 168.59,90.06 168.59,88.88 168.67,88.81 168.79,88.81 168.79,88.8 172.49,88.8 172.74,88.55 172.74,86.21 174.77,84.18 174.77,81.7 174.64,81.56 172.85,81.56 172.81,81.52 172.25,81.52 172.24,81.51 166.86,86.89 166.86,91 166.81,91.05 166.81,92.96 167.08,93.23 168.35,93.23
+2.5V_MEM on BOTTOM (solid shape): 195.2,91.35 195.2,89.09 192.54,86.44 191.12,86.44 188.31,83.63 188.31,81.68 188.21,81.58 187.87,81.58 187.86,81.58 186.58,81.58 186.26,81.9 186.26,83.99 185.3,84.95 181.78,84.95 180.94,85.79 180.94,86.66 181.34,87.06 185.52,87.06 186.35,87.89 186.35,89.14 186.57,89.36 191.37,89.36 191.51,89.5 192.6,89.5 193.49,90.38 193.49,91.38 193.54,91.43 195.12,91.43
+2.5V_MEMP on TOP (solid shape): 165.22,95.44 165.22,94.47 166.01,93.69 166.01,92.86 166.03,92.84 166.55,92.84 166.57,92.82 166.57,92.57 166.56,92.57 166.05,92.57 166.02,92.53 166.02,92.04 166.03,92.03 166.56,92.03 166.56,92.03 166.56,91.78 166.55,91.77 166.03,91.77 166.02,91.76 166.02,91.17 166.51,90.68 166.51,88.98 166.29,88.76 165.01,88.76 164.84,88.93 164.84,90.07 164.1,90.81 164.1,90.82 164.07,90.85 163.08,90.85 162.94,90.98 162.94,93.75 162.95,93.76 162.95,95.22 163.52,95.8 164.87,95.8
+2.5V_MEMP on BOTTOM (solid shape): 166.65,93.89 166.65,89.1 166.18,88.63 165.14,88.63 164.77,89 164.77,93.86 165.09,94.18 166.36,94.18
+3.3V_1.8V_AZIO on BOTTOM (solid shape): 122.64,37.78 122.64,36.66 122.63,36.64 121.04,36.64 121.01,36.68 121.01,37.77 121.2,37.96 122.46,37.96
+3.3V_1.8V_GPPD on BOTTOM (solid shape): 125.41,36.97 125.41,36.03 125.36,35.98 124.09,35.98 124.03,36.04 124.03,36.41 124.03,36.46 124.07,36.51 124.66,36.51 124.79,36.64 124.79,37 124.99,37.2 125.18,37.2
+3.3V_1.8V_SPI on BOTTOM (solid shape): 129.61,27.78 129.69,27.73 129.78,27.7 129.8,27.7 130.38,27.13 130.38,26.25 128.94,26.25 128.86,26.32 128.86,27.29 129.17,27.6 129.17,27.62 129.33,27.78
+3.3V_ALW on TOP (solid shape): 119.28,62.35 119.28,61.44 119.19,61.35 117.18,61.35 116.96,61.57 116.96,62.24 117.12,62.4 119.23,62.4
+3.3V_ALW on TOP (solid shape): 147.08,80.39 147.08,74.22 146.89,74.03 145.36,74.03 145.2,74.2 145.2,80.38 145.23,80.42 147.06,80.42
+3.3V_ALW on TOP (solid shape): 114.65,147.62 114.65,146.35 114.45,146.15 112.63,146.15 111.9,146.87 111.9,147.71 112.25,148.06 114.2,148.06
+3.3V_ALW on TOP (solid shape): 140.69,87.03 140.69,85.6 140.38,85.28 138.51,85.28 138.36,85.13 136.06,85.13 135.94,85.25 135.94,85.68 136.75,86.48 137.11,86.48 138.09,87.46 140.26,87.46
+3.3V_ALW on TOP (solid shape): 150.77,103.44 150.77,102.16 150.58,101.97 150.4,101.97 150.24,101.81 149.11,101.81 148.77,102.15 148.74,102.17 148.69,102.21 148.69,102.83 148.74,102.88 149.35,102.88 149.36,102.9 149.45,102.9 149.45,103.62 149.55,103.72 150.49,103.72
+3.3V_ALW on TOP (solid shape): 138.5,15.29 138.5,14.45 138.43,14.37 137.79,14.37 137.77,14.35 137.76,14.35 137.66,14.3 137.6,14.2 137.59,14.19 137.1,13.7 136.82,13.7 136.5,14.01 136.5,15.18 136.71,15.38 138.4,15.38
+3.3V_ALW on TOP (solid shape): 47.72,55.95 47.72,55.92 47.76,55.91 47.79,55.88 48.21,55.88 48.23,55.91 48.84,55.91 48.91,55.84 48.91,54.64 48.56,54.29 46.34,54.29 46.27,54.36 46.27,55.8 46.34,55.87 47.44,55.87 47.49,55.91 47.49,55.93 47.55,55.98 47.55,56.01 47.63,56.04
+3.3V_ALW on TOP (solid shape): 136.71,64.07 136.82,63.96 136.98,63.91 137.95,63.91 137.98,63.92 138.08,63.88 138.12,63.79 138.12,63.51 138.17,63.47 138.17,62.27 137.8,61.9 137.79,61.9 137.73,61.86 137.67,61.81 134.87,61.81 134.87,62.39 134.86,62.4 134.86,62.81 134.72,62.96 133.09,62.96 132.97,63.08 132.97,63.67 133.22,63.92 133.69,63.92 133.72,63.95 134.97,63.95 135.08,64.07
+3.3V_ALW on TOP (solid shape): 115.56,24.5 115.59,24.47 115.62,24.39 115.6,24.31 115.58,23.89 115.98,23.75 115.99,23.75 116.27,23.75 116.28,23.74 116.28,23.05 116.1,22.87 114.99,22.87 114.82,22.98 114.63,23.03 114.6,23.03 114.55,23.08 114.29,23.08 113.85,22.64 113.85,21.59 113.63,21.37 112.29,21.37 112.12,21.54 112.12,23.34 113.35,24.56 115.52,24.56
+3.3V_ALW on TOP (solid shape): 129.3,70.01 129.3,68.68 129.49,68.5 129.49,68.21 129.02,68.21 129.01,68.2 128.94,68.2 128.93,68.19 128.93,68.12 128.92,68.12 128.92,67.82 128.93,67.82 128.93,67.75 128.93,67.74 129,67.74 129.01,67.73 129.18,67.73 129.18,67.74 129.47,67.74 129.48,67.73 129.48,67.4 129.48,67.4 129.48,67.3 129.33,67.15 128.85,67.15 128.84,67.14 128.2,67.14 127.86,67.48 127.86,68.44 128.12,68.7 128.14,68.7 128.47,69.04 128.16,69.4 128.14,69.41 128.09,69.46 128.09,70 128.2,70.12 129.2,70.12
+3.3V_ALW on TOP (solid shape): 154.13,96.31 154.13,95.02 154.01,94.8 154.13,94.57 154.13,93.56 153.22,92.65 153.22,92.58 153.21,92.57 153.21,92.12 153.22,92.11 153.22,92.05 153.23,92.04 153.29,92.04 153.31,92.02 153.75,92.02 153.77,92.01 153.77,91.77 153.31,91.77 153.29,91.75 153.22,91.75 153.21,91.74 153.21,91.31 153.21,91.24 153.22,91.22 153.3,91.22 153.31,91.21 153.76,91.21 153.76,90.96 153.31,90.96 153.3,90.95 153.26,90.95 153.25,90.94 153.23,90.94 153.23,90.92 153.22,90.91 153.22,90.86 153.21,90.86 153.21,90.43 153.22,90.43 153.22,90.33 152.9,90.01 151.58,90.01 151.23,90.36 151.23,96.17 151.54,96.48 151.76,96.48 151.85,96.58 153.86,96.58
+3.3V_ALW on TOP (solid shape): 146.03,104.7 146.03,104 145.95,103.77 146.03,103.55 146.03,103.33 146.08,102.82 146.58,102.88 147.29,102.88 147.39,102.78 147.39,102.02 147.24,101.87 146.38,101.87 146.34,101.91 146.09,102.02 145.83,101.93 145.81,101.92 145.77,101.92 145.71,101.86 144.78,101.86 144.57,102.07 144.57,103.6 145,104.02 145,104.03 145.05,104.07 145.05,104.61 145.04,104.63 145.04,104.99 145.16,105.11 145.61,105.11
+3.3V_ALW on TOP (solid shape): 128.59,81.75 128.63,81.75 128.85,81.54 129.21,81.54 129.21,81.51 129.97,81.51 129.97,81.95 130.01,82.01 130.08,82 130.12,81.95 130.12,79.3 129.91,79.09 129.37,79.09 129.31,79.16 129.31,79.17 128.98,79.4 128.65,79.19 128.55,79.11 128.44,79.15 127.78,79.81 127.75,79.9 127.79,79.99 127.91,80.35 127.63,80.61 127.58,80.62 127.58,81.82 127.63,81.83 127.8,81.91 127.91,82.06 127.93,82.1 128.25,82.1
+3.3V_ALW on TOP (solid shape): 147.71,70.35 147.71,68.49 148.02,68.17 148.02,67.88 148.01,67.87 148.01,66.8 147.97,66.78 147.77,66.46 147.97,66.14 148.01,66.12 148.01,65.7 148.02,65.69 147.99,65.53 148.03,65.38 148.03,64.13 146.99,63.08 146.43,63.08 146.12,63.62 145.82,63.08 143.95,63.08 143.52,63.51 143.52,64.91 143.69,65.08 145.9,65.08 145.91,65.06 146.01,65.16 146.06,65.24 146.16,65.25 146.6,65.63 146.09,65.92 146.08,65.91 146,65.91 146,66.02 145.24,66.78 145.24,70.44 145.34,70.54 145.91,70.54 146.01,70.49 146.03,70.38 146.38,69.94 146.72,70.39 146.74,70.5 146.84,70.55 147.51,70.55
+3.3V_ALW on TOP (solid shape): outline of 185 points within 90.77,17.25 97.06,20.9
+3.3V_ALW on BOTTOM (solid shape): 167.8,140.3 167.8,139.9 167.81,139.9 167.81,138.77 167.71,138.67 166.84,138.67 166.66,138.85 166.68,138.89 166.7,139.15 166.54,139.35 166.54,140.55 166.67,140.67 167.43,140.67
+3.3V_ALW on BOTTOM (solid shape): 152.23,67.75 152.23,67.12 152.26,67.09 152.26,66.96 152.26,66.96 152.55,66.67 152.68,66.67 152.71,66.63 152.71,64.45 152.52,64.26 152.52,62.97 151.92,62.37 151.92,61.86 151.55,61.49 149.76,61.49 149.76,62.16 149.56,62.16 149.56,62.17 149.22,62.5 149.22,63.46 149.36,63.6 150.54,63.6 150.84,63.9 150.84,63.91 151.22,64.29 151.22,64.74 151.24,64.76 151.73,64.76 151.74,64.77 151.77,64.77 151.77,65.21 151.72,65.21 151.38,65.21 151.38,65.21 151.25,65.21 151.22,65.23 151.22,65.62 151.41,65.8 151.41,67.95 151.54,68.08 151.9,68.08
+3.3V_ALW on BOTTOM (solid shape): 120.47,63.1 120.47,60.42 120.47,60.41 120.47,57.95 120.09,57.57 117.76,57.57 117.66,57.67 117.66,59.38 117.83,59.55 117.83,60.97 118.65,60.97 118.66,60.92 118.67,60.87 118.69,60.82 118.71,60.77 118.75,60.73 118.79,60.7 118.83,60.67 118.88,60.64 118.93,60.63 118.98,60.62 119.04,60.62 119.09,60.63 119.14,60.64 119.19,60.67 119.23,60.7 119.27,60.73 119.3,60.77 119.33,60.82 119.35,60.87 119.36,60.92 119.37,60.97 119.36,61.03 119.35,61.08 119.33,61.13 119.3,61.18 119.27,61.22 119.23,61.25 119.19,61.28 119.14,61.31 119.09,61.32 119.04,61.33 118.98,61.33 118.93,61.32 118.88,61.31 118.83,61.28 118.79,61.25 118.75,61.22 118.71,61.18 118.69,61.13 118.67,61.08 118.66,61.03 118.65,60.97 117.83,60.97 117.83,62.26 117.66,62.43 117.66,63.44 117.76,63.54 120.03,63.54
+3.3V_ALW on BOTTOM (solid shape): outline of 102 points within 127.35,77.93 130.58,81.57
+3.3V_ALW on BOTTOM (solid shape): outline of 252 points within 147.81,20.45 153.02,25.12
+3.3V_ALW on BOTTOM (solid shape): outline of 378 points within 143.82,100.32 150.52,105.82
+3.3V_ALW on IN1 (solid shape): 62.18,37.73 62.18,36.46 61.54,35.83 59.26,35.83 59,36.08 59,37.35 59.64,37.99 61.92,37.99
+3.3V_ALW on IN2 (solid shape): 155.93,66.61 155.93,63.72 155.82,63.61 155.75,63.68 155.76,63.72 155.37,64.17 155.12,63.63 155.12,63.5 155.01,63.44 154.53,63.44 154.44,63.48 154.41,63.57 154.05,63.95 153.7,63.57 153.66,63.48 153.57,63.44 153.35,63.44 153.25,63.49 153.23,63.6 153.03,64.03 152.58,63.89 152.49,63.82 152.38,63.86 151.36,64.89 151.36,67.27 151.51,67.43 155.12,67.43
+3.3V_ALW on TOP: 139.27,64.72 139.14,64.59 139.14,63.39 139.46,63.07 142.1,63.07 142.21,63.18 142.21,64.68 142.16,64.72
+3.3V_ALW on IN1: 27.51,32.15 29.92,32.15 30.17,31.89 30.17,29.86 29.16,28.84 27.89,28.84 27.38,29.35 27.38,32.02
+3.3V_ALW on IN1: 51.38,32.65 50.87,33.16 50.87,34.69 51,34.81 54.43,34.81 54.81,34.43 54.81,33.03 54.43,32.65 52.72,32.65 52.7,32.69 52.39,32.88 52.07,32.69 52.05,32.65
+3.3V_ALW on VCC: 74.17,31.54 73.76,31.94 73.76,36.54 74.41,37.19 75.09,37.19 83.62,45.72 88.32,45.72 113.9,71.29 114.02,71.29 123.67,80.94 123.67,91.02 132.6,99.95 132.6,102.57 132.66,102.63 132.66,119.27 134.57,121.17 152.13,121.17 153.82,119.48 153.82,85.16 160.35,78.63 160.35,68.47 160.33,68.45 160.33,67.51 160.01,67.19 158.35,67.19 157.96,67.58 155.65,67.58 153.36,65.29 151.1,65.29 151.09,65.28 149.11,65.28 139.18,55.35 137.69,55.35 135.76,53.42 118.72,53.42 117.92,54.22 116.81,54.22 116.79,54.21 115.05,54.21 113.67,52.83 106.58,52.83 85.29,31.54 ; 1 cut-out
+3.3V_ALW on VCC: 108.96,36.61 98.86,36.61 98.4,36.15 98.4,33.14 96.85,31.59 96.85,31.54 94.55,29.24 94.55,26.42 91.01,22.88 91.01,18.6 92.05,17.56 94.9,17.56 94.98,17.64 95.09,17.53 98.46,17.53 101.17,14.82 106.54,14.82 107.21,14.16 107.21,11.47 109.22,9.46 134.61,9.46 134.62,9.46 146,9.46 150.65,14.1 150.65,14.2 151.64,15.19 151.64,20.88 150.6,21.92 140.62,21.92 137.84,19.14 124.38,19.14 119.83,23.69 114.3,23.69 114.16,23.83 108.37,23.83 107.29,24.91 107.29,27.55 111.1,31.36 111.1,34.15 108.89,36.35 108.89,36.55
+3.3V_ALW on IN3: 60.2,14.85 56.84,18.2 56.84,23.71 58.27,25.14 73.4,25.14 74.19,25.92 74.19,34.79 72.51,36.46 57.73,36.46 52.27,41.92 52.27,50.94 49.35,53.86 47.32,53.86 46.68,54.5 46.68,55.77 47.09,56.17 51.89,56.17 53.79,54.27 53.79,45.35 59.38,39.77 78.64,39.77 80.64,37.76 80.64,29.54 78.44,29.54 77.53,28.63 77.53,26.9 78.02,26.41 80.64,26.41 80.64,25.92 81.43,25.14 91.39,25.14 93.52,23 93.52,22.93 95.4,21.05 95.43,21.05 95.43,17.31 94.52,16.41 90.17,16.41 89.57,17.01 87.55,17.01 86.99,17.57 68.45,17.57 65.94,15.05 65.94,15.03 65.76,14.85
+3.3V_ALW on IN3: 112.03,145.37 117.28,145.37 123.68,138.97 123.68,137.77 123.99,137.46 126.53,137.46 127.7,138.63 127.7,143.99 123.82,147.87 111.91,147.87 111.77,147.73 111.77,145.63
+3.3V_ALW on IN4: outline of 169 points within 122.18,96.8 168.22,140.95
+3.3V_ALW_PCH on TOP (solid shape): 144.47,18.13 144.47,14.46 144.29,14.28 143.3,14.28 142.85,14.72 142.85,15.24 143.14,15.52 143.14,16.13 142.59,16.13 142.59,16.38 143.14,16.38 143.14,16.92 142.59,16.92 142.59,17.18 143.14,17.18 143.14,17.96 143.43,18.25 144.35,18.25
+3.3V_ALW_PCH on TOP (solid shape): 375.79,56.38 376.92,56.38 377.4,55.89 377.4,55.12 377.25,54.96 374.52,54.96 373.71,55.77 375.2,55.77 375.21,55.71 375.22,55.66 375.24,55.61 375.27,55.57 375.3,55.53 375.34,55.49 375.38,55.46 375.43,55.44 375.48,55.42 375.53,55.41 375.59,55.41 375.64,55.42 375.69,55.44 375.74,55.46 375.78,55.49 375.82,55.53 375.86,55.57 375.88,55.61 375.9,55.66 375.91,55.71 375.92,55.77 375.91,55.82 375.9,55.87 375.88,55.92 375.86,55.97 375.82,56.01 375.78,56.05 375.74,56.08 375.69,56.1 375.64,56.12 375.59,56.12 375.53,56.12 375.48,56.12 375.43,56.1 375.38,56.08 375.34,56.05 375.3,56.01 375.27,55.97 375.24,55.92 375.22,55.87 375.21,55.82 375.2,55.77 373.71,55.77 373.68,55.8 373.68,57.3 374,57.61 374.56,57.61
+3.3V_ALW_PCH on BOTTOM (solid shape): 176.63,14.9 176.63,13.65 176.53,13.55 175.18,13.55 174.65,14.09 174.65,14.65 175.18,15.18 176.35,15.18
+3.3V_ALW_PCH on BOTTOM (solid shape): 375.55,57.45 375.55,56.54 375.57,56.52 375.57,56.3 375.35,56.09 375.31,56.05 375.27,56.02 374.1,56.02 374.08,56.01 373.17,56.01 373.14,56.03 373.14,57.35 373.36,57.56 373.42,57.56 373.42,57.56 374.15,57.56 374.15,57.57 375.43,57.57
+3.3V_ALW_PCH on IN1 (solid shape): 261.03,24.93 261.03,23.48 260.53,22.98 259.97,22.98 259.71,23.23 259.71,24.81 260.07,25.16 260.8,25.16
+3.3V_ALW_PCH on IN1 (solid shape): 375.55,57.75 375.55,56.61 375.05,56.1 372.71,56.1 372.11,56.71 372.11,57.5 372.55,57.94 375.37,57.94
+3.3V_ALW_PCH on IN3 (solid shape): outline of 88 points within 174.29,13.6 177.35,16.73
+3.3V_ALW_PCH on IN4 (solid shape): 260.68,24.53 260.68,24.33 260.59,24.24 260.59,23.54 259.67,22.62 259.41,22.62 259.28,22.75 259.28,23.64 259.29,23.66 259.31,23.74 259.32,23.83 259.31,23.86 260.11,24.65 260.55,24.65
+3.3V_ALW_PCH on TOP: 132.89,20.22 131.31,20.22 131.1,20.43 130.35,20.43 129.69,19.77 129.69,18.77 129.81,18.65 131.93,18.65 132.17,18.41 132.96,18.41 133.14,18.59 133.14,19.96
+3.3V_ALW_PCH on TOP: 116.9,37.51 118.92,37.51 119.38,37.05 119.38,36.33 119.26,36.21 118.74,36.21 118.6,36.35 118.6,36.61 118.6,36.61 118.18,36.61 118.01,36.78 117.24,36.78 117.13,36.67 117.13,35.31 117.09,35.27 116.48,35.27 116.1,35.66 115.72,35.66 115.7,35.68 115.7,35.92 115.69,35.92 115.69,36.32 115.76,36.39 116.31,36.39 116.38,36.46 116.38,36.99
+3.3V_ALW_PCH on BOTTOM: 131.13,18.54 131.11,18.56 131.04,18.61 130.96,18.64 130.95,18.65 130.82,18.65 130.62,18.85 130.62,20.07 130.73,20.18 133.5,20.18 133.58,20.1 133.58,19.38 133.17,18.97 133.17,18.54 133.06,18.43 131.24,18.43 131.14,18.53
+3.3V_ALW_PCH on BOTTOM: 118.79,32.94 118.79,32.51 118.64,32.36 118.64,31.23 118.5,31.1 117.99,31.1 117.98,31.1 117.85,31.1 117.71,31.24 117.71,31.78 116.96,31.78 116.94,31.79 116.68,31.79 116.67,31.78 116.61,31.78 116.51,31.83 116.49,31.94 116.5,32.14 116.39,32.31 116.35,32.4 116.38,32.49 116.37,32.97 115.89,33 115.88,32.99 115.84,32.97 115.79,32.99 115.78,33 115.59,33.1 115.37,33.07 115.25,33.08 115.19,33.18 115.19,34.99 115.94,35.75 115.94,40.07 116.61,40.74 116.61,41.3 116.7,41.38 117.64,41.38 117.83,41.57 119.18,41.57 119.4,41.35 119.4,40.38 119.49,40.3 119.49,36.87 119.37,36.76 118.92,36.76 118.54,37.14 118.34,37.14 118.02,36.93 118.08,36.57 118.11,36.48 118.07,36.39 118.01,36.33 118.01,35.93 118.01,35.92 117.99,35.83 118.01,35.74 118.01,35.73 118.01,33.85 118.01,33.85 118.29,33.48 118.64,33.78 118.64,33.84 119.52,33.84 119.63,33.73 119.63,33.19 119.57,33.12 118.97,33.12
