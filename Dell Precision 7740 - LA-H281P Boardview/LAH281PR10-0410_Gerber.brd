# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_PRIM_EN: length 86.1
  TOP w0.109: RH442.2 125.32,14.57 125.6,14.29 v2(125.6,14.26) ; v2(106.97,25.19) 107.24,25.45 PR803.1 ; v2(111.03,29.53) 111.03,28.45 111.41,28.07 111.75,28.07 111.89,28.21 114.05,28.21 114.82,28.97 117.7,28.97 118.02,28.65 118.5,28.65 RH441.2 ; PR901.2 102.05,22.63 102.05,23.67 103.69,25.31 v1(104.09,25.31) v2(104.81,25.31) ; v2(135.3,13.35) 135.3,13.82 135.99,14.51 RZ509.1
  IN1 w0.102: v2(125.6,14.26) 126.21,14.87 130.53,14.87 132.46,12.94 134.9,12.94 v2(135.3,13.35)
  IN3 w0.081: v2(111.03,29.53) 111.03,29.22 109.67,27.86 109.67,27.45 108.02,25.8 107.74,25.8 107.13,25.19 v2(106.97,25.19)
  IN4 w0.102: v2(146.57,15.53) 146.57,15.72 146.37,15.92 145.3,15.92 145.01,15.62 145.01,14.32 144.78,14.09 137.78,14.09 137.04,13.35 v2(135.3,13.35) ; v2(104.81,25.31) 105.26,25.76 105.81,25.76 106.28,25.29 106.87,25.29 v2(106.97,25.19) 107.07,25.29 107.32,25.29 108.65,23.96 108.65,17.66 109.05,17.25 113.02,17.25 114.63,18.86 116.25,18.86 117.4,17.72 117.4,15.97 119.1,14.26 v2(125.6,14.26)
  BOTTOM w0.109: UZ34.1 151.31,17.35 151.15,17.2 149.9,17.2 149.24,16.54 148.99,16.54 148.33,15.88 146.92,15.88 v2(146.57,15.53)
PCH_PWROK: length 252.1
  TOP w0.109: v2(311.03,41.01) 310.45,41.59 308.6,41.59 308.35,41.84 PR1114.2 307.92,42.05 307.79,41.92 307.36,41.92 307.14,42.15 PU1100.45 ; UH1.AY42 125.97,28.2 v2(125.84,28.07)
  IN2 w0.081: v2(125.84,28.07) 125.99,27.91 125.99,27.49 126.37,27.11 126.86,27.11 127.07,26.91 127.07,26.58 128.99,24.66 128.99,23.35 127.52,21.88 v2(127.52,21.54) ; v2(245.62,14.47) 245.62,14.04 246.09,13.56 256.79,13.56 259.41,10.95 290.87,10.95 294.92,15 302.09,15 311.45,24.36 311.45,35.35 311.22,35.57 311.22,40.82 v2(311.03,41.01)
  IN3 w0.081: v2(125.84,28.07) 125.7,28.21 124.07,28.21 122.96,27.09 122.96,25.54 121.75,24.33 121.75,23.86 122.12,23.49 122.4,23.49 122.77,23.13 122.77,22.21 122.1,21.54 122.1,19.47 124.6,16.97 124.6,16.65 v2(125.28,15.97)
  BOTTOM w0.109: v2(125.84,28.07) 125.84,27.63 v4(125.94,27.52) ; v2(125.28,15.97) 126.41,14.84 126.41,14.08 126.69,13.79 127.45,13.79 131.06,10.19 137.95,10.19 139.01,11.25 140.05,11.25 140.73,10.57 162.15,10.57 163.04,9.69 213.49,9.69 215.8,12.01 230.06,12.01 230.92,11.15 233.34,11.15 235.04,9.46 238.4,9.46 239.45,10.51 242.06,10.51 245.62,14.07 v2(245.62,14.47) ; v2(127.52,21.54) 127.34,21.37 RH424.1
PCH_RSMRST#: length 153.4
  TOP w0.109: v2(97.27,33.8) 96.85,34.22 96.85,37.61 96.21,38.24 94.46,38.24 94.27,38.43 94.27,39.55 93.74,40.08 90.71,40.08 89.02,41.77 89.02,42.54 89.98,43.5 89.98,51.75 90.84,52.61 104.84,52.61 105.41,53.18 105.41,60.03 102.99,62.45 RZ1413.1 ; RE342.1 136.14,67.57 135.1,68.61 135.1,69.01 135.67,69.58 v2(135.67,70.08) UE1.M5
  IN3 w0.081: v2(135.67,70.08) 135.41,70.08 134.9,69.56 133.95,69.56 132.53,68.14 131.57,68.14 131.23,68.48 131.23,68.87 130.88,69.22 129.99,69.22 128.98,68.21 128.56,68.21 128.38,68.02 123.29,68.02 122.65,68.67 121.03,68.67 119.78,67.43 119.78,67.02 119.28,66.51 118.33,66.51 116.02,64.2 116.02,63.38 114.92,62.28 114.92,61.94 112.7,59.72 112.7,58.06 111.7,57.06 109.38,57.06 108.28,55.96 108.28,55.27 105.59,52.58 100.39,52.58 98.91,51.1 98.91,45.2 97.94,44.23 97.94,34.47 v2(97.27,33.8)
  IN4 w0.102: v2(102.78,13.17) 102.14,13.17 99.24,16.08 99.24,16.59 97.84,17.99 97.84,20.46 96.66,21.64 96.66,22.68 98.91,24.93 99.95,24.93 100.65,25.64 100.65,28.35 102.87,30.57 102.87,31.17 102.49,31.55 99.85,31.55 98.14,33.26 97.8,33.26 v2(97.27,33.8)
  BOTTOM w0.109: UZ6.1 v2(102.78,13.17)
PCH_RSMRST#_AND: length 162.2
  TOP w0.102: UH1.BA47 125.4,25.7 125.4,25.34 125.45,25.28 125.45,24.67 125.58,24.55 125.58,24.17 125.34,23.94 124.94,23.94 123.62,22.62 123.62,21.35 124.1,20.87 RC75.1
  TOP w0.109: RH215.2 123.62,19.4 v2(124.36,20.13) 124.36,20.49 RC75.1
  IN2 w0.081: v2(124.36,20.13) 122.65,18.43 122.65,15.43 121.55,14.33 118.53,14.33 118.31,14.54 115.01,14.54 114.55,14.09 114.55,13.35 112.6,11.39 107.38,11.39 105.96,12.82 v2(105.29,12.82)
  IN3 w0.081: v2(236.09,10.5) 236.09,10.23 232.85,6.98 169.16,6.98 162.96,13.18 160.51,13.18 158.67,15.03 149.71,15.03 149.4,14.71 146.04,14.71 144.1,16.65 137.06,16.65 136.8,16.91 135.25,16.91 135.03,16.69 130.47,16.69 130.31,16.85 130.31,19.58 129.47,20.42 124.65,20.42 v2(124.36,20.13)
  BOTTOM w0.109: UZ6.4 105.54,14.47 105.41,14.34 105.41,12.93 v2(105.29,12.82) v4(105.29,12.07) ; v2(236.09,10.5) 236.13,10.53 236.13,11.58 RC124.1
PCH_RTCRST#: length 116.9
  TOP w0.109: v2(120.35,22.79) 120.37,22.78 RH200.2 120.04,21.36 CH40.2 118.9,21.36 118.56,21.03 118.56,20.12 CMOS1.2 ; UH1.BE47 123.91,25.85 124.52,25.85 v2(124.55,25.88)
  IN1 w0.102: v2(109.33,64.68) 109.87,64.15 109.87,58.11 111,56.98 111,51.79 112.45,50.33 112.45,42.55 112.62,42.37 112.62,37.68 113.92,36.38 113.92,35.45 114.18,35.19 114.18,31.83 114.48,31.52 114.48,29.43 114.23,29.18 114.23,28.45 114.12,28.34 114.12,26.91 114.77,26.27 115.53,26.27 116.34,25.45 116.34,25.22 116.98,24.59 118.56,24.59 v2(120.35,22.79)
  IN2 w0.081: v2(124.55,25.88) 124.48,25.81 122.72,25.81 121.15,24.24 121.15,23.59 v2(120.35,22.79)
  IN3 w0.081: v2(149.68,76.77) 149.38,76.77 148.6,77.55 148.6,78.47 147.32,79.75 145.32,79.75 144.74,80.32 142.71,80.32 142.45,80.07 140.9,80.07 140.32,79.49 139.67,79.49 139.22,79.94 137.6,79.94 137.08,80.46 135.2,80.46 134.75,80 134.7,80 134.47,79.77 133.93,79.24 133.09,79.24 132.76,78.91 131.52,78.91 131.26,79.16 130.66,79.16 129.49,77.99 128.72,77.99 128.52,77.79 127.34,77.79 126.59,78.54 125.22,78.54 122.86,76.17 121.8,76.17 116.54,70.91 115.48,70.91 110,65.43 110,65.35 v2(109.33,64.68)
  BOTTOM w0.109: RE94.2 150.85,77.15 150.47,76.77 v2(149.68,76.77) ; JAPS1.9 109.21,67.02 v4(108.93,66.74) 108.93,65.08 v2(109.33,64.68)
PCH_RTCX1: length 5.5
  TOP w0.102: RH44.1 125.38,21.47 125.38,22.5 125.33,22.55 125.33,23.39 125.96,24.02 125.96,24.85 UH1.BA49
  TOP w0.109: RH43.2 126.54,20.31 RH44.1
PCH_RTCX1_R: length 2.9
  TOP w0.109: RH43.1 127.37,20.13 CH4.2 127.37,18.74 YH1.1
PCH_RTCX2: length 8.8
  TOP w0.102: RH44.2 125.19,20.74 125.19,22.42 125.13,22.48 125.13,23.46 125.77,24.1 125.77,24.66 125.65,24.78 125.65,25.07 125.68,25.11 UH1.BA48
  TOP w0.109: YH1.2 126.53,18.43 126.53,19.35 CH5.2 126.52,19.42 RH44.2
PCH_SMB_ALERT#: length 7.3
  TOP w0.102: RH61.2 117.73,36.24 118.54,36.24 118.72,36.05 120.19,36.05 120.32,36.19 120.32,36.75 120.55,36.97 120.97,36.97 121.13,36.81 121.85,36.81 122.02,36.97 123.67,36.97 UH1.BE25
PCH_SPI_CLK: length 63.1
  TOP w0.102: UH1.AW47 126.93,25.88 126.85,25.8 126.85,25.46 126.97,25.34 126.97,24.06 127.04,23.99 127.04,23.87 v2(127.56,23.36)
  IN1 w0.102: v2(115.84,24.72) 116.16,24.72 116.78,24.11 118.66,24.11 119.71,23.06 119.71,22.72 120.03,22.4 120.56,22.4 120.64,22.32 120.64,22.07 120.56,21.99 119.99,21.99 119.89,21.89 119.89,21.69 119.99,21.59 122.43,21.59 122.53,21.49 122.53,21.28 122.43,21.18 120.03,21.18 119.94,21.09 119.94,20.87 120,20.8 122,20.8 122.3,20.5 122.3,19.87 122.72,19.45 123.54,19.45 123.95,19.85 123.95,20.51 124.22,20.78 125.11,20.78 127.04,22.71 127.04,24.54 127.45,24.96 128.95,24.96 129.06,24.86 129.06,23.89 128.9,23.73 128.75,23.73 128.62,23.87 128.62,24.3 128.52,24.4 128.27,24.4 127.56,23.69 v2(127.56,23.36)
  IN2 w0.081: v2(115.84,24.72) 115.65,24.72 115.33,24.4 115.33,23.69 114.23,22.59 112.61,22.59 112.34,22.32 110.81,22.32 109.97,23.15 105.2,23.15 102.87,25.48 100.91,25.48 100.69,25.25 100.46,25.25 99.2,23.99 99.2,23.08 96.24,20.12 v2(95.92,20.12)
  BOTTOM w0.109: RH640.1 127.98,22.94 v2(127.56,23.36) ; JSPI1.8 96.92,19.12 v2(95.92,20.12) ; v2(115.84,24.72) 115.76,24.64 RH181.2
PCH_SPI_CLK_0_R: length 7.3
  BOTTOM w0.109: RH724.2 119.09,23.83 RH29.1 119.54,24.13 119.54,23.09 v4(119.52,23.06) 119.52,22.47 119.64,22.34 120.75,22.34 120.96,22.13 120.96,21.04 121.09,20.91 121.28,20.91 121.61,21.24 UC5.6
PCH_SPI_CLK_1_R: length 9.8
  BOTTOM w0.109: RH728.2 107.82,21.1 107.56,21.35 107.56,22.01 106.26,23.32 106.26,23.67 105.09,24.84 104.37,24.84 104.2,25.01 104.2,25.62 103.97,25.85 UC6.6 101.75,25.85 RH28.1
PCH_SPI_CLK_2_R: length 2.6
  BOTTOM w0.109: UZ12.19 135.71,16.54 135.69,16.51 RZ63.2 RZ60.2
PCH_SPI_CLK_R1: length 52.1
  IN2 w0.081: v2(115.89,24.1) 115.89,23.9 114.35,22.36 112.71,22.36 112.43,22.09 110.92,22.09 v2(110.44,21.6) 110.18,21.86 110.18,22.42 109.67,22.93 105.1,22.93 102.78,25.25 101.08,25.25 100.85,25.02 100.55,25.02 99.77,24.24 v2(99.77,23.7)
  IN4 w0.102: v2(115.89,24.1) 117.1,22.89 117.1,22.48 119.1,20.48 119.93,20.48 121.19,19.22 122.41,19.22 122.82,19.62 125.32,19.62 125.34,19.65 129.37,19.65 129.91,19.12 133.14,19.12 133.67,18.59 v2(133.67,17.16)
  BOTTOM w0.109: RZ60.1 134.1,17.16 v2(133.67,17.16) ; v2(110.44,21.6) 110.3,21.6 109.79,21.1 RH728.1 ; RH181.1 115.51,23.73 v2(115.89,24.1) 116.16,23.83 RH724.1 ; v2(99.77,23.7) 99.73,23.7 99.69,23.66 97.06,23.66 v4(96.76,23.36) 96.42,23.02 JSPI1.7
PCH_SPI_CS#0: length 45
  TOP w0.102: v2(127.46,22.35) 127.13,22.35 127.05,22.43 127.05,22.77 126.85,22.97 126.85,23.87 126.76,23.96 126.76,25.28 126.64,25.4 126.64,25.83 UH1.AY47
  IN1 w0.102: v2(127.46,22.35) 127.15,22.35 124.52,19.73 124.15,19.73 123.64,19.22 121.15,19.22 120.74,19.62 120.03,19.62 117.03,22.62 v2(116.6,22.62)
  BOTTOM w0.109: JSPI1.10 97.92,17.33 98.62,16.63 99.26,16.63 99.5,16.4 100.66,16.4 101.92,15.14 102.67,15.14 102.9,15.37 106.6,15.37 106.77,15.19 108.07,15.19 108.91,16.04 108.91,16.68 109.22,16.99 110.04,16.99 110.95,16.08 112.23,16.08 v1(113.92,17.78) 115.16,19.01 115.16,20.82 116.6,22.25 v2(116.6,22.62) RH182.2
PCH_SPI_CS#0_R1: length 46.2
  IN1 w0.102: v2(114.75,20.09) 114.82,20.09 117.04,17.86 117.04,15.7 v2(117.22,15.52)
  IN2 w0.081: v2(101.69,24.32) 102.74,24.32 104.82,22.24 106.86,22.24 108.05,21.05 108.05,18.86 108.52,18.39 109.98,18.39 110.68,19.09 110.95,19.09 111.25,19.38 112,19.38 112.51,19.89 114.55,19.89 v2(114.75,20.09)
  BOTTOM w0.109: v2(114.75,20.09) 114.92,20.26 114.92,21.3 115.05,21.43 RH182.1 114.67,23 114.67,24.31 114.04,24.93 113.48,24.93 113.04,25.36 113.04,25.83 112.89,25.98 RH352.1 ; v2(117.22,15.52) v4(117.82,14.92) 118.17,14.57 118.17,12.14 119.19,11.12 122.76,11.12 RH37.1 ; v2(101.69,24.32) 101.42,24.32 100.34,23.25 99.31,23.25 98.85,22.79 98.28,22.79 97.42,21.92 JSPI1.9
PCH_SPI_CS#0_R2: length 3
  BOTTOM w0.109: UC5.1 123.84,13.6 123.26,13.03 RH37.2 124.22,12.54 v4(124.51,12.25)
PCH_SPI_CS#0_R3: length 18.6
  BOTTOM w0.109: RH352.2 112.71,27.14 112.71,27.87 112.47,28.11 v1(112.24,28.11) 112.2,28.07 111.31,28.07 110.93,27.69 108.71,27.69 108.58,27.56 108.58,26.85 108.51,26.77 108.16,26.77 108.05,26.88 108.05,27.78 107.95,27.89 107.73,27.89 107.62,27.78 107.62,26.88 107.51,26.77 107.29,26.77 107.18,26.88 107.18,27.78 107.07,27.89 106.85,27.89 106.74,27.78 106.74,26.88 106.63,26.77 106.39,26.77 106.25,26.91 106.25,28.16 106.32,28.23 108.73,28.23 108.89,28.39 UC6.1
PCH_SPI_CS#1: length 45.3
  TOP w0.102: UH1.AW48 127.09,25.56 127.18,25.46 127.18,24.21 127.54,23.84 127.8,23.84 v2(128.14,23.51)
  IN2 w0.081: v2(128.14,23.51) 127.88,23.76 127.39,23.76 127.07,23.45 127.07,22.48 126.67,22.07 125.41,22.07 124.61,22.87 123.88,22.87 121.94,20.93 120.82,20.93 117.93,18.04 117.93,17.16 116.73,15.96 115.01,15.96 v2(114.55,15.5)
  BOTTOM w0.109: v2(114.55,15.5) 114.55,15.65 RH177.2 114.08,16.12 v1(113.23,16.12) 112.89,16.12 112.61,15.84 109.39,15.84 108.27,14.72 106.56,14.72 106.39,14.89 103.09,14.89 102.87,14.67 101.72,14.67 100.47,15.93 99.3,15.93 99.06,16.16 98.3,16.16 97.34,17.12 95.1,17.12 94.91,17.31 94.09,17.31 93.92,17.48 JSPI1.2
PCH_SPI_CS#1_R1: length 39.8
  IN2 w0.081: v2(90.82,17.52) 91.37,16.96 93.72,16.96 95.05,15.63 99.38,15.63 99.79,15.23 105.62,15.23 105.79,15.05 107.15,15.05 107.55,14.65 107.55,13.83 108.21,13.17 110.93,13.17 112.82,15.06 113.59,15.06 113.69,15.16 113.69,15.55 114.56,16.41 116.13,16.41 v2(116.5,16.77)
  BOTTOM w0.109: v2(116.5,16.77) 116.31,16.59 v1(115.34,16.59) RH177.1 ; v2(90.82,17.52) 90.82,21.36 91.79,22.34 93.18,22.34 93.42,22.1 JSPI1.1
PCH_SPI_CS#2: length 36.9
  TOP w0.109: UH1.AT40 128.66,29.32 v2(128.66,29.06)
  BOTTOM w0.109: v2(128.66,29.06) 128.66,28.25 128.49,28.08 127.65,28.08 127.52,27.96 127.52,27.63 127.39,27.5 127.39,25.2 127.3,25.11 127.3,24.28 127.56,24.02 127.8,24.02 127.91,24.13 128.38,24.13 129.65,22.86 130.25,22.86 130.48,22.63 130.48,21.57 130.13,21.22 v1(130.03,21.22) 130.41,20.84 130.41,14.46 130.52,14.35 131.89,14.35 132,14.46 132,14.68 131.89,14.79 130.94,14.79 130.83,14.9 130.83,15.12 130.94,15.22 131.36,15.22 131.47,15.33 131.47,15.55 131.36,15.66 130.87,15.66 130.76,15.77 130.76,15.99 130.87,16.1 132.36,16.1 132.47,15.99 132.47,14.37 132.58,14.26 132.79,14.26 132.91,14.38 132.91,14.92 133.02,15.03 133.42,15.03 133.53,15.14 133.53,15.36 133.42,15.47 133.02,15.47 132.91,15.58 132.91,15.92 133.2,16.21 133.2,16.43 133.09,16.54 131.46,16.54 131.34,16.65 131.34,16.92 131.52,17.1 132.45,17.1 133.02,17.67 133.29,17.67 133.86,18.24 RZ61.1
PCH_SPI_CS#2_R: length 2.7
  BOTTOM w0.109: RZ61.2 135.23,18.24 135.84,17.62 135.84,17.31 136.11,17.04 UZ12.20
PCH_SPI_D0: length 174.9
  TOP w0.109: v2(127.33,29.13) 127.64,28.82 UH1.AU41
  IN2 w0.081: v2(150.89,11.38) 150.89,12.31 149.64,13.57 145.86,13.57 144.85,12.56 134.92,12.56 133.9,13.58 133.9,16.18 134.19,16.46 134.19,17.26 133.78,17.67 132.85,17.67 132.34,17.16 131.9,17.16 131.58,17.48 131.58,18.39 129.55,20.42 128.64,20.42 128.13,20.93 128.13,21.81 130.35,24.02 130.35,25.45 128.28,27.52 128.28,27.78 127.33,28.73 v2(127.33,29.13) 125.89,29.13 124.72,27.95 123.68,27.95 123.15,27.43 123.13,27.43 122.47,26.76 122.47,26.09 119.59,23.22 119.59,21.95 117.08,19.43 112.7,19.43 112.19,18.93 111.44,18.93 v2(110.94,18.43) 110.77,18.26 110.77,17.74 109.49,16.46 v2(109.39,16.46)
  BOTTOM w0.109: v2(150.89,11.38) 151.46,11.94 155.35,11.94 155.59,11.7 162.81,11.7 163.53,10.98 171.3,10.98 172.14,11.82 181.21,11.82 182.42,10.6 213.17,10.6 215.44,12.88 231.23,12.88 v1(231.42,12.69) 231.72,12.38 232.66,12.38 232.99,12.71 232.99,13.12 232.74,13.37 232.74,14.68 233.47,15.41 RC128.1 ; RH178.2 RH600.2 111.33,18.93 110.94,18.54 v2(110.94,18.43) ; JSPI1.4 94.92,17.64 95.2,17.36 97.49,17.36 98.45,16.4 99.16,16.4 99.4,16.16 100.56,16.16 101.82,14.91 102.77,14.91 102.99,15.13 106.49,15.13 106.66,14.96 108.17,14.96 109.39,16.18 v2(109.39,16.46)
PCH_SPI_D0_0_R: length 7.7
  BOTTOM w0.109: UC5.5 120.34,20.97 120.22,20.84 119.64,20.84 119.52,20.72 119.52,19.28 119.39,19.15 118.65,19.15 118.4,19.41 v4(118.4,19.79) 118.4,20.7 118.76,21.06 118.76,21.93 118.51,22.18 RH723.2
PCH_SPI_D0_1_R: length 7.7
  BOTTOM w0.109: UC6.5 105.02,24.58 105.97,23.63 105.97,23.27 107.33,21.92 107.33,21.02 RH727.2
PCH_SPI_D0_2_R: length 2.7
  BOTTOM w0.109: RZ59.2 135.69,18.93 135.62,18.85 135.62,18.2 136.29,17.54 UZ12.21
PCH_SPI_D0_R1: length 56.9
  IN1 w0.102: v2(110.56,20.97) 110.99,20.97 111.56,21.54 114.81,21.54 115.72,20.63 115.72,20.59 v2(115.81,20.5) 115.84,20.47 116.6,20.47 116.99,20.07 116.99,19.37 117.9,18.46 117.9,16.58 118.82,15.66 120.29,15.66 120.75,15.2 120.75,14.39 121.05,14.09 123.04,14.09 123.89,14.94 125.54,14.94 126.31,15.7 129.73,15.7 130.82,16.79 v2(130.82,17.29)
  IN2 w0.081: v2(110.56,20.97) 108.45,20.97 106.95,22.47 104.91,22.47 102.59,24.79 101.31,24.79 100.87,24.36 v2(100.82,24.36)
  BOTTOM w0.109: RH727.1 109.42,20.21 110.18,20.97 v2(110.56,20.97) RH178.1 ; v2(115.81,20.5) 115.81,20.7 115.96,20.84 115.96,20.89 117.22,22.15 RH723.1 ; RZ59.1 134.58,19 133.84,19 133.66,18.82 133.66,18.52 133.18,18.04 131.57,18.04 v2(130.82,17.29) ; v2(100.82,24.36) 100.52,24.67 98.83,24.67 98.56,24.4 v4(98.07,24.4) 96.82,24.4 94.42,22 JSPI1.3
PCH_SPI_D1: length 46.1
  TOP w0.102: v2(126.27,23.21) 126.28,23.21 126.36,23.28 126.36,25.11 126.28,25.19 126.17,25.3 126.17,25.78 126.11,25.84 126.11,26.33 126.03,26.42 126.03,26.55 126.02,26.56 UH1.BA45
  IN2 w0.081: v2(126.27,23.21) 126.27,23.09 125.84,22.67 125.36,22.67 124.77,23.26 123.72,23.26 121.91,21.44 120.57,21.44 116.56,17.44 v2(116.56,17.41) 116.32,17.41 115.66,16.75 112.72,16.75 112.06,16.09 110.79,16.09 109.79,15.09 109.79,13.82 109.37,13.4 108.31,13.4 107.78,13.93 107.78,14.75 107.25,15.28 105.89,15.28 105.7,15.47 99.98,15.47 v2(95.92,19.53)
  BOTTOM w0.109: v2(95.92,19.53) 95.92,19.52 JSPI1.6 ; RH179.2 117.23,18.66 v1(116.68,18.11) 116.58,18.01 116.58,17.43 v2(116.56,17.41)
PCH_SPI_D1_0_R: length 11
  BOTTOM w0.109: RH722.2 117.94,21.15 117.94,18.24 v4(118.39,17.79) 119.38,16.8 119.38,16.19 119.94,15.64 121.79,15.64 122.88,14.54 122.88,13.6
PCH_SPI_D1_1_R: length 11.2
  BOTTOM w0.109: RH726.2 108.14,23.34 107.9,23.59 107.77,23.59 107.69,23.66 107.69,23.89 107.8,24 108.35,24 108.46,24.11 108.46,24.33 108.35,24.44 107.8,24.44 107.69,24.55 107.69,24.77 107.8,24.88 108.35,24.88 108.46,24.98 108.46,25.2 108.35,25.31 107.54,25.31 106.88,25.98 106.88,26.15 107.09,26.36 107.26,26.36 107.81,25.81 108.62,25.81 108.89,26.08 108.89,26.95 109.05,27.12 UC6.2
PCH_SPI_D1_2_R: length 3
  BOTTOM w0.109: v1(135.54,20.94) 135.54,20.14 RZ58.2 136.45,19.99 136.78,19.67 136.78,19.57 137,19.35 UZ12.24
PCH_SPI_D1_R1: length 56.9
  IN1 w0.102: v2(109.74,22.1) 109.88,21.96 109.88,20.89 110.22,20.55 111.16,20.55 111.92,21.31 114.71,21.31 115.14,20.88 115.14,20.59 115.67,20.06 v2(116.43,20.06) 116.43,19.5 117.57,18.35 117.57,16.56 118.73,15.41 119.35,15.41 119.78,14.98 119.78,14.49 120.5,13.78 123.11,13.78 124.03,14.7 125.63,14.7 126.4,15.47 130.78,15.47 133.49,18.18 133.49,19.7 v2(134.19,20.4)
  IN2 w0.081: v2(109.74,22.1) 107.64,22.1 107.05,22.7 105.01,22.7 102.68,25.02 101.21,25.02 100.98,24.79 100.65,24.79 100.34,24.49 v2(100.34,23.95)
  BOTTOM w0.109: v2(109.74,22.1) 109.74,22.24 109.05,22.93 RH726.1 ; v2(100.34,23.95) 100.02,24.28 v4(99.78,24.28) 99.01,24.28 98.7,23.97 96.77,23.97 95.42,22.62 JSPI1.5 ; RZ58.1 134.37,20.4 v2(134.19,20.4) ; RH722.1 117.23,20.89 117.23,20.89 RH179.1 116.65,20.28 v2(116.43,20.06)
PCH_SPI_D2: length 44.9
  TOP w0.102: UH1.AY48 126.43,25.33 126.57,25.19 126.57,23.83 126.64,23.76 126.64,22.84 v2(126.44,22.63)
  TOP w0.109: RH180.2 126.03,22.23 v2(126.44,22.63)
  IN2 w0.081: v2(112.87,19.03) 112.99,19.15 117.16,19.15 119.91,21.91 121.75,21.91 123.68,23.84 126.24,23.84 126.67,23.41 126.67,22.86 v2(126.44,22.63)
  BOTTOM w0.109: JSPI1.12 98.92,17.06 99.11,16.87 99.36,16.87 99.59,16.63 100.76,16.63 102.01,15.38 102.57,15.38 102.8,15.6 106.7,15.6 106.87,15.43 107.97,15.43 108.68,16.14 108.68,16.78 109.12,17.22 110.14,17.22 111.04,16.32 111.7,16.32 112.09,16.7 v1(112.09,17.13) 112.87,17.92 v2(112.87,19.03) 113.5,19.66 113.5,21.74 RH30.2 RH183.2
PCH_SPI_D2_0_R: length 2.6
  BOTTOM w0.109: UC5.3 121.31,13.6 120.72,13.02 RH351.2 v1(119.73,12.54)
PCH_SPI_D2_1_R: length 3.2
  BOTTOM w0.109: UC6.3 111.8,25.85 RH353.2 112.55,25.1 112.84,25.1 v1(113.04,24.9)
PCH_SPI_D2_R1: length 36.8
  IN1 w0.102: v2(118.97,14.98) 118.83,14.98 117.35,16.46 117.35,18.07 114.91,20.5 114.91,20.79 114.62,21.08 113.24,21.08 v2(112.82,20.67)
  IN2 w0.081: v2(104.94,23.99) 106.71,23.99 107.08,23.61 109.95,23.61 110.74,24.4 111.91,24.4 112.06,24.55 v2(112.63,24.55)
  BOTTOM w0.109: v2(112.82,20.67) 113.07,20.91 113.07,22.11 113.53,22.57 113.53,23.43 RH183.1 113.36,24.55 v2(112.63,24.55) 112.18,24.55 RH353.1 ; JSPI1.11 98.42,22.02 99.4,23.01 100.44,23.01 101.33,23.9 102.13,23.9 102.13,23.9 104.85,23.9 v2(104.94,23.99) ; RH351.1 120.09,11.62 118.97,12.74 v2(118.97,14.98)
PCH_SPI_D2_XDP: length 128.8
  TOP w0.109: v2(126.68,21.11) 126.95,21.38 RH180.1
  BOTTOM w0.109: v2(126.68,21.11) 126.02,21.11 124.58,19.67 124.58,16.78 124.95,16.4 126.88,16.4 127.2,16.08 127.2,14.94 131.47,10.67 137.57,10.67 v1(138.49,11.58) 138.68,11.77 140.53,11.77 141.23,11.07 149.91,11.07 151.02,12.18 155.44,12.18 155.69,11.93 162.91,11.93 163.62,11.22 171.21,11.22 172.04,12.05 181.38,12.05 182.59,10.84 213.07,10.84 215.35,13.12 229.52,13.12 236.59,20.19 RC127.2
PCH_SPI_D3: length 48.7
  TOP w0.102: v2(125.72,23.06) 125.58,23.2 125.58,23.36 126.15,23.94 126.15,25.05 125.98,25.22 125.98,25.7 125.92,25.76 125.92,26.25 UH1.BA46
  IN2 w0.081: v2(107.16,15.88) 107.16,15.69 108.01,14.84 108.01,14.02 108.4,13.63 109.04,13.63 109.55,14.14 109.55,15.19 110.93,16.58 111.33,16.58 v2(111.5,16.75) 111.97,17.22 113.65,17.22 115.35,18.93 117.5,18.93 120.29,21.72 121.83,21.72 123.67,23.56 125.22,23.56 v2(125.72,23.06)
  BOTTOM w0.109: JSPI1.14 99.92,17.02 100.07,16.87 100.86,16.87 102.11,15.62 102.48,15.62 102.7,15.84 107.12,15.84 v2(107.16,15.88) ; RH184.2 111.5,23.29 111.65,23.14 RH335.2 112.14,23.2 RH334.2 113.29,23.46 113.29,22.66 112.84,22.21 112.84,21.52 112.41,21.09 112.41,18.64 v1(112.38,18.61) 112.38,18.02 111.5,17.15 v2(111.5,16.75)
PCH_SPI_D3_0_R: length 9.5
  BOTTOM w0.109: 122.88,21.6 121.82,22.67 121.82,24.45 121.63,24.63 120.32,24.63 120.21,24.74 120.21,25.31 120.14,25.39 119.85,25.39 119.78,25.31 v1(119.78,25.2) 119.78,24.74 119.67,24.63 119.45,24.63 119.34,24.74 119.34,25.19 119.26,25.26 118.98,25.26 118.9,25.19 118.9,24.74 118.75,24.59 RH725.2
PCH_SPI_D3_1_R: length 8.6
  BOTTOM w0.109: UC6.7 103.63,27.12 104.16,26.58 105.57,26.58 106.16,26 106.16,24.11 106.62,23.64 106.62,23.43 v1(106.86,23.19) 108.13,21.92 RH729.2
PCH_SPI_D3_R1: length 25
  IN2 w0.081: v2(105.43,23.58) 106.79,23.58 106.99,23.38 110.83,23.38 v2(111.48,22.74) 111.57,22.82 114.16,22.82 115.12,23.78 115.12,24.57 v2(115.85,25.3)
  BOTTOM w0.109: RH725.1 116.57,24.59 v2(115.85,25.3) 115.83,25.33 115.83,25.85 v1(115.83,25.85) ; JSPI1.13 99.42,22.26 99.91,22.75 100.51,22.75 101.43,23.67 102.03,23.67 102.04,23.66 104.59,23.66 104.67,23.58 v2(105.43,23.58) ; v2(111.48,22.74) 111.12,22.38 RH184.1 110.6,22.38 109.89,21.67 109.31,21.67 RH729.1
PCH_TBT_PERST#: length 100.4
  TOP w0.109: RT500.1 114.02,60.81 113.61,60.4 113.61,59.24 113.81,59.04 114.44,59.04 RT621.1 114.87,57.24 115.29,56.82 v2(115.52,56.82) ; UH1.AM48 130.04,25.31 130.04,24.86 130.12,24.79 130.12,24.62 130.53,24.2 130.53,23.89 129.94,23.31 129.94,22.35 v2(129.99,22.3) 130.39,22.7 RT616.2 130.57,22.7 130.99,22.27 130.99,21.38 130.59,20.98 RT615.2 130.5,20.98 129.68,20.16 129.61,20.16 v1(129.58,20.12)
  IN1 w0.102: v2(129.99,22.3) 130.39,21.91 130.39,20.74 129.83,20.18 129.83,16.78 129.43,16.39 125.11,16.39 124.34,15.62 122.55,15.62 118.23,19.94 118.23,20.45 117.07,21.61 116.57,21.61 116.56,21.62 116.2,21.77 115.28,22.68 114.07,22.68 113.07,23.68 112.28,23.68 111.42,24.54 110.84,24.54 110.51,24.88 110.51,26.16 110.16,26.5 110.16,28.99 109.75,29.4 109.75,30.35 110.06,30.66 110.06,31.86 110.23,32.04 110.23,32.8 109.62,33.41 109.62,37.19 107.39,39.42 101.39,39.42 98.91,41.9 98.91,51.87 101.27,54.23 106.22,54.23 v2(107.53,55.54)
  IN2 w0.081: v2(115.52,56.82) 115.38,56.69 108.68,56.69 v2(107.53,55.54)
  BOTTOM w0.109: v2(129.99,22.3) 129.79,22.3 129.33,21.85 129.33,20.61 129.92,20.03 RT644.2
PCH_THERMTRIP#: length 9.2
  TOP w0.109: UH1.AD3 134.46,47.78 134.46,48.31 134.84,48.69 134.84,51.61 134.41,52.03 134.41,52.59 v1(134.39,52.62) 133.51,53.5 133.51,55.93 RH75.1
PCH_XDP_CLK_DN: length 155.4
  TOP w0.102: RH154.2 133.96,59.42 133.96,59.94 v2(134.26,60.24)
  IN2 w0.094: v2(243.91,17.63) 243.91,17.73 244.04,17.86 244.28,17.86 244.42,17.73 244.42,16.9 243.37,15.85 242.97,15.85 242.44,15.32 242.44,14.54 242.64,14.34 242.64,13.35 240.82,11.52 235.32,11.52 233.75,9.96 174.04,9.96 167.21,16.78 167.21,22.65 165.13,24.73 165.13,30.33 162.34,33.13 162.34,42.82 155.17,49.99 154.2,49.99 151.77,52.42 151.77,54.44 149.43,56.78 146.06,56.78 145.07,57.77 142.93,57.77 141.47,56.31 136.04,56.31 135.06,57.3 135.06,58.03 134.15,58.94 134.15,60.13 v2(134.26,60.24)
  BOTTOM w0.102: v2(243.91,17.63) 244.23,17.96 244.23,18.04 243.98,18.29 JXDP1.42
PCH_XDP_CLK_DN_R: length 12.3
  TOP w0.076: UH1.Y3 136.11,47.35 136.07,47.3 135.89,47.3 135.79,47.41 135.79,48.16 135.63,48.31 135.63,48.84 135.65,48.86 135.65,48.88
  TOP w0.102: RH154.1 133.95,57.98 133.95,57.74 v3(134.4,57.29) 135.34,56.35 135.34,55.04 135.37,55.01 135.37,54.46 135.34,54.42 135.34,52.14 135.65,51.82 135.65,48.88
PCH_XDP_CLK_DP: length 155.5
  TOP w0.102: v2(133.55,60.24) 133.77,60.02 133.77,59.49 RH155.2
  IN2 w0.094: v2(133.55,60.24) 133.95,59.83 133.95,58.86 134.86,57.95 134.86,57.21 135.96,56.12 141.55,56.12 143.01,57.58 144.99,57.58 145.98,56.59 149.34,56.59 151.58,54.36 151.58,52.34 154.12,49.79 155.09,49.79 162.14,42.73 162.14,33.05 164.94,30.25 164.94,24.65 167.02,22.57 167.02,16.7 173.96,9.76 233.83,9.76 235.4,11.33 240.9,11.33 242.84,13.27 242.84,14.42 242.64,14.62 242.64,15.24 243.05,15.65 243.45,15.65 244.61,16.82 244.61,17.42 v2(244.83,17.63)
  BOTTOM w0.102: JXDP1.40 244.58,18.25 244.42,18.09 244.42,17.99 244.77,17.63 v2(244.83,17.63)
PCH_XDP_CLK_DP_R: length 12.4
  TOP w0.076: 135.46,48.88 135.46,48.86 135.48,48.84 135.48,48.25 135.63,48.1 135.63,47.35 135.83,47.15 135.92,47.15 UH1.Y4
  TOP w0.102: 135.46,48.88 135.46,51.74 135.14,52.06 v3(135.14,54.71) 135.14,56.27 134.5,56.92 134.44,56.92 134.03,57.33 134.03,57.39 133.76,57.66 133.76,57.95 RH155.1
PCH_XDP_PRDY#: length 222
  TOP w0.102: v2(130.02,50.14) 130.25,50.14 130.55,49.84 130.55,48.96 130.61,48.9 130.61,48.37 130.4,48.16 130.4,47.41 130.44,47.37 130.44,46.92 130.41,46.89 UH1.AM5
  TOP w0.109: v2(265.91,6.49) 265.91,6.15 265.82,6.06 264.45,6.06 264.17,6.34 264.17,7.22 265.58,8.63 265.58,11.89 263.44,14.04 v2(261.71,14.04) 261.29,14.46 258.8,14.46 258.32,13.97 CC337.1
  IN3 w0.081: v2(265.91,6.49) 265.91,6.72 265.19,7.44 261.82,7.44 260.59,6.21 256.94,6.21 254.42,8.73 246.74,8.73 242.07,4.07 167.97,4.07 166.94,5.1 158.26,5.1 154.53,8.84 149.4,8.84 147.89,10.35 141.35,10.35 140.5,11.2 133.68,11.2 133.08,11.8 130.63,11.8 129.69,12.74 128.9,12.74 128.39,13.25 123.97,13.25 119.02,18.2 119.02,20.51 118.44,21.09 118.44,23.97 119.87,25.41 119.87,27.5 119.04,28.33 119.04,29.52 119.49,29.97 119.49,34.97 119.75,35.22 119.75,36.89 120.05,37.19 120.05,44.47 120.6,45.03 120.6,46.62 121.25,47.26 122.58,47.26 123.73,48.4 125.67,48.4 126.78,49.52 128.09,49.52 128.79,50.22 129.94,50.22 v2(130.02,50.14)
  BOTTOM w0.109: RC314.2 260.21,13.26 260.58,13.64 261.31,13.64 v2(261.71,14.04)
PCH_XDP_PREQ#: length 218.6
  TOP w0.102: UH1.AL2 130.82,48.04 130.99,48.21 130.99,50.19 130.3,50.88
  TOP w0.109: v2(265.33,6.61) 265.33,6.72 266.41,7.8 266.41,12.23 263.36,15.28 v1(261.46,15.28) 260.46,15.28 v2(260.3,15.45) 259.53,16.21 259.16,16.21 259.09,16.27 CC338.1 ; 130.3,50.88 v2(129.98,50.88)
  IN3 w0.081: v2(265.33,6.61) 264.84,7.1 264.04,7.1 263.92,7.22 261.92,7.22 260.69,5.98 256.85,5.98 254.32,8.51 246.87,8.51 242.21,3.84 167.88,3.84 166.84,4.88 158.13,4.88 154.4,8.61 149.31,8.61 147.8,10.12 138.83,10.12 137.97,10.98 133.58,10.98 132.99,11.57 130.54,11.57 129.58,12.53 128.81,12.53 128.3,13.04 123.85,13.04 121.37,15.52 120.14,15.52 119.84,15.83 119.84,17.05 118.79,18.11 118.79,20.41 118.21,20.99 118.21,24.01 119.26,25.07 119.26,27.78 118.83,28.21 118.83,29.62 119.3,30.09 119.3,35.04 119.56,35.3 119.56,36.96 119.86,37.27 119.86,44.52 120.43,45.1 120.43,46.72 121.23,47.51 122.45,47.51 123.58,48.64 125.64,48.64 126.79,49.8 127.93,49.8 129.01,50.88 v2(129.98,50.88)
  BOTTOM w0.109: v2(260.3,15.45) 260.17,15.58 RC315.2
PCI_CLK_LPC1: length 6.1
  TOP w0.109: v2(125.41,31.96) UH1.BB34
  BOTTOM w0.109: RH99.1 120.97,32.64 v1(121.74,31.87) 125.33,31.87 v2(125.41,31.96)
PCIE_PRX_C_DTX_N5: length 2.4
  TOP w0.102: UL1.39 151.78,136.19 151.67,136.08 v3(151.67,135.68) 151.67,135.29 151.57,135.19 151.57,135.04 CL2.1
PCIE_PRX_C_DTX_N6: length 3.3
  BOTTOM w0.102: CR206.2 22.98,13.43 22.34,13.43 21.98,13.79 21.93,13.79 21.52,14.2 21.52,14.24 21.42,14.33 21.24,14.33 21.14,14.23 UR1.11
PCIE_PRX_C_DTX_P5: length 2.4
  TOP w0.102: CL1.1 151.38,135.06 151.38,135.26 151.44,135.33 151.44,136.12 151.38,136.19 UL1.38
PCIE_PRX_C_DTX_P6: length 3.3
  BOTTOM w0.102: UR1.10 21.14,14.63 21.24,14.52 21.52,14.52 v3(21.88,14.16) 22.42,13.62 22.93,13.62 CR204.2
PCIE_PRX_C_TTX_N1: length 6.1
  BOTTOM w0.076: 41.16,41.51 41.14,41.51 41.12,41.49 40.92,41.49 40.41,42 40.41,42.6 40.17,42.83 UT1.V22
  BOTTOM w0.102: 41.16,41.51 42.81,41.51 43.65,40.67 43.65,40.05 43.61,40.01 43.61,39.68 CT7.2
PCIE_PRX_C_TTX_N2: length 4.9
  BOTTOM w0.076: 38.74,41.89 38.73,41.9 38.7,41.9 38.56,42.04 38.56,42.61 38.33,42.84 UT1.P22
  BOTTOM w0.102: CT9.2 41.07,39.68 41.07,39.84 40.71,40.21 40.43,40.21 38.74,41.89
PCIE_PRX_C_TTX_N3: length 4.7
  BOTTOM w0.076: 36.65,41.51 36.63,41.52 36.63,41.55 36.57,41.61 36.38,41.8 36.38,42.11 36.25,42.25 36.25,42.59 36.49,42.83 UT1.K22
  BOTTOM w0.102: CT128.2 38.31,39.66 38.31,39.8 38.22,39.89 37.86,39.89 v3(37.43,40.32) 37.13,40.62 37.13,41.03 36.65,41.51
PCIE_PRX_C_TTX_N4: length 4.5
  BOTTOM w0.076: 34.78,41.72 34.74,41.72 34.57,41.89 34.57,42.11 34.43,42.26 34.43,42.62 34.65,42.84 UT1.F22
  BOTTOM w0.102: 34.78,41.72 35.05,41.72 35.16,41.62 35.16,41.3 35.31,41.15 35.31,41.09 35.72,40.68 35.77,40.68 35.91,40.55 35.91,40.12 35.79,40 35.79,39.68 CT130.2
PCIE_PRX_C_TTX_P1: length 6.2
  BOTTOM w0.076: UT1.V23 40.17,42.54 40.1,42.61 39.99,42.61 39.94,42.56 39.94,42.22 40.02,42.14 40.18,42.14 40.26,42.06 40.26,41.94 40.86,41.33 41.12,41.33 41.14,41.32 41.16,41.32
  BOTTOM w0.102: CT6.2 43.42,39.69 v3(43.42,40.34) 43.42,40.62 42.73,41.32 41.16,41.32
PCIE_PRX_C_TTX_P2: length 4.9
  BOTTOM w0.076: UT1.P23 38.33,42.56 38.28,42.61 38.17,42.61 38.11,42.56 38.11,42.28 38.59,41.8 38.59,41.77 38.61,41.76
  BOTTOM w0.102: CT8.2 40.88,39.69 40.88,39.76 40.63,40.02 40.35,40.02 38.61,41.76
PCIE_PRX_C_TTX_P3: length 4.7
  BOTTOM w0.076: UT1.K23 36.49,42.58 36.55,42.64 36.62,42.64 36.71,42.55 36.71,42.26 36.54,42.09 36.54,41.86 36.74,41.66 36.77,41.66 36.78,41.64
  BOTTOM w0.102: 36.78,41.64 37.32,41.11 37.32,40.76 37.99,40.08 38.3,40.08 38.5,39.88 38.5,39.71 CT127.2
PCIE_PRX_C_TTX_P4: length 4.5
  BOTTOM w0.076: 34.78,41.91 34.72,41.97 34.72,42.08 34.87,42.23 34.87,42.6 34.82,42.65 34.72,42.65 34.65,42.58 UT1.F23
  BOTTOM w0.102: CT129.2 35.99,39.69 35.99,39.93 36.1,40.04 36.1,40.63 v3(35.67,41.05) 35.35,41.37 35.35,41.69 35.13,41.91 34.78,41.91
PCIE_PRX_DTX_N5: length 115.4
  TOP w0.076: UH1.F20 142.66,39.32 142.59,39.39 142.59,39.5 142.83,39.74 143.6,39.74 144.23,40.38 145.04,40.38 145.2,40.22 145.76,40.22 146.01,40.48 146.95,40.48 147.34,40.87 147.37,40.87 147.38,40.88
  TOP w0.102: v2(150.4,41.92) 150.23,41.75 150.23,41.5 149.9,41.16 147.66,41.16 147.38,40.88 ; CL2.2 151.56,133.77 151.56,132.63 v2(151.82,132.37)
  IN1 w0.102: v2(150.4,41.92) 150.11,42.22 150.11,42.37 150.32,42.58 151.16,42.58 152.35,43.77 152.35,54.22 155.62,57.5 156.49,57.5 157.33,58.33 157.33,64.68 155.95,66.05 155.95,67.27 155.17,68.06 155.17,71.3 154.76,71.71 154.76,73.74 154.85,73.83 154.85,74.55 153.21,76.19 153.21,76.65 152.69,77.17 152.69,92.95 156,96.27 156,99.04 153.66,101.39 153.66,102.24 148.31,107.58 148.31,108.56 146.95,109.92 146.95,113.5 147.85,114.4 147.85,121.53 148.23,121.91 148.23,123.92 151.58,127.26 151.58,132.12 v2(151.82,132.37)
PCIE_PRX_DTX_N6: length 164.6
  TOP w0.102: UH1.K21 v2(140.54,39.38)
  IN2 w0.094: v2(26.32,14.19) 26.11,13.98 25.97,13.98 25.86,14.09 25.86,15.12 25.52,15.46 22.06,15.46 21.6,15.92 21.6,17.31 23.58,19.29 23.58,20.61 24.14,21.17 30.96,21.17 31.67,21.89 33.08,21.89 33.89,21.07 37.47,21.07 38.49,22.09 38.49,22.77 38.87,23.15 40.24,23.15 40.66,22.74 42.6,22.74 44.8,20.53 49.97,20.53 50.15,20.72 56.19,20.72 58.54,18.37 61.31,18.37 62.7,16.98 65.95,16.98 66.8,17.84 67.7,17.84 69.13,19.27 75.42,19.27 76.51,20.36 76.94,20.36 80.83,24.25 81.58,24.25 81.96,24.63 83.17,24.63 84.32,25.78 87.49,25.78 89.54,27.83 93.33,27.83 95.64,30.14 95.64,30.72 97.05,32.13 97.47,32.13 102.1,36.76 102.1,37.41 104.69,40.01 108.85,40.01 111.99,43.14 111.99,47.93 113.74,49.69 116.23,49.69 117.39,50.85 125.91,50.85 127.39,49.36 127.39,48.45 128.57,47.27 131.95,47.27 132.65,46.56 133.75,46.56 135.12,45.19 138.32,45.19 138.65,44.87 138.65,43.6 138.37,43.32 138.37,42.38 138.67,42.08 138.67,41.41 138,40.73 138,40.25 138.27,39.97 140.72,39.97 140.81,39.88 140.81,39.66 v2(140.54,39.38)
  BOTTOM w0.102: v2(26.32,14.19) 26.02,13.89 26.02,13.78 25.68,13.45 25.27,13.45 25.23,13.41 24.65,13.41 24.61,13.45 24.25,13.45 CR206.1
PCIE_PRX_DTX_N7: length 85.6
  TOP w0.102: v2(140.82,38.27) 141.08,38.01 141.08,37.59 UH1.L24
  IN1 w0.102: v2(140.82,38.27) 140.82,37.61 141.09,37.33 141.69,37.33 142.03,37.67 142.03,39.77 142.19,39.92 142.19,41.67 142.31,41.8 142.31,42.94 141.04,44.21 141.04,48.38 141.45,48.78 141.45,51.25 141.15,51.55 141.15,52.55 142.15,53.56 142.15,59.41 141.49,60.08 139.16,60.08 135.67,63.57 134.27,63.57 132.57,65.27 131.78,65.27 129.79,67.26 129.79,71.59 129.26,72.12 129.26,73.01 127.69,74.59 127.29,74.59 126.57,75.31 126.57,77.09 127.79,78.31 127.79,79.49 128.24,79.95 128.24,89.73 127.37,90.6 127.37,94.89 124.66,97.6 124.66,98.59 123.88,99.38 122.88,99.38 121.24,101.02 121.23,102.61 v2(121.49,102.87)
  BOTTOM w0.102: v2(121.49,102.87) 121.13,103.24 121.13,103.96 121.26,104.09 JNGFF1.35
PCIE_PRX_DTX_N8: length 94
  TOP w0.102: v2(143.08,38.04) 143.01,37.97 143.01,37.38 UH1.F24
  IN1 w0.102: v2(155.83,104.41) 155.83,104.14 155.71,104.02 155.5,104.02 155.4,104.11 155.4,104.71 155.53,104.84 155.98,104.84 156.54,104.28 156.54,103.58 157.75,102.37 157.75,101.55 158.27,101.03 158.27,96.24 154.29,92.27 154.29,78.42 155.45,77.26 156.06,77.26 157.54,75.78 157.54,71.04 158.7,69.89 158.7,67.86 159.11,67.44 159.11,66.28 160.33,65.06 160.33,61.36 160.03,61.06 160.03,59.63 159.58,59.17 159.58,53.9 157.72,52.05 157.66,51.99 157.66,49.59 156.12,48.05 156.12,42.37 153.94,40.19 153.94,38.32 152.3,36.68 144.77,36.68 144.34,36.26 143.67,36.26 142.6,37.33 142.6,37.74 142.91,38.04 v2(143.08,38.04)
  BOTTOM w0.102: JNGFF2.35 155.74,106.33 155.59,106.18 155.59,105.87 155.44,105.73 155.44,104.79 v2(155.83,104.41)
PCIE_PRX_DTX_N9: length 199.8
  TOP w0.102: v2(142.43,30.94) 142.35,30.94 142.21,31.08 142.21,31.36 UH1.G36
  IN1 w0.102: v2(142.43,30.94) 142.76,30.94 142.91,31.09 143.44,31.09 143.84,30.7 144.25,30.7 145.22,29.73 149.16,29.73 149.48,29.42 152.42,29.42 159.18,22.66 159.18,22.15 173.29,8.04 240.6,8.04 245.15,12.6 265.97,12.6 266.81,11.75 296.65,11.75 305.02,20.13 305.02,22.36 310.88,28.22 310.88,28.65 313.22,30.99 314.08,30.99 v2(314.48,31.38)
  BOTTOM w0.102: JNGFF3.5 318.53,31.04 318.38,30.89 316.78,30.89 316.67,31 314.85,31 v2(314.48,31.38)
PCIE_PRX_DTX_N10: length 207.5
  TOP w0.094: UH1.K37 140.67,30.98 v2(140.31,30.63)
  IN1 w0.102: v2(140.31,30.63) 140.53,30.41 140.53,30.28 141.67,29.14 141.67,27.27 143.75,25.19 144.32,25.19 145.62,26.48 149.1,26.48 169.56,6.02 241.44,6.02 246.04,10.62 256.38,10.62 257.22,9.78 298.12,9.78 307.45,19.12 310.73,19.12 311.67,20.06 312.7,20.06 315.75,23.1 315.75,27.45 315.3,27.89 314.75,27.89 v2(314.48,28.17)
  BOTTOM w0.102: JNGFF3.17 318.55,28.04 318.41,27.9 315.54,27.9 315.47,27.98 314.66,27.98 v2(314.48,28.17)
PCIE_PRX_DTX_N11: length 197.3
  TOP w0.094: UH1.G38 142.34,29.88 v2(142.51,29.72)
  IN1 w0.102: v2(142.51,29.72) 142.66,29.72 142.96,30.02 143.97,30.02 145.58,28.41 152.58,28.41 158.21,22.78 158.21,19.32 170.13,7.4 240.81,7.4 245.41,12 256.95,12 257.8,11.16 296.94,11.16 307.07,21.28 307.88,21.28 311.49,24.89 313.53,24.89 v2(313.91,25.28)
  BOTTOM w0.102: v2(313.91,25.28) 314.29,24.9 318.47,24.9 318.61,25.04 JNGFF3.29
PCIE_PRX_DTX_N12: length 195.5
  TOP w0.094: v2(142.69,28.11) 142.58,28 142.31,28 UH1.H42
  IN1 w0.102: v2(142.69,28.11) 142.69,28.27 142.88,28.46 143.45,28.46 144.17,27.74 145,27.74 145.3,27.45 151.51,27.45 153.11,25.85 153.11,23.32 169.81,6.62 241.18,6.62 245.78,11.22 256.63,11.22 257.47,10.38 297.3,10.38 307.34,20.41 309.48,20.41 310.21,21.14 312.31,21.14 v2(312.62,20.83)
  BOTTOM w0.102: v2(312.62,20.83) 312.94,21.15 314.96,21.15 315.56,21.74 318.37,21.74 318.57,21.54 JNGFF3.43
PCIE_PRX_DTX_N13: length 113.3
  TOP w0.102: UH1.C45 144.49,26.84 144.49,27.05 v2(144.31,27.23)
  BOTTOM w0.102: v2(144.31,27.23) 144.49,27.23 145.64,28.38 151.63,28.38 152.4,29.15 152.4,44.4 152.98,44.99 152.98,48.39 151.71,49.66 151.71,51.31 151.27,51.75 151.27,54.23 149.86,55.64 146.52,55.64 144.62,57.55 142.12,57.55 140.41,59.26 138.77,59.26 136.56,61.47 135.22,61.47 133.52,63.17 127.25,63.17 126.3,64.12 125.89,64.12 125.23,64.78 125.23,65.15 123.3,67.08 123.3,68.55 123.07,68.78 123.07,74.74 122.47,75.34 122.47,76.67 119.74,79.39 118.72,79.39 116.24,81.87 v3(116.24,82.55) 116.24,84.83 117.3,85.89 117.3,91.9 118.56,93.17 118.56,93.5 119.45,94.39 122.88,94.39 124.19,95.7 128.84,95.7 129.09,95.95 129.09,96.62 129.02,96.69 128.84,96.69 128.78,96.75 JNGFF6.43
PCIE_PRX_DTX_N14: length 117.9
  TOP w0.102: v2(143.9,26.68) 143.9,26.46 144.1,26.26 UH1.D46
  BOTTOM w0.102: JNGFF6.29 132.28,96.72 132.43,96.58 132.43,96.32 131.9,95.79 130.23,95.79 129.32,94.87 124.84,94.87 118.29,88.33 118.29,85.6 117.07,84.38 117.07,83.17 v3(117.96,82.29) 123.25,76.99 123.25,75.67 123.86,75.07 123.86,69.11 124.09,68.87 124.09,67.45 126.06,65.48 126.46,65.48 127.25,64.7 127.25,64.29 127.58,63.96 133.85,63.96 135.51,62.3 136.95,62.3 139.16,60.09 141.06,60.09 142.77,58.37 144.91,58.37 146.85,56.43 150.8,56.43 152.09,55.13 152.09,52.61 152.79,51.91 152.79,50.13 153.82,49.1 153.82,44.67 153.3,44.15 153.3,28.34 152.99,28.04 152.15,27.19 146.17,27.19 144.17,25.2 143.51,25.2 143.13,25.57 143.13,26.17 143.43,26.47 143.69,26.47 v2(143.9,26.68)
PCIE_PRX_DTX_N15: length 118.9
  TOP w0.102: UH1.F44 143.05,27.51 143.24,27.51 v2(143.41,27.68)
  BOTTOM w0.102: v2(143.41,27.68) 143.37,27.71 142.58,27.71 142.28,27.41 142.28,25.46 142.98,24.76 144.41,24.76 145.17,25.52 146.2,25.52 147.21,26.52 152.83,26.52 154.06,27.75 154.06,43.99 154.61,44.54 154.61,49.44 153.62,50.43 153.62,52.34 152.73,53.23 152.73,55.51 151.22,57.03 147.1,57.03 144.86,59.26 143.22,59.26 141.19,61.29 139.33,61.29 137.68,62.94 135.72,62.94 134.1,64.56 129.32,64.56 128.09,65.79 127.82,65.79 127.48,65.79 127.19,66.08 126.3,66.08 124.72,67.66 124.72,69.08 124.45,69.35 124.45,75.32 123.85,75.92 123.85,79.06 122.95,79.96 122.95,81.45 122.29,82.11 122.29,82.31 122.32,82.35 122.32,82.93 122.29,82.97 122.29,84.18 123.47,85.36 123.47,88.18 124.09,88.8 124.09,91.07 127.24,94.22 129.63,94.22 130.33,94.93 134.11,94.93 135.38,96.19 135.38,96.61 135.28,96.71 JNGFF6.17
PCIE_PRX_DTX_N16: length 126.9
  TOP w0.102: v2(140.98,29.17) UH1.L41
  BOTTOM w0.102: JNGFF6.5 138.28,96.65 138.36,96.57 138.36,96.14 137.73,95.51 135.62,95.51 134.24,94.12 130.57,94.12 130.07,93.63 127.49,93.63 124.7,90.84 124.7,88.16 124.17,87.62 124.17,85.06 123.43,84.32 v3(123.43,83.56) 123.43,82.69 124.39,81.74 124.39,80.22 124.45,80.16 124.45,76.17 125.13,75.48 125.13,70.83 125.78,70.17 125.78,68.34 127.73,66.39 128.36,66.39 129.53,65.22 135.45,65.22 136.46,64.21 137.37,64.21 138.9,62.69 141.19,62.69 142.71,61.17 143.8,61.17 146.09,58.88 148.47,58.88 149.72,57.62 151.52,57.62 153.19,55.96 154.48,55.96 156.11,54.33 156.11,44.47 154.82,43.18 154.82,27.11 153.61,25.9 148.07,25.9 146.43,24.26 145.25,24.26 145.11,24.12 142.59,24.12 141.63,25.08 141.63,29.22 141.24,29.61 140.8,29.61 140.6,29.41 140.6,29.02 140.72,28.9 140.87,28.9 140.98,29 v2(140.98,29.17)
PCIE_PRX_DTX_N17: length 266.6
  TOP w0.102: v2(140.45,28.33) 140.63,28.51 140.86,28.51 140.97,28.39 UH1.K43
  IN1 w0.102: v2(365.86,23.45) 366.05,23.45 366.2,23.29 366.2,23.13 366.05,22.97 359.8,22.97 356.14,26.64 324.38,26.64 314.75,17 314.32,17 309.67,12.36 301.32,12.36 298.33,9.37 257.06,9.37 256.21,10.22 246.29,10.22 241.69,5.62 169.39,5.62 149.41,25.6 145.44,25.6 144.63,24.79 143.41,24.79 141.15,27.05 141.15,27.88 140.93,28.1 140.68,28.1 v2(140.45,28.33)
  BOTTOM w0.102: v2(365.86,23.45) 366.02,23.45 366.18,23.29 366.18,19.42 369.69,15.9 370.56,15.9 371.59,14.87 372.23,14.87 373.9,13.2 373.9,11.1 373.75,10.95 JNGFF4.43
PCIE_PRX_DTX_N18: length 271.9
  TOP w0.094: UH1.P41 138.81,28.82 v2(138.66,28.97)
  IN1 w0.102: v2(138.66,28.97) 138.43,29.2 138.24,29.2 138.14,29.1 138.14,26.59 139.58,25.15 139.58,22.9 140.8,21.68 146.57,21.68 148.68,19.57 148.68,19.37 149.22,18.82 153.62,18.82 168.61,3.84 242.54,3.84 247.14,8.44 255.47,8.44 256.32,7.59 299.54,7.59 302.52,10.58 312.26,10.58 326.54,24.85 355.19,24.85 358.93,21.12 367.91,21.12 368.17,20.85 368.17,20.64 v2(368.46,20.35)
  BOTTOM w0.102: v2(368.46,20.35) 368.18,20.07 368.18,19.54 369.94,17.78 370.64,17.78 372.14,16.29 372.78,16.29 374.84,14.23 375.96,14.23 377.1,13.09 377.1,11.1 377.25,10.95 JNGFF4.29
PCIE_PRX_DTX_N19: length 271.6
  TOP w0.102: UH1.M44 139.81,27.5 139.24,27.5 v2(139.19,27.44)
  IN1 w0.102: v2(139.19,27.44) 139.19,27.63 139.1,27.71 138.92,27.71 138.79,27.58 138.79,26.95 139.99,25.75 140.41,25.75 142.55,23.6 146.09,23.6 147.3,22.39 147.3,21.87 149.08,20.09 153.2,20.09 168.87,4.43 242.27,4.43 246.87,9.03 255.72,9.03 256.56,8.19 299.01,8.19 302,11.17 312,11.17 326.27,25.45 355.53,25.45 359.2,21.79 369.86,21.79 370.13,21.52 370.13,21.26 v2(370.39,20.99)
  BOTTOM w0.102: v2(370.39,20.99) 370.13,20.73 370.13,20.3 372.75,17.68 373.36,17.68 375.01,16.03 377.21,16.03 380.09,13.15 380.09,11.1 380.25,10.95 JNGFF4.17
PCIE_PRX_DTX_N20: length 279.4
  TOP w0.102: UH1.R35 138.81,31.81 v2(139.09,31.53)
  IN1 w0.102: v2(372.01,23.53) 372.01,22.82 371.38,22.19 359.42,22.19 355.76,25.85 325.33,25.85 311.05,11.58 301.65,11.58 298.67,8.59 256.73,8.59 255.89,9.44 246.68,9.44 242.08,4.84 169.07,4.84 150,23.91 143.03,23.91 139.61,27.33 139.61,29.07 138.41,30.27 138.41,31.13 138.62,31.33 138.89,31.33 v2(139.09,31.53)
  BOTTOM w0.102: v2(372.01,23.53) 371.97,23.5 371.97,20.76 375.51,17.22 377.71,17.22 380.63,14.3 381.56,14.3 383.09,12.76 383.09,11.1 383.25,10.95 JNGFF4.5
PCIE_PRX_DTX_N21: length 241.5
  TOP w0.102: UH1.T43 137.62,28.1 v2(137.43,28.29)
  IN1 w0.102: v2(321.66,18.38) 321.66,18 321.89,17.77 321.89,17.36 321.34,16.81 320.21,16.81 313.19,9.79 303.2,9.79 300.21,6.81 288.54,6.81 287.62,5.89 256.91,5.89 255.15,7.65 247.51,7.65 242.91,3.05 168.26,3.05 165.94,5.37 159.74,5.37 151.66,13.45 151.66,15.53 149.53,17.67 149.19,17.67 145.95,20.91 142.98,20.91 142.06,19.99 140.95,19.99 140.05,20.89 140.05,21.45 138.76,22.75 138.76,24.84 136.73,26.86 136.73,27.88 136.96,28.11 137.25,28.11 v2(137.43,28.29)
  BOTTOM w0.102: v2(321.66,18.38) 321.41,18.38 321.16,18.64 321.16,31.54 321.99,32.37 321.99,35.24 321.5,35.74 321.5,42.38 320.72,43.16 320.72,47.03 320.4,47.35 318.86,47.35 JNGFF5.41
PCIE_PRX_DTX_N22: length 248.8
  TOP w0.102: UH1.U40 137.34,29.42 137.15,29.42 v2(136.86,29.71)
  IN1 w0.102: v2(136.86,29.71) 136.68,29.53 136.47,29.53 136.2,29.25 136.2,26.59 138.2,24.59 138.2,22.59 139.47,21.33 139.47,20.44 140.6,19.31 144.76,19.31 146.3,17.77 147.33,17.77 149.03,16.07 149.84,16.07 150.91,15 150.91,13.28 159.91,4.29 166.17,4.29 168,2.46 243.25,2.46 247.85,7.06 254.9,7.06 257.78,4.18 300.34,4.18 305.36,9.2 313.46,9.2 320.37,16.11 322.14,16.11 322.92,16.89 322.92,17.19 v2(323.12,17.39)
  BOTTOM w0.102: JNGFF5.29 319.8,50.35 319.8,50.35 320.63,50.35 321.32,49.66 321.32,43.41 322.11,42.62 322.11,36.01 322.59,35.53 322.59,31.99 322.18,31.58 322.18,18.97 322.88,18.27 322.88,17.62 v2(323.12,17.39)
PCIE_PRX_DTX_N23: length 253.5
  TOP w0.102: v2(135.69,28.29) 135.91,28.07 UH1.W43
  IN1 w0.102: v2(323.88,18.86) 323.68,18.66 323.68,18.41 323.9,18.19 323.9,16.79 322.45,15.35 320.57,15.35 313.42,8.19 305.85,8.19 301.24,3.59 257.53,3.59 254.66,6.46 248.13,6.46 243.53,1.86 167.72,1.86 166.52,3.06 159.78,3.06 149.01,13.84 149.01,14.38 147.37,16.02 145.04,16.02 143.02,18.04 140.91,18.04 138.82,20.13 138.82,21.25 137.56,22.52 137.56,24.41 135.96,26.01 135.14,26.01 134.78,26.37 134.78,27.79 135.11,28.12 135.53,28.12 v2(135.69,28.29)
  BOTTOM w0.102: JNGFF5.17 320.89,53.35 321.92,52.33 321.92,43.88 322.76,43.05 322.76,36.33 323.2,35.88 323.2,19.89 323.67,19.42 323.67,19.07 v2(323.88,18.86)
PCIE_PRX_DTX_N24: length 262.5
  TOP w0.102: UH1.Y40 135.95,29.83 v2(135.57,29.83)
  IN1 w0.102: v2(325.53,17.92) 325.3,17.69 325.3,16.98 322.93,14.62 320.98,14.62 313.96,7.6 306.09,7.6 301.49,2.99 257.29,2.99 254.41,5.87 248.41,5.87 243.81,1.27 167.26,1.27 166.29,2.24 157.98,2.24 143.82,16.39 141.04,16.39 138.7,18.74 138.7,19.38 137.24,20.84 137.24,21.34 136.44,22.14 136.44,24.64 135.65,25.42 134.87,25.42 134.03,26.26 134.03,28.01 134.67,28.65 134.67,29.36 134.95,29.65 135.39,29.65 v2(135.57,29.83)
  BOTTOM w0.102: v2(325.53,17.92) 325.31,18.14 325.31,18.48 324.84,18.95 324.84,21.16 323.81,22.19 323.81,34.66 325.44,36.28 325.44,38.78 323.37,40.85 323.37,43.28 322.51,44.13 322.51,54.51 320.67,56.35 319.73,56.35 JNGFF5.5
PCIE_PRX_DTX_P5: length 115.4
  TOP w0.076: 147.25,41.02 147.24,41 147.24,40.98 146.89,40.63 145.95,40.63 145.69,40.38 145.26,40.38 145.11,40.53 144.17,40.53 143.53,39.89 142.77,39.89 142.44,39.56 142.44,39.2 UH1.G20
  TOP w0.102: v2(149.69,41.92) 149.97,41.92 150.04,41.85 150.04,41.58 149.82,41.35 147.58,41.35 147.25,41.02 ; v2(151.11,132.37) 151.37,132.63 151.37,133.77 CL1.2
  IN1 w0.102: v2(151.11,132.37) 151.39,132.08 151.39,127.34 148.88,124.83 148.04,123.99 148.04,121.99 147.66,121.61 147.66,114.48 146.76,113.58 146.76,109.84 148.13,108.48 148.13,107.5 153.47,102.16 153.47,101.31 155.82,98.96 155.82,96.35 152.5,93.03 152.5,77.09 153.02,76.57 153.02,76.11 154.66,74.48 154.66,73.9 154.57,73.82 154.57,71.63 154.98,71.22 154.98,67.98 155.77,67.2 155.77,65.98 157.14,64.61 157.14,58.41 156.41,57.68 155.55,57.68 152.16,54.3 152.16,43.84 151.08,42.76 150.24,42.76 149.92,42.45 149.92,42.16 v2(149.69,41.92)
PCIE_PRX_DTX_P6: length 164.6
  TOP w0.094: v2(141.18,39.39) 141.18,39.25 141.5,38.94 UH1.J21
  IN2 w0.094: v2(25.37,14.19) 25.66,14.48 25.66,15.04 25.44,15.26 21.98,15.26 21.4,15.84 21.4,17.39 23.38,19.37 23.38,20.69 24.06,21.37 30.88,21.37 31.59,22.08 33.16,22.08 33.98,21.27 37.39,21.27 38.29,22.17 38.29,22.85 38.79,23.35 40.33,23.35 40.74,22.93 42.68,22.93 44.88,20.73 49.89,20.73 50.07,20.91 56.27,20.91 58.62,18.56 61.39,18.56 62.78,17.18 65.87,17.18 66.72,18.03 67.62,18.03 69.05,19.47 75.34,19.47 76.43,20.56 76.86,20.56 80.75,24.44 81.5,24.44 81.88,24.82 83.09,24.82 84.24,25.98 87.41,25.98 89.46,28.03 93.25,28.03 95.45,30.22 95.45,30.81 96.97,32.33 97.39,32.33 101.91,36.84 101.91,37.5 104.61,40.2 108.77,40.2 111.79,43.23 111.79,48.01 113.66,49.88 116.15,49.88 117.31,51.04 125.99,51.04 127.58,49.45 127.58,48.53 128.65,47.46 132.03,47.46 132.73,46.76 133.83,46.76 135.2,45.39 138.41,45.39 138.84,44.95 138.84,43.52 138.56,43.24 138.56,42.46 138.87,42.16 138.87,41.33 138.19,40.65 138.19,40.33 138.35,40.16 140.8,40.16 141,39.96 141,39.57 v2(141.18,39.39)
  BOTTOM w0.102: v2(25.37,14.19) 25.75,14.19 25.83,14.11 25.83,13.86 25.6,13.64 v3(24.94,13.64) 24.22,13.64 CR204.1
PCIE_PRX_DTX_P7: length 85.6
  TOP w0.102: v2(141.48,38.29) 141.27,38.08 141.27,37.6 UH1.J24
  IN1 w0.102: v2(141.48,38.29) 141.48,37.92 141.41,37.85 141.27,37.85 141.19,37.94 141.09,37.94 141,37.85 141,37.69 141.17,37.52 141.61,37.52 141.85,37.75 141.85,39.84 142,40 142,41.75 142.13,41.88 142.13,42.86 140.86,44.13 140.86,48.45 141.26,48.86 141.26,51.17 140.96,51.47 140.96,52.63 141.97,53.64 141.97,59.33 141.41,59.89 139.08,59.89 135.59,63.38 134.19,63.38 132.49,65.08 131.71,65.08 129.6,67.18 129.6,71.51 129.07,72.04 129.07,72.93 127.61,74.4 127.21,74.4 126.38,75.23 126.38,77.17 127.6,78.39 127.6,79.57 128.05,80.02 128.05,89.65 127.18,90.52 127.18,94.82 124.47,97.53 124.47,98.52 123.8,99.19 122.81,99.19 121.05,100.95 121.04,102.47 v2(120.65,102.87)
  BOTTOM w0.102: JNGFF1.33 120.75,104.14 120.94,103.96 120.94,103.16 v2(120.65,102.87)
PCIE_PRX_DTX_P8: length 93.9
  TOP w0.102: UH1.G24 v2(142.42,38.08)
  IN1 w0.102: v2(142.42,38.08) 142.42,37.25 143.59,36.07 144.42,36.07 144.84,36.49 152.38,36.49 154.12,38.24 154.12,40.11 156.31,42.29 156.31,47.97 157.85,49.51 157.85,51.91 159.76,53.83 159.76,59.1 160.22,59.55 160.22,60.98 160.52,61.28 160.52,65.14 159.3,66.36 159.3,67.52 158.88,67.93 158.88,69.97 157.73,71.12 157.73,75.86 156.14,77.45 155.53,77.45 154.48,78.5 154.48,92.19 158.45,96.16 158.45,101.11 157.93,101.63 157.93,102.45 156.73,103.66 156.73,104.36 156.06,105.03 155.46,105.03 155.21,104.78 155.21,104.71 v2(154.91,104.41)
  BOTTOM w0.102: v2(154.91,104.41) 155.25,104.75 155.25,105.81 155.39,105.95 155.39,106.13 155.24,106.29 JNGFF2.33
PCIE_PRX_DTX_P9: length 199.8
  TOP w0.102: v2(143.09,30.42) 143.01,30.51 UH1.F36
  IN1 w0.102: v2(314.48,30.44) 314.11,30.8 313.29,30.8 311.07,28.58 311.07,28.14 305.21,22.28 305.21,20.05 296.72,11.56 266.73,11.56 265.89,12.41 245.23,12.41 240.68,7.85 173.21,7.85 158.99,22.07 158.99,22.58 152.34,29.23 149.4,29.23 149.08,29.55 145.14,29.55 144.18,30.51 143.76,30.51 143.36,30.9 142.98,30.9 142.86,30.78 142.86,30.66 v2(143.09,30.42)
  BOTTOM w0.102: v2(314.48,30.44) 314.85,30.81 316.59,30.81 316.7,30.7 318.37,30.7 318.53,30.54 JNGFF3.7
PCIE_PRX_DTX_P10: length 207.5
  TOP w0.102: UH1.J37 141.6,30.82 141.47,30.82 v2(141.15,30.49)
  IN1 w0.102: v2(141.15,30.49) 140.96,30.68 140.82,30.68 140.71,30.57 140.71,30.36 141.86,29.22 141.86,27.34 143.82,25.38 144.25,25.38 145.54,26.67 149.18,26.67 169.64,6.21 241.36,6.21 245.96,10.81 256.46,10.81 257.3,9.97 298.04,9.97 307.37,19.3 310.65,19.3 311.59,20.24 312.62,20.24 315.56,23.18 315.56,27.37 315.22,27.7 314.47,27.7 314.38,27.61 314.38,27.44 v2(314.47,27.35)
  BOTTOM w0.102: v2(314.47,27.35) 314.47,27.63 314.63,27.79 315.39,27.79 315.46,27.71 318.41,27.71 318.58,27.54 JNGFF3.19
PCIE_PRX_DTX_P11: length 197.3
  TOP w0.094: v2(143.13,29.33) 143.13,29.74 UH1.F39
  IN1 w0.102: v2(313.91,24.36) 313.57,24.71 311.57,24.71 307.96,21.1 307.15,21.1 297.02,10.97 257.72,10.97 256.87,11.81 245.49,11.81 240.89,7.21 170.05,7.21 158.02,19.25 158.02,22.7 152.5,28.22 145.5,28.22 143.9,29.83 143.04,29.83 142.89,29.68 142.89,29.57 v2(143.13,29.33)
  BOTTOM w0.102: JNGFF3.31 318.61,24.54 318.45,24.71 314.26,24.71 v2(313.91,24.36)
PCIE_PRX_DTX_P12: length 195.6
  TOP w0.102: UH1.J41 v2(142.46,28.64)
  IN1 w0.102: v2(312.62,21.75) 312.2,21.32 310.13,21.32 309.41,20.6 307.26,20.6 297.22,10.56 257.55,10.56 256.71,11.41 245.71,11.41 241.11,6.81 169.89,6.81 153.3,23.4 153.3,25.93 151.59,27.63 145.37,27.63 145.08,27.93 144.24,27.93 143.53,28.64 v2(142.46,28.64)
  BOTTOM w0.102: v2(312.62,21.75) 313.03,21.34 314.88,21.34 315.48,21.94 318.44,21.94 318.55,22.04 JNGFF3.41
PCIE_PRX_DTX_P13: length 113.3
  TOP w0.102: UH1.C46 144.7,26.56 v2(144.94,26.8)
  BOTTOM w0.102: v2(144.94,26.8) 144.74,26.99 144.74,27.21 145.72,28.19 151.71,28.19 152.59,29.07 152.59,44.33 153.17,44.91 153.17,48.47 151.9,49.74 151.9,51.39 151.46,51.83 151.46,54.31 149.94,55.83 146.6,55.83 144.7,57.74 142.2,57.74 140.49,59.45 138.85,59.45 136.64,61.66 135.3,61.66 133.6,63.36 127.33,63.36 126.38,64.32 125.97,64.32 125.42,64.86 125.42,65.23 123.49,67.16 123.49,68.62 123.26,68.86 123.26,74.82 122.66,75.42 122.66,76.75 119.82,79.58 118.8,79.58 116.43,81.95 116.43,82.22 116.47,82.26 116.47,82.84 116.43,82.88 116.43,84.75 117.49,85.81 117.49,91.83 118.76,93.09 118.76,93.42 119.53,94.2 122.96,94.2 124.27,95.51 128.92,95.51 129.28,95.88 JNGFF6.41
