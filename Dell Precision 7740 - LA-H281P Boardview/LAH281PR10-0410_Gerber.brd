# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.8V_PRIM_PCH: length 77
  TOP w0.254: UH1.AG20 v2(133.04,39.44) 133.04,39.45 UH1.AG19 ; UH1.BB11 125.41,43.78 v2(125.17,44.02) ; UH1.AN15 v2(130.34,41.65) ; v2(129.3,41.54) 129.19,41.65 UH1.AR15
  TOP w0.508: RZ376.1 135.01,96.46 134.17,95.62 RZ378.1 134.17,94.22 133.3,93.35 133.3,92.09 132.6,91.39 v2(129.17,91.39)
  IN4 w0.508: v2(115.45,79.05) 115.45,79.25 117.01,80.8 117.68,80.8 127.07,90.18 128.79,90.18 129.17,90.57 v2(129.17,91.39)
  BOTTOM w0.254: v2(125.17,44.02) 125.28,44.02 125.78,43.53 125.78,42.89 125.66,42.78 125.66,42.36 126.22,41.8 126.76,41.8 127.07,41.48 128.04,41.48 CH22.1
  BOTTOM w0.508: v2(115.45,79.05) 116.73,77.78 117.4,77.78 117.4,77.78 118.74,77.78 120.11,76.41 120.34,76.41 120.85,75.9 120.85,75.48 119.81,74.43 119.81,73.06 120.91,71.95 120.91,70.12 121.3,69.74 121.3,68.72 120.6,68.02
  BOTTOM w1.016: 135.32,56.41 135.32,56.7 133.69,58.32 133.69,58.85 131.58,60.97 128.63,60.97 126.37,58.7 124.95,58.7 123.71,59.95 123.71,61.89 123.26,62.33 123.26,63.7 120.7,66.27 120.7,66.96
  vias: v1(133.44,47.97) v2(121.36,67.71) v2(121.94,67.82)
+1.8V_PRIMP: length 13.9
  TOP w0.109: v2(98.69,23.23) v1(98.69,24.04)
  TOP w0.254: PC904.1 99.45,22.62 PR904.1 98.62,23.16 v2(98.69,23.23)
  IN4 w0.254: v2(107.21,19.42) 107.21,21.94 106.65,22.51 99.4,22.51 98.71,23.19 98.71,23.21 v2(98.69,23.23)
+1.8V_RUN: length 60.7
  TOP w0.508: v2(372.92,18.09) 373.41,17.59 CA66.1 CA65.1 374.75,17.57 374.75,16.44 RA201.1
  IN1 w0.508: v2(375.65,14.63) 374.73,15.55 367.68,15.55 365.2,13.07 365.2,12.35 364.8,11.95 363.64,11.95 362.51,10.82 355.39,10.82 353.38,8.81 353.38,3.31 352.57,2.5 350.27,2.5 349.8,2.97 346.32,2.97 346.01,3.29 343.89,3.29 342.82,4.36 342.82,11.9 v2(342.11,12.61)
  IN3 w0.508: v2(375.65,14.63) 374.54,14.63 372.92,16.26 v2(372.92,18.09)
  BOTTOM w0.109: v2(342.11,12.61) v4(342.11,13.29)
+1.8V_RUN_AUDIO: length 11.6
  TOP w0.203: CA69.1 382.16,19.01 382.33,19.18 UA1.20
  TOP w0.381: CA69.1 382.13,17.53 382.01,17.53 381.67,17.19 v2(381.25,17.19)
  TOP w0.508: v2(381.71,15.38) 381.48,15.62 379.38,15.62 378.65,16.35 376.63,16.35 376.59,16.4 RA201.2
  IN3 w0.508: v2(381.71,15.38) 381.71,16.4 381.25,16.86 v2(381.25,17.19)
  vias: v1(382.05,13.18)
+1.8V_RUN_PWR:
  vias: v1(336.62,15.04)
+1.24V_DPHY: length 3
  TOP w0.254: UH1.AJ23 131.88,37.51 v2(131.5,37.88) 131.89,38.27 UH1.AJ22
  BOTTOM w0.109: v1(132.28,37.72) 132.12,37.88 v2(131.5,37.88)
  BOTTOM w0.254: v2(131.5,37.88) 131.5,38.03 131.98,38.51 RH237.1
+1.24V_DPHY_MAR: length 6.2
  TOP w0.203: 121.85,47.72 122.89,46.69 UH1.BG5
  TOP w0.3: T75.1 120.51,49.35 121.85,48.01 121.85,47.72
  TOP w0.508: CH559.1 CH30.1 119.16,49.35 T75.1
+1.24V_LDOSRAM: length 3.2
  TOP w0.254: UH1.AK22 130.9,38.28 130.55,37.93 v2(130.55,37.84) 130.66,37.84 130.99,37.51 UH1.AK23
  BOTTOM w0.254: RH237.2 130.55,38.24 v2(130.55,37.84) 130.91,37.48 T287.1
+2.5V_MEM: length 9.5
  TOP w2.032: 182.08,92.47 181.7,92.85 177.41,92.85 176.01,94.25 173.3,94.25
  vias: v2(167.33,92.34) v2(167.33,91.71) v2(167.33,91.07) v2(167.97,92.98) v2(167.97,92.34) v2(167.97,91.71) v2(181.29,86.45) v2(181.87,86.45) v2(193.7,91.24) v2(194.28,91.24) v4(168.11,90.52)
+2.5V_MEMP: length 12.1
  TOP w0.508: v2(157.07,96.93) 156.85,96.72 PC402.1 PR404.1
  IN4 w0.508: v2(157.07,96.93) 158.36,95.65 164.22,95.65 165.17,94.69 v2(165.17,93.53)
  vias: v1(163.62,95.6)
+2.8V_FHV0: length 1.6
  TOP w0.203: UH1.AF31 133.44,33.68 133.72,33.96 v2(133.79,33.96)
  BOTTOM w0.109: v2(133.79,33.96) 133.79,34.01 v1(133.46,34.34)
  BOTTOM w0.305: v2(133.79,33.96) 133.8,33.95 RH287.2
+2.8V_FHV1: length 1.4
  TOP w0.203: UH1.AG31 133.04,33.25 v2(133.04,33.14)
  BOTTOM w0.305: v2(133.04,33.14) 132.81,33.37 RH288.2
+3.3V_1.8V_AZIO: length 19.2
  IN2 w0.381: v2(115.43,43.8) 115.39,43.77 115.39,43.39 115.76,43.02 120.79,43.02 123.35,40.45 123.35,38.62 122.21,37.48 v2(121.45,37.48)
  BOTTOM w0.381: CC329.1 119.07,44.54 LC1.1 118.82,44.51 118.53,44.8 v1(116,44.8) 115.86,44.8 115.5,44.44 115.5,43.88 v2(115.43,43.8)
+3.3V_1.8V_AZIO_R: length 7.4
  TOP w0.254: UH1.BB14 125.41,42.89 v2(125.11,43.19)
  BOTTOM w0.254: LC1.2 119.79,43.57 CC327.1 v1(121.38,43.45) 121.77,43.45 121.98,43.23 CC310.1 125.07,43.23 v2(125.11,43.19)
+3.3V_1.8V_GPPA: length 24.9
  TOP w0.254: UH1.AN32 v2(129.82,32.93)
  TOP w0.381: v2(113.82,28.62) 113.72,28.72 RH95.2 ; v2(118.31,30.22) 118.42,30.22 118.44,30.24 RH327.2
  IN2 w0.381: v2(113.82,28.62) 115,29.8 116.75,29.8 117.09,30.14 118.23,30.14 v2(118.31,30.22) 118.36,30.27 118.9,30.27 120.34,31.71 120.88,31.71 122.43,33.26 123.72,33.26 124.2,32.78 127.12,32.78 127.89,33.54 129.2,33.54 v2(129.82,32.93)
  BOTTOM w0.109: v2(118.31,30.22) 118.4,30.13 v1(118.84,30.13) 118.84,30.44 118.78,30.51 118.78,31.63 119.02,31.87 RH340.2
  BOTTOM w0.254: v2(129.82,32.93) 129.92,33.04 RH294.1 129.92,33.68 RH291.2
+3.3V_1.8V_GPPD: length 7.5
  TOP w0.254: v2(129.98,37.83) 129.98,37.38 UH1.AN24
  IN2 w0.508: v2(129.98,37.83) 129.38,37.23 126.57,37.23 126.56,37.23 125.47,37.23 v2(125.11,36.87)
  BOTTOM w0.109: v2(125.11,36.87) 125.11,37.01 125.46,37.35 125.46,38 125.42,38.04 125.42,38.32 v1(125.36,38.38)
+3.3V_1.8V_SPI: length 1.3
  TOP w0.254: UH1.AN44 129.57,27.44 v2(129.48,27.53)
  BOTTOM w0.109: v2(129.48,27.53) 130.06,27.53 v1(130.21,27.68)
+3.3V_ALW: length 280.3
  TOP w0.254: RE302.2 RE68.2 127.49,76.52 127.49,76.43 127.91,76.01 v2(128.01,76.01)
  TOP w0.356: UT32.5 117.55,64.4 117.8,64.66 CT237.1 v2(118.15,64.12)
  TOP w0.381: PR730.2 65.61,20.73 PR62.1
  TOP w0.508: v2(135.9,94.81) RZ377.1 ; v2(58.08,19.68) 57.91,19.51 57.91,19.27 57.11,18.47 PR2018.2 ; PR2008.2 60.7,16.44 ; 60.7,16.44 PR2007.2 ; 60.7,16.44 61.08,16.44 61.67,17.03 v2(61.67,17.29) ; PR800.2 104.31,29.1 103.71,29.71 v2(103.71,29.73) ; RZ1482.1 98.37,61.41 100.44,61.41 100.8,61.76 102.78,61.76 v2(103.81,60.73) ; RE732.2 v2(141.87,63.77) ; RE734.2 140.35,63.9 v2(140.22,63.77) ; PR40.2 53.85,33.75 v2(53.55,34.05) ; v2(118.82,16.78) 118.72,16.88 RH431.2 ; v2(141.02,63.74) 141.11,63.83 RE733.2 ; RE37.2 132.81,65.79 v2(132.74,65.72) ; RE735.2 v2(139.58,63.77) ; PR41.1 52.72,33.78 v2(52.72,34.05) ; v2(57.37,20.61) 57.33,20.61 56.84,20.13 PR2021.2 ; v2(98.62,35.65) 97.91,34.94 PR10.2 ; v2(76.68,19.83) 76.42,19.57 76.42,19.33 PR721.1 76.27,19.18 PR720.1 ; v2(37.87,12.22) 38.05,12.4 QT3.1 ; RE701.2 129.54,73 RE700.2 127.33,72.89 127.23,72.79 v2(126.7,72.79) 126.5,72.99 126.5,73.56 RE12.2 ; v2(67.51,18.76) 67.7,18.57 PR725.2 ; v2(64.72,20.78) PR730.2 ; PR107.1 v2(133.16,117.49) ; v2(58.62,20.72) 58.63,20.73 PR2151.2 ; PR2005.2 v2(58.74,19.97) ; PR205.1 109.14,10.24 v2(109.13,10.22) ; PR2016.2 v2(57.84,23.02) ; RE43.2 v2(131.81,65.81) ; JKBTP1.6 15.84,6.66 v2(16.3,7.13) ; RZ381.1 135.76,103.22 v2(134.95,104.03) ; PR2010.2 v2(57.92,22.18) ; RZ375.1 143.27,100.42 v2(142.56,99.71) ; PR2003.2 v2(64.13,15.14)
  IN1 w0.381: 26.12,26.3 24.74,27.67 23.68,27.67 22.76,28.59 22.76,34.33 23.12,34.7 23.68,34.7 23.95,34.43 v2(23.95,32.49)
  IN1 w0.508: v2(28.01,29.35) 27.77,29.35 27.2,28.78 27.2,27.38 25.74,25.92 24.09,25.92 23.46,26.56 21.7,26.56 21.14,27.13 19.84,27.13 18.88,26.17 16.95,26.17 v2(16.83,26.28) 16.83,26.33 17.7,27.21 17.7,29.35 17.07,29.99 15.69,29.99 15.31,30.37 13.85,30.37 13.14,29.66 v2(13.02,29.66) ; v2(50.24,25.42) 50.49,25.68 50.49,32.27 51.89,33.67 ; v2(21.86,39.5) 23.13,39.5 23.53,39.9 24.07,39.9 24.55,39.42 25.27,39.42 26.86,37.84 28.21,37.84 28.64,37.4 28.64,31.94 28.62,31.92
  IN1 w1.016: 50.87,34.05 47.6,34.05 46.96,34.69 41.59,34.69 40.5,33.59 37.08,33.59 34.92,31.43 29.85,31.43 ; 54.81,34.3 55.11,34.6 55.11,34.6 56.66,36.15 59.07,36.15 59.26,36.34
  IN2 w0.508: v2(13.02,29.66) 12.5,29.66 10.89,31.27 v2(9.75,31.27) ; v2(128.01,76.01) 127.44,76.59 127.44,77.31 v2(128.32,78.19) ; v2(137.98,137.99) 130.07,137.99 v2(127.45,140.6)
  IN3 w0.508: 57.78,17.65 57.47,17.34 57.47,16.91 58.11,16.27 58.11,15.32 57.8,15 55.02,15 54.09,14.07 54.09,13.23 53.02,12.16 47.72,12.16 47.6,12.28 43.1,12.28 42.26,11.44 38.45,11.44 37.87,12.03 v2(37.87,12.22) ; v2(160.16,77.75) 159.1,77.75 158.32,78.53 v2(158.32,80.02)
  IN4 w0.508: v2(14.46,8.26) 13.98,7.77 13.09,7.77 11.48,9.39 11.48,12.18 13.77,14.47 13.77,19.58 13.37,19.97 11.41,19.97 9.26,22.13 9.26,24.64 12.65,28.03 12.65,29.28 v2(13.02,29.66) ; v2(57.48,3.01) 58.54,3.01 61.71,6.18 67.76,6.18 68.91,7.33 68.91,12.56 68.15,13.32 68.15,18.13 v2(67.51,18.76)
  BOTTOM w0.229: CE340.1 157.27,70.17 157.27,70.98 157.98,71.69 UE12.14
  BOTTOM w0.254: UE5.5 154.51,66.94 154.32,67.13 CE52.1 154.91,67.48 155.06,67.32 v2(155.06,67.12) ; UE3.5 154.77,61.99 155.01,62.23 CE53.1 155.01,63.42 v2(154.68,63.74) ; CE341.1 159.61,77.94 159.61,77.76 158.88,77.04 UE12.24
  BOTTOM w0.305: JAPS1.7 111.72,68.02 v2(111.77,68.06) ; v2(113.47,69.53) 113.28,69.53 112.79,70.02 JAPS1.3
  BOTTOM w0.356: RT516.2 v2(28.01,29.35) ; v2(28.9,31.28) 28.76,31.28 28,30.52 RT518.2 ; v2(16.3,7.13) 15.97,7.46 CZ91.1 15.59,7.91 15.27,8.24 14.48,8.24 v2(14.46,8.26)
  BOTTOM w0.381: v2(23.95,32.49) 24.04,32.58 24.85,32.58 25.04,32.39 RT528.1 ; UZ6.5 106.79,13.17 CZ82.1 107.2,13.29 v2(107.47,13.02)
  BOTTOM w0.508: CE341.1 160.16,78.11 v2(160.16,77.75) ; v2(16.83,26.28) 17.19,25.92 RT512.2 ; RT515.2 RT511.2 RT514.2 RT510.2 10.51,30.88 10.12,31.27 v2(9.75,31.27) ; RE563.2 158.93,68.85 158.96,68.89 RE566.1 159.35,68.24 v2(159.99,67.6) ; RE74.1 RE73.1 118.52,55.39 v2(118.98,55.85) ; RV909.1 v2(137.98,137.99) ; RT529.1 21.86,39.08 v2(21.86,39.5) ; PR110.1 57.37,6.38 57.68,6.07 57.68,3.22 v2(57.48,3.01) ; PR2143.2 96.12,26.04 v2(95.78,26.38) ; RE561.2 131.63,67.58 131.41,67.36 130.96,67.36 v2(130.93,67.38) ; CE340.1 156.61,70.12 v2(155.7,70.12) ; PR59.2 PR60.1 50.43,25.58 50.27,25.42 v2(50.24,25.42) ; RE564.1 v2(154.08,74.06) ; RE565.1 v2(158.32,80.02)
  vias: v2(47.19,55.26) v2(47.83,55.31) v2(60.35,37.66) v2(60.37,36.92) v2(61.03,37.68) v2(61.06,36.92) v2(61.67,37.66) v2(61.72,36.95) v2(76.58,36.05) v2(76.93,36.58) v2(77.16,36.04) v2(77.55,36.52) v2(77.9,36.06) v2(78.28,36.5) v2(78.65,36.05) v2(79.04,36.52) v2(79.43,36.08) v2(80.46,36.08) v2(92.91,19.55) v2(93.2,18.99) v2(93.34,20.04) v2(112.86,23.23) v2(113.68,147.65) v2(113.68,147.07) v2(113.68,146.48) v2(114.26,147.07) v2(114.26,146.48) v2(119.01,62.16) v2(119.01,61.57) v2(125.16,139.21) v2(125.16,138.62) v2(125.42,138.06) v2(125.74,139.21) v2(125.74,138.62) v2(128.2,67.57) v2(128.21,68.42) v2(128.38,79.41) v2(128.87,81.32) v2(128.89,79.7) v2(128.9,80.28) v2(133.8,117.49) v2(136.22,120.92) v2(136.22,119.9) v2(136.4,63.49) v2(136.54,120.41) v2(136.73,15.05) v2(136.73,14.47) v2(136.92,120.92) v2(136.92,119.9) v2(137.01,63.49) v2(137.01,13.95) v2(137.32,15.05) v2(137.32,14.47) v2(138.2,85.99) v2(138.86,85.99) v2(144.94,103.47) v2(144.94,102.83) v2(144.96,102.16) v2(145.23,104.29) v2(145.33,104.9) v2(145.46,103.75) v2(145.46,103.11) v2(145.44,102.52) v2(145.78,104.53) v2(146.28,102.43) v2(146.53,75.58) v2(146.53,75) v2(146.53,74.41) v2(146.86,66.51) v2(146.86,65.47) v2(149.69,103.41) v2(149.69,102.77) v2(149.67,102.08) v2(149.89,21.58) v2(150.28,103.41) v2(150.28,102.75) v2(150.28,102.16) v2(150.27,21.14) v2(150.7,20.75) v2(151.71,95.26) v2(152.09,95.77) v2(152.28,95.14) v2(152.46,66.52) v2(152.47,65.45) v2(152.6,96.15) v2(152.79,95.57) v2(153.2,95.99) v2(166.79,139.96) v2(167.43,139.96) v4(147.25,103.84) v4(147.58,101.32) v4(149.03,102.91)
+3.3V_ALW2: length 35.5
  TOP w0.109: v1(133.96,107.96) 133.73,108.19 PR104.2
  TOP w0.254: v2(131.47,81.55) 131.06,81.96 131.06,82.29 130.88,82.46 130.68,82.46 RE57.2
  TOP w0.508: PR104.2 131.97,108.19 v2(131.73,107.95)
  IN1 w0.508: v2(131.73,107.95) 130.34,106.56 130.34,105.58 127.71,102.95 127.71,101.87 129.53,100.05 130.43,100.05 131.37,99.11 131.37,96.76 132.9,95.23 132.9,83.19 131.54,81.84 131.54,81.62 v2(131.47,81.55)
+3.3V_ALW_DSW_R: length 3.9
  TOP w0.109: QH7.1 112.84,20.06 v1(112.02,19.24)
  TOP w0.508: RH439.2 113.12,18.41 113.61,18.91 QH7.1
+3.3V_ALW_PCH: length 703.9
  TOP w0.254: RH736.1 112.27,34.69 v2(112.91,34.69) 113.29,34.3 RH81.1 113.84,34.56 RH56.1 ; RH329.2 113.85,30.81 112.56,30.81 v2(112.44,30.93)
  TOP w0.305: RH310.1 131.98,22.43 131.98,21.81 v2(131.96,21.8)
  TOP w0.381: RH80.1 115.62,33.31 115.65,33.35 v2(115.68,33.35)
  TOP w0.508: v2(113.23,27.32) 113.47,27.08 RH204.2 ; RZ1385.1 144.97,96.61 145.55,96.03 v2(146.23,96.03) 147.2,96.03 147.77,95.46 147.77,93.8 150.12,91.45 150.12,90.6 152.82,87.9 159.33,87.9 162.13,85.1 162.13,81.36 166.38,77.1 166.38,64.21 165.86,63.69 165.86,59.84 167.71,57.99 v2(167.71,56.02) ; RI95.2 383.17,40.19 v2(382.34,41.01) ; v2(118.35,31.38) RH203.2 ; RZ379.1 143.08,102.85 143.08,103.07 v2(142.38,103.77) ; v2(134.17,19.77) 133.98,19.58 RH712.2 ; RH440.2 109.73,17.78 v2(109.62,17.68) ; v2(111.28,25.26) 111.63,24.91 RH57.1 ; v2(113.89,70.26) 113.88,70.26 113.88,70.26 113.11,70.26 112.63,69.78 112.63,69.78 112.06,69.22 105.12,69.22 104.54,68.65 v2(104.54,67.79) ; v2(15.76,46.5) 17.79,46.5 18.49,45.8 v2(19.23,45.8) 19.23,46.15 19.57,46.5 20.89,46.5 24.14,43.25 v2(24.76,43.25) ; v2(239.2,17.77) 237.9,16.47 RC133.1 ; RH731.1 138.64,20.7 138.31,21.03 v2(138.06,21.03)
  IN1 w0.406: v2(126.27,37.83) 126.29,37.81 126.29,37.61 126.07,37.39 124.9,37.39 124.49,36.99 124.49,36.52 125.52,35.49 v2(125.52,34.82) ; v2(113.89,70.26) 114.18,69.97 114.18,68.5 114.47,68.21 114.47,66.59 114.63,66.43 114.63,66.16 113.36,64.89 113.36,63.7 114.69,62.37 114.69,59.4 114.1,58.8 114.1,53.68 115.15,52.63 115.15,49.66 115.38,49.43 116.16,49.43 116.62,48.96 116.62,48.06 117.79,46.89 117.79,43.67 117.85,43.62 117.85,42.28 117.85,42.28 117.85,41.85 v2(118.38,41.32)
  IN1 w0.508: 260.47,24.81 260.91,25.24 265.37,25.24 267.18,23.43 280.77,23.43 282.75,21.45 291.26,21.45 292.53,22.72 292.53,23.17 296.64,27.28 296.64,29.34 297.72,30.42 303.01,30.42 303.8,29.63 309.42,29.63 315.94,36.15 315.94,44.83 317.16,46.05 318.84,46.05 319.71,45.18 321.26,45.18 321.82,45.74 321.82,54.7 323.49,56.38 324.7,56.38 325.94,57.62 341.13,57.62 344.05,54.69 354.18,54.69 355.63,56.15 363.32,56.15 364.31,57.14 372.54,57.14 372.9,56.78 ; v2(109.62,17.68) 108.75,16.8 108.75,15.83 108,15.08 106.7,15.08 106.22,15.56 102.8,15.56 v2(102.18,16.18) ; v2(142.38,103.77) 142.38,100.89 141.95,100.47 141.95,99.28 140.2,97.53 137.52,97.53 v2(136.41,96.41)
  IN2 w0.508: v2(167.71,56.02) 170.94,56.02 172.59,54.37 173.93,54.37 174.32,53.98 174.32,52.22 173.86,51.76 173.86,45.38 173.15,44.67 173.15,25.22 172.45,24.53 171.02,24.53 170.51,24.02 170.51,21.35 171.08,20.78 171.84,20.78 172.27,20.35 172.27,17.73 175.3,14.7 v2(176.3,14.7) ; 119.36,35.45 120.88,35.45 121.66,36.24 123.06,36.24 123.44,35.86 123.44,35.12 124.03,34.53 125.24,34.53 v2(125.52,34.82)
  IN2 w0.762: 145.1,14.43 149.84,14.43 150.43,15.02 150.43,19.71 v2(149.4,20.74)
  IN3 w0.508: v2(144.29,14.6) 144.64,14.6 145.37,13.87 149.75,13.87 150,14.12 154.96,14.12 v2(156.12,12.97) ; v2(146.23,96.03) 146.23,96.19 146.18,96.23 140.47,96.23 139.76,95.52 137.15,95.52 136.41,96.26 v2(136.41,96.41) ; v2(45.04,58.55) 44.73,58.24 42.52,58.24 42.26,58.5 41.48,58.5 41.35,58.37 38.47,58.37 38.3,58.54 30.53,58.54 29.39,57.39 29.09,57.39 26.61,54.92 26.61,45.09 v2(24.76,43.25)
  IN3 w0.762: 176.87,16.15 177.87,16.15 180.58,18.85 187.16,18.85 187.82,18.19 196,18.19 198.81,15.38 228.28,15.38 235.69,22.79 237.81,22.79 238.12,23.1 238.12,23.92 238.86,24.65 239.6,24.65 239.8,24.44 239.8,24.25 v2(239.91,24.14)
  IN4 w0.508: v2(104.54,67.79) 104.32,67.79 101.25,64.72 98.89,64.72 90.84,56.67 85.88,56.67 85.69,56.48 69.38,56.48 68.63,55.73 66.83,55.73 66.42,56.15 60.23,56.15 59.77,55.69 58.32,55.69 58,55.37 53.29,55.37 53,55.08 49.02,55.08 48.13,55.97 46.84,55.97 45.04,57.76 v2(45.04,58.55) ; v2(169.15,96.64) 168.36,97.42 158.29,97.42 157.78,97.93 156.41,97.93 155.57,97.09 151.32,97.09 149.67,95.45 148.23,95.45 147.64,96.03 v2(146.23,96.03) ; v2(167.71,56.02) 167.71,54.37 166.51,53.16 166.51,49.94 165.3,48.73 v2(165.3,47.4) ; 117.04,19.47 116.86,19.29 114.32,19.29 112.71,17.68 v2(109.62,17.68) ; v2(239.91,24.14) 239.8,24.04 239.8,21.65 240.37,21.09 240.37,18.94 239.28,17.86 239.28,17.82 239.23,17.77 v2(239.2,17.77)
  IN4 w0.762: v2(239.91,24.14) 240.12,24.14 240.43,24.46 242.55,24.46 v2(243.61,25.51) 243.96,25.51 244.02,25.58 245.71,25.58 246.31,24.98 247.69,24.98 248.55,25.84 251.24,25.84 251.82,25.26 251.82,24.84 252.79,23.87 255.29,23.87 256.16,23 259.25,23 259.41,23.16
  BOTTOM w0.305: JAPS1.1 112.95,71.02 113.69,70.28 113.88,70.28 113.88,70.26 v2(113.89,70.26) ; v2(134.52,14.87) 134.67,14.72 RZ69.1 ; RH309.1 125.95,37.6 126.18,37.83 v2(126.27,37.83) ; RH555.2 126.16,34.93 RH311.1 126.06,34.82 v2(125.52,34.82)
  BOTTOM w0.381: UH7.5 110.82,30.84 111.06,31.07 112.31,31.07 v2(112.44,30.93)
  BOTTOM w0.508: RH330.1 18.97,46.05 v2(19.23,45.8) ; RH101.1 v2(169.15,96.64) ; RT391.2 45.58,57.19 45.04,57.73 v2(45.04,58.55) ; v2(382.34,41.01) 382.08,41.27 377.12,41.27 376.76,41.64 376.76,46.35 373.38,49.73 373.38,56.14 373.73,56.49 374.3,56.49 v2(374.42,56.61) ; v2(149.4,20.74) RZ368.1 ; RH734.1 v2(165.3,47.4) ; v2(131.96,21.8) 131.7,22.06 RH730.1 ; JSPI1.16 100.92,17.53 101.58,16.87 RH185.1 102.18,16.82 v2(102.18,16.18) ; RC137.2 243.62,25.5 v2(243.61,25.51) ; RH376.1 v2(15.76,46.5)
  BOTTOM w0.762: 174.98,14.16 174.95,14.14 172.46,14.14 170.58,12.26 164.05,12.26 163.34,12.97 v2(156.12,12.97)
  vias: v2(111.56,27.66) v2(111.56,27.07) v2(115.53,33.94) v2(116.14,33.71) v2(116.77,36.99) v2(132.31,18.68) v2(132.94,18.71) v2(143.16,15.04) v2(143.47,14.53) v2(143.7,15.27) v2(144.3,15.22) v2(176.43,13.96) v2(259.97,24.14) v2(259.98,23.53) v2(374.44,57.35) v4(117.37,36.71)
+3.3V_ALW_PCH_PWR:
  vias: v1(140.26,16.27)
+3.3V_ALW_PCHRES: length 45.1
  IN2 w0.381: v2(132.95,26.54) 133.63,27.23 133.63,29.25 v2(134.14,29.76) 134.14,32.83 132.15,34.81 130.69,34.81 v2(130.35,35.15)
  IN3 w0.508: v2(121.4,45.41) 121.4,44.8 120.8,44.19 120.8,38.55 121.22,38.13 122.49,38.13 122.95,37.67
  IN4 w0.381: v2(124.45,37.81) 124.39,37.87 124.39,38.87 124.93,39.41 126.69,39.41 127.35,38.75 127.73,38.75 128.4,38.09 v2(128.4,37.88) 129.89,36.39 130.02,36.39 130.63,35.78 130.63,35.52 130.35,35.25 v2(130.35,35.15) 130.52,34.99 132.03,34.99 132.41,35.37 134.75,35.37 135.05,35.07 135.59,35.07 v2(136.07,35.56)
  BOTTOM w0.254: RH291.1 130.83,34.67 v2(130.35,35.15)
  BOTTOM w0.381: v2(132.95,26.54) 132.66,26.54 131.17,25.05 129.64,25.05 129.21,25.48 RH246.1 128.65,25.59 128.22,25.16 RH300.1
  BOTTOM w0.508: v2(136.07,35.56) 136.09,35.57 RH302.1
  vias: v1(133.59,29.58) v2(121.52,35.14) v2(121.51,34.58) v2(125.04,37.92)
+3.3V_ALW_R: length 335.3
  TOP w0.254: v2(388.33,5.63) CZ93.1 388.33,6.25 388.69,6.62 389.13,6.62 389.47,6.96 UZ10.5 ; v2(309.43,55.45) 309.18,55.45 308.93,55.7 PU300.10 ; v2(362.42,12.78) 362.42,13.18 362.11,13.49 UZ60.5
  TOP w0.305: v2(371.78,46.98) 371.9,46.86 JPB1.3
  TOP w0.381: v2(273.96,75.14) 273.99,75.17 273.99,75.47 273.77,75.68 UZ35.5
  TOP w0.508: PR500.1 350.3,39.88 v2(349.9,39.47) ; v2(312.4,63.1) PR313.1 312.41,62.42 PR311.2 ; v2(240.29,12.3) 238.63,12.3 238.05,11.72 236.41,11.72 235.3,12.83 RC241.1 ; PR515.1 318.41,4.51 318.12,4.21 318.12,2.39 319.15,1.36 v2(319.15,1.28)
  IN1 w0.508: v2(240.29,12.3) 240.29,9.36 v2(240,9.07)
  IN2 w0.381: v2(362.42,12.78) 362.32,12.78 361.36,13.73 361.36,15.27 362.21,16.12 366.09,16.12 367.19,15.01 373.96,15.01 376.89,12.08 381.07,12.08 382.72,10.43 385.65,10.43 386.41,9.67 386.41,9.41 387.22,8.6 387.22,8.09 388.33,6.98 v2(388.33,5.63)
  IN2 w0.508: v2(155.17,11.02) 154.85,11.34 154.85,13.34 153.93,14.25 152.22,14.25 151.74,14.73 151.74,18.01 153.07,19.34 v2(153.08,19.34)
  VCC w0.508: v2(279.79,84.47) 280.11,84.15 280.81,84.15 281.38,84.72 285.59,84.72 v2(286.17,85.3) 286.33,85.14 286.33,84.47 285.97,84.11 285.97,82.21 286.65,81.54 v2(286.65,79.61)
  IN3 w0.508: v2(301.72,4.91) 299.99,3.18 277.86,3.18 274.85,6.18 269.02,6.18 265.96,9.25 256.79,9.25 255.27,10.77 245.85,10.77 244.15,9.07 v2(240,9.07)
  IN4 w0.508: v2(286.65,79.61) 286.65,79.26 286.27,78.88 281.18,78.88 v2(279.64,77.35) 278.92,76.62 275.49,76.62 274.01,75.14 v2(273.96,75.14)
  BOTTOM w0.254: CZ540.1 363.02,13.02 362.66,13.02 v2(362.42,12.78)
  BOTTOM w0.381: RV821.1 281.18,76.93 280.63,77.47 UV68.5 279.76,77.47 v2(279.64,77.35) ; UV63.5 285.08,83.61 RV817.1 285.16,84.61 CV810.1 ; CV811.1 279.6,82.47 279.6,81.94 UV60.5
  BOTTOM w0.508: v2(155.17,11.02) 155.18,11.01 162.33,11.01 163.22,10.12 213.31,10.12 215.62,12.44 230.24,12.44 231.1,11.58 233.53,11.58 235.22,9.89 236.63,9.89 239.04,12.3 v2(240.29,12.3) ; PC313.1 308.53,55.95 309.03,55.45 v2(309.43,55.45) 309.43,54.87 PR300.1 ; v2(339.13,5.08) 339.1,5.05 339.1,3.84 338.38,3.11 335.71,3.11 333.75,1.16 319.28,1.16 v2(319.15,1.28) 304.41,1.28 301.72,3.97 v2(301.72,4.91) ; v2(279.79,84.47) 279.79,82.84 CV811.1 ; RV821.1 280.91,76.47 RV820.1 ; v2(153.08,19.34) 153.02,19.28 CZ200.1 151.99,19.7 UZ34.5 ; v2(299.21,70.37) 297.16,70.37 295.09,72.43 295.09,74.72 293.19,76.62 293.19,81.88 290.91,84.17 v4(289.72,84.17) 288.69,84.17 287.56,85.3 v2(286.17,85.3) 286,85.13 CV810.1 ; v2(336.83,52.2) 336.59,52.2 RZ9.1
  vias: v2(299.26,69.2) v2(299.81,70.05) v2(300.17,69.44) v2(300.42,70.04) v2(332.2,49.6) v2(332.84,49.63) v2(333.48,49.65) v2(334.15,50.49) v2(334.17,49.72) v2(334.69,16.98) v2(334.72,17.64) v2(334.72,16.37) v2(335.38,17.67) v2(335.35,17.01) v2(335.38,16.4) v2(335.99,17.67) v2(335.96,17.01) v2(335.99,16.4) v2(336.6,17.67) v2(336.57,17.01) v2(336.6,16.4) v2(336.83,52.83) v2(337.18,17.01) v2(337.21,17.67) v2(337.21,16.4) v2(337.79,17.03) v2(337.82,17.69) v2(337.82,16.42) v2(338.48,17.69) v2(338.45,17.06) v2(338.48,16.45) v2(338.5,7.52) v2(338.5,6.76) v2(338.5,5.87) v2(338.5,5.1) v2(339.09,17.69) v2(339.06,17.03) v2(339.09,16.42) v2(339.13,7.49) v2(339.13,6.73) v2(339.13,5.84) v2(339.75,17.67) v2(339.72,17.06) v2(339.75,16.45) v2(339.81,7.46) v2(339.81,6.7) v2(339.81,5.81) v2(339.81,5.05) v2(340.36,17.67) v2(340.33,17.06) v2(340.36,16.45) v2(340.43,7.51) v2(340.43,6.75) v2(340.43,5.86) v2(340.43,5.09) v2(340.97,17.67) v2(340.94,17.06) v2(340.97,16.45) v2(348.16,47.77) v2(348.48,48.97) v2(348.5,37.08) v2(349.03,37.6) v2(349.07,36.56) v2(349.14,48.23) v2(349.3,38.24) v2(349.58,35.45) v2(349.61,37.1) v2(349.62,36.09) v2(349.86,47.9) v2(349.83,38.75) v2(349.87,37.72) v2(349.99,48.95) v2(350.05,36.58) v2(350.09,34.94) v2(350.19,35.61) v2(350.41,38.26) v2(350.42,37.24) v2(350.61,36.1) v2(350.62,11.09) v2(350.62,10.45) v2(350.62,9.82) v2(350.72,36.72) v2(350.72,35.19) v2(350.85,37.73) v2(351.1,35.7) v2(351.23,37.1) v2(351.23,36.34) v2(351.25,11.09) v2(351.25,10.45) v2(351.25,9.82) v2(351.74,36.72) v2(351.74,35.96) v2(351.89,11.09) v2(351.89,10.45) v2(351.89,9.82) v2(352.65,36.27) v2(366.09,32.91) v2(366.09,32.27) v2(366.09,31.64) v2(366.72,32.78) v2(366.72,32.15) v2(366.72,31.51) v2(367.36,32.78) v2(367.36,32.15) v2(367.36,31.51) v2(367.99,32.78) v2(367.99,32.15) v2(367.99,31.51) v2(368.63,32.65) v2(368.63,32.02) v2(368.63,31.38) v2(374.36,59.03) v2(374.31,58.32) v2(378.17,48.3) v2(379.51,48.32)
+3.3V_ALW_RP: length 20.7
  TOP w0.109: 338.03,3.29 v1(339.53,3.29)
  TOP w0.254: PU501.14 323.17,4.39 323.36,4.2 323.36,3.31 PR513.2 323.92,3.2 324.17,2.95 324.17,1.3 324.3,1.16 331.24,1.16 331.98,1.89 332.12,1.89 v2(332.18,1.95)
  IN1 w0.254: v2(337.87,4.13) 336.14,4.13 334.07,2.06 332.29,2.06 v2(332.18,1.95)
+3.3V_ALW_UE1: length 13.6
  TOP w0.254: UE1.M9 v2(139.61,70.08) ; UE1.K2 v2(133.27,71.68) ; UE1.G8 v2(138.81,74.08) ; UE1.B7 v2(137.27,78.82)
  TOP w0.305: UE1.H1 132.81,73.62 132.29,73.62 v2(132.27,73.65)
  TOP w0.508: v2(129.12,74.94) 128.77,75.28 RE314.2
  BOTTOM w0.356: v2(138.81,74.08) 138.97,74.24 CE23.1
  BOTTOM w0.381: CE19.1 CE15.1 139.82,69.36 139.61,69.57 v2(139.61,70.08) ; v2(137.27,78.82) 137.29,78.8 CE13.1 ; CE20.1 133.3,74.09 132.84,73.62 132.29,73.62 v2(132.27,73.65) 132.24,73.65 130.96,74.94 v1(130.03,74.94) v2(129.12,74.94)
  BOTTOM w0.508: CE14.1 133.28,71.7 v2(133.27,71.68)
  vias: v2(130.21,67.85) v2(130.51,68.58)
+3.3V_ALW_UZ12:
  vias: v1(142.77,21.12)
+3.3V_ALWP: length 18
  TOP w0.254: v2(132.98,111.33) 132.63,111.68 PR106.2 132.71,112.03 PU100.14
  IN1 w0.254: v2(139.24,102.88) 138.73,102.38 135.2,102.38 133.74,103.84 133.74,108.66 132.98,109.43 v2(132.98,111.33)
  BOTTOM w0.109: v1(132.03,112.35) 132.03,112.28 v2(132.98,111.33)
  vias: v2(140.08,102.86) v2(140.74,102.83) v2(141.53,102.88)
+3.3V_CARD_SPI: length 31.6
  IN2 w0.508: v2(13.25,7.17) 13.25,6.35 14.45,5.15 14.45,4.19 15.6,3.04 18.62,3.04 18.9,3.32 21.1,3.32 22.36,2.06 24.36,2.06 25.56,3.26 v2(25.56,3.95) 23.47,3.95 22.02,5.4 v2(22.02,7.2)
  BOTTOM w0.109: v2(13.25,7.17) 13.74,7.66 v1(13.74,7.86)
  BOTTOM w0.356: v2(13.25,7.17) 13.25,7.48 12.82,7.9 CR236.2 12.6,6.81 12.91,6.49 RR238.2
  BOTTOM w0.508: RR235.2 22.63,7.58 22.25,7.2 v2(22.02,7.2) ; RR238.2 13.51,6.49 14.02,5.98 UR3.8 ; v2(25.56,3.95) 25.56,3.58 25.17,3.19 24.94,3.19 RR236.2 RR237.2
+3.3V_DGFF: length 27.1
  TOP w0.254: v2(247.64,93.5) 248.04,93.1 248.04,92.65 247.72,92.32 JDGFF2.E9
  TOP w0.381: v2(247.61,94.09) 247.39,94.09 247.09,93.79 247.09,93.24 JDGFF2.E10
  TOP w0.508: v2(249.24,85.72) 248.59,85.07 CV956.1 CV902.1
  IN4 w0.508: v2(284,75.15) 284,75.35 283.78,75.56 v2(283.78,78.04) ; v2(290.99,77) 290.99,76.74 290.7,76.44 v2(290.7,75.83)
  BOTTOM w0.109: v2(293.8,71.44) v4(293.8,72.23)
  BOTTOM w0.381: QV30.2 275.85,78.71 RV805.1 275.93,78.5 276.97,77.46 v2(276.97,77.28) ; UV61.5 290.7,75.63 v2(290.7,75.83) ; UV62.5 290.88,77.82 290.93,77.87 CV809.1 291.82,77.84 291.82,77.26 291.56,77 v2(290.99,77) ; v2(276.81,83.48) 276.81,82.8 RV804.1 276.69,82.46 275.85,81.62 QV30.5 ; v2(278.61,83.47) 278.54,83.55 RV819.1 ; v2(280.36,84.91) 280.49,84.79 RV816.1
  BOTTOM w0.508: RV806.1 284.01,75.8 284.01,75.16 v2(284,75.15) 283.8,74.95 RV807.1 ; RV803.1 283.06,77.46 283.64,78.04 v2(283.78,78.04) ; RV815.1 286.01,77.47 285.67,77.82 v2(285.67,78.11)
  vias: v2(232.03,93.44) v2(232.65,93.47) v2(233.13,92.93) v2(276.16,83.41) v2(293.06,70.75) v2(293.22,71.36) v2(293.7,70.75)
+3.3V_DGFF_PWR: length 1.1
  TOP w0.109: CZ528.1 296.92,71.49 v1(297.14,71.71)
+3.3V_DSW: length 31.9
  TOP w0.33: v2(122.73,20.05) 122.96,20.28 122.96,21.1 ; RH93.2 114.16,25.37 114.09,25.44 v2(114.08,25.44)
  TOP w0.381: RH602.2 114.03,26.06 114.03,25.49 v2(114.08,25.44)
  TOP w0.508: v2(116.29,26.39) 116.35,26.33 RH243.2 ; RH94.2 118.61,25.42 117.66,25.42 117.62,25.38 v2(117.57,25.38) ; RH440.1 111.87,17.78 112.2,18.11 RH439.1 111.97,18.48 v2(111.57,18.48)
  IN1 w0.508: v2(123.61,24.28) 123.51,24.18 123.51,22.76 123.12,22.37 ; v2(122.73,20.05) 122.73,20.37 123.12,20.76 123.12,22.37 ; 123.12,22.37 122.05,22.37 121.73,22.69 121.73,22.79 119.28,25.23 118.53,25.23 118.38,25.38 v2(117.57,25.38)
  IN3 w0.508: v2(114.08,25.44) 114.08,25.29 113.48,24.69 113.48,18.49 113.07,18.08 111.96,18.08 v2(111.57,18.48) ; v2(117.57,25.38) 117.55,25.4 117.55,25.71 117.01,26.25 117.01,26.39 v2(116.29,26.39)
  BOTTOM w0.508: v2(116.29,26.39) 114.76,26.39 v1(114.36,25.98) 114.08,25.71 v2(114.08,25.44)
+3.3V_EC_PLL: length 7.2
  TOP w0.109: CE17.1 129.86,77.39 v1(128.62,78.63)
  TOP w0.254: 131.15,75.78 131.39,75.55 132.56,75.55 132.84,75.27 UE1.F1
  TOP w0.305: RE314.1 129.5,76.53 CE17.1 130.75,76 CE18.1 130.94,76 131.15,75.78
+3.3V_FUSE: length 2.6
  TOP w0.254: UH1.AT44 v2(128.89,27.77)
  BOTTOM w0.381: RH300.2 127.9,26.73 v1(128.27,27.09) 128.89,27.71 v2(128.89,27.77)
+3.3V_LAN: length 51.6
  TOP w0.356: CL15.1 v2(145.2,139.62)
  TOP w0.381: UL2.5 128.87,143.89 128.47,144.29 128.47,145.56 129.23,146.32 130.17,146.32 RL29.1
  TOP w0.508: v2(131.53,148.35) 130.3,147.12 RL29.1 ; CL18.1 CL199.1 135.26,153.25 135.96,152.54 v2(136.47,152.54) ; RL30.1 135.54,142.64 136.66,143.75 v2(136.66,145.24) ; JLOM1.B2 149.94,162.17 142.63,154.87 v2(136.65,154.87) ; v2(136.56,153.68) 135.84,153.68 134.74,154.78 CL19.1 134.74,156.02 137.11,158.38 139.39,158.38 JLOM1.A1 ; RL2.1 147.77,137.28 v2(148.13,136.91) ; RL1.1 v2(146.91,138.82)
  IN3 w0.508: 136.47,148.35 v2(131.53,148.35)
  vias: v2(161.23,133.38) v2(162.01,133.62) v2(162.28,134.29) v2(162.79,133.55) v4(165.39,137.26)
+3.3V_LAN_OUT: length 3
  TOP w0.203: UL1.15 154.58,142.28 154.89,141.98 v2(155.19,141.98) ; UL1.29 149.41,140.43 v2(149.3,140.54) ; v2(152.98,142.02) UL1.19
  vias: v1(157.83,137.68) v2(158.14,136.96) v2(158.18,136.36)
+3.3V_M_TPM:
  vias: v1(146.21,18.19)
+3.3V_MMI_AUX: length 7.7
  IN3 w0.508: v2(24.67,24.18) 23.1,24.18 21.51,22.59 20.55,22.59
  BOTTOM w0.109: v1(15.89,24.2) 16.33,23.75 v2(16.33,23.26)
  BOTTOM w0.381: v2(16.33,23.26) 16.12,23.04 RR201.1
  BOTTOM w0.508: RR211.1 24.41,24.45 v2(24.67,24.18)
  vias: v2(19.22,22.85) v2(19.84,22.8) v2(20.65,8.73) v2(20.65,8.14)
+3.3V_MV:
  vias: v1(21.63,12.89) v2(15.21,21) v2(15.62,20.51) v2(16,21) v2(16.23,20.44) v2(18.88,10.31) v2(18.88,9.73) v2(23.49,7.89) v2(23.51,12.1) v2(24.08,8.02) v2(24.08,7.25) v2(24.71,5.6)
+3.3V_PGPPBC: length 3.4
  TOP w0.254: v2(130.25,36.89) 129.91,36.55 UH1.AN26 UH1.AP26
  BOTTOM w0.109: v1(127.85,37.24) 128.01,37.24 128.86,36.39 RH304.2
+3.3V_PGPPEF: length 1.5
  TOP w0.254: v2(133.07,30.99) 133.45,30.99 UH1.AE36 ; v2(133.04,31.57) 133.04,31.83 133.14,31.93 UH1.AE35
+3.3V_PGPPG: length 1.7
  TOP w0.254: v2(129.92,39.29) 129.92,39.29 UH1.AN21
  BOTTOM w0.109: v2(129.92,39.29) v1(129.92,39.78)
  BOTTOM w0.254: v2(129.92,39.29) 129.69,39.06 RH305.2
+3.3V_PGPPHK: length 4.3
  TOP w0.254: UH1.AC35 134.98,31.93 135.33,31.58 v2(135.39,31.58) ; UH1.AC36 135.13,31.17 v2(135.3,30.99)
  BOTTOM w0.109: v1(136.76,28.58) 136.37,28.97 136.37,30.79 135.99,31.17 CH64.1
+3.3V_PHVC: length 3.4
  TOP w0.254: v2(125.93,44.52) 125.97,44.55 UH1.AW9
  BOTTOM w0.305: RH299.2 124.03,44.92 124.93,44.92 v1(125.2,44.66) 125.4,44.46 125.88,44.46 v2(125.93,44.52)
+3.3V_PHVLDO: length 2.2
  TOP w0.254: UH1.AY8 126.27,45.22 125.81,45.22 v2(125.73,45.14) 125.55,45.32 UH1.BB7
  BOTTOM w0.381: CH37.1 125.78,46.86 126.01,46.63 126.01,46.08 126.02,46.06
  vias: v1(120.23,46.18)
+3.3V_PRTC: length 1.5
  TOP w0.254: UH1.BC49 124.75,24.85 124.53,24.63 124.53,24.46 v2(124.36,24.28) 124.25,24.39 UH1.BD49
  vias: v1(124.6,24.88)
+3.3V_PUSB2: length 2.7
  TOP w0.254: UH1.V23 v2(136.9,37.1)
  BOTTOM w0.109: v1(135.76,38.29) 135.76,37.54 RH302.2
  BOTTOM w0.508: RH302.2 136.78,37.21 v2(136.9,37.1)
+3.3V_RTC_LDO: length 327.5
  TOP w0.508: PR105.2 128.17,111.39 127.94,111.17 v2(127.94,111.11)
  IN1 w0.508: v2(262.33,63.44) 262.33,63.2 263.26,62.27 263.95,62.27 265.95,64.26 265.95,66.5 267.64,68.19 291.36,68.19 292.49,67.06 292.49,64.54 293.43,63.6 296.21,63.6 297.46,62.35 308.64,62.35 309.99,61 314.78,61 316.56,59.22 316.56,57.47 316.15,57.06 316.15,51.42 314.91,50.18 314.02,50.18 313.14,49.3 313.14,40.96 313.09,40.92 313.09,34.68 308.83,30.42 v2(303.91,30.42)
  IN2 w0.508: v2(167.21,102.25) 168.24,103.29 168.24,108.31 165.59,110.96 162.95,110.96 161.69,112.22 161.69,113.39 160.8,114.29 150.27,114.29 149.72,114.83 147.67,114.83 145.73,116.77 141.6,116.77 140.54,117.83 139.65,117.83 138.63,118.85 132.3,118.85 131.75,118.29 131.75,117.69 129.28,115.23 129.13,115.23 128.17,114.26 128.17,112.24 127.94,112.01 v2(127.94,111.11)
  IN3 w0.508: 257.88,64.99 257.89,64.98 261.71,64.98 262.27,64.42 262.27,63.5 v2(262.33,63.44) ; 255.76,66.24 255.57,66.43 255.57,66.45 255.44,66.58 255.44,67.15 254.38,68.22 254.38,72.29 254.01,72.66 252.88,72.66 252.38,72.16 236.93,72.16 236.38,71.62 236.38,70.83 235.71,70.16 235.04,70.16 231.33,73.87 231.33,79.57 229.91,80.99 221.74,80.99 221.28,81.45 218.15,81.45 216.63,82.97 194.06,82.97 192.47,84.55 190.07,84.55 188.95,83.43 180.3,83.43 179.11,84.62 174.18,84.62 172.3,82.75 172.3,81.68 170.46,79.83 170.46,75.53 169.59,74.66 169.59,71.47 169.93,71.12 169.93,69.68 v2(171.02,68.59)
  IN4 w0.508: v2(167.21,102.25) 167.21,100.6 169.94,97.87 169.94,96.22 168.98,95.26 168.98,94.38 168.41,93.8 167.22,93.8 165.02,91.61 165.02,88.56 160.27,83.81 v2(160.27,83.38)
  BOTTOM w0.508: PD8.3 v2(303.91,30.42) ; v2(171.02,68.59) 171.02,68.7 170.28,69.43 v1(169.39,69.43) 168.22,70.6 168.22,75.76 160.6,83.38 v2(160.27,83.38)
+3.3V_RUN: length 563.8
  TOP w0.203: UV8.51 294.23,81.74 294.12,81.85 294.12,82.17 v2(294.27,82.33) ; UV64.26 160.75,119.35 v2(160.81,119.4) ; UV8.21 304.1,78.14 304.25,77.99 304.25,77.12 v2(303.91,76.77) ; UV64.21 160.7,117.35 ; v2(304.09,82.21) 304.26,82.03 304.26,81.88 304.13,81.74 UV8.30 ; UV64.60 150.5,117.35 v2(150.16,117.02) ; UV64.35 157.62,122.52 v2(157.7,122.61) ; 151.57,122.69 152.02,122.25 UV64.49 ; UV8.5 296.97,76.71 296.8,76.55 v2(296.64,76.55) ; v2(293.81,78.8) 293.81,79.06 294.08,79.34 UV8.57
  TOP w0.254: RH124.2 116.12,32.71 v2(116.12,32.72) ; v2(121.71,117.21) 121.71,116.97 121.37,116.63 RH319.1 ; JUSH1.8 336.37,50.05 336.46,50.14 336.74,50.14 ; v2(115.75,41.44) 115.51,41.44 115.21,41.15 115.21,40.62 115.45,40.38 115.98,40.38 116.31,40.71 RH373.2 ; RH402.1 115.77,31.13 v2(115.61,30.97)
  TOP w0.305: RC444.2 128.79,20.78 v2(128.89,20.78) ; UV65.5 164.69,125.58 164.27,125.16 CV844.1
  TOP w0.33: RH267.2 116.74,32.82 RH123.2
  TOP w0.381: RH378.1 115.96,41.63 115.77,41.44 v2(115.75,41.44) ; CV844.1 163.09,125.16 162.51,125.74 v2(162.51,126.25) ; RH324.1 369.39,13.37 368.86,13.9 v2(368.86,14.01) ; RV59.1 291.76,81.96 291.18,81.96 v2(290.93,82.21) ; CZ72.1 338.91,49.88 338.64,50.14 CZ67.1 336.74,50.14 ; RH267.2 116.65,33.26 v2(116.12,32.72) ; v2(291.37,80.36) 291.4,80.39 RV61.1
  TOP w0.508: v2(175.84,92.4) 175.35,91.91 RD23.1 RD22.1 ; v2(137.15,19.87) 137.15,20.17 137.41,20.44 RZ365.2 ; v2(84.4,49.25) 83.8,49.25 RV886.2 ; RV822.2 156.8,126.2 v2(156.49,126.51) ; v2(118.33,32.68) 118.89,32.68 RH331.1 ; v2(127.47,75.33) 127.58,75.22 RE67.2 ; RV63.1 291.03,78.58 v2(290.99,78.62) ; 160.7,117.35 161.21,117.35 CV816.1 161.37,117.78 160.98,118.17 v2(160.8,118.17) ; v2(150.96,124.3) 150.9,124.23 CV813.1 150.9,123.37 151.57,122.69 ; RV840.1 128.1,135 v2(127.84,135.27) ; RV126.1 304.38,74.01 304.12,73.75 v2(304.01,73.75) ; v2(84.4,48.1) 83.77,48.1 RV885.2 ; v2(291.36,75.83) 291.41,75.83 291.53,75.71 RV127.1 RV125.1 ; v2(113.56,66.38) 113.73,66.55 RE557.2 113.41,67.9 113.3,68.01 112.64,68.01 111.96,67.32 109.17,67.32 108.99,67.15 v2(104.54,67.15) ; RV739.1 165.81,107.44 v2(166.57,106.68) 166.88,106.68 167.68,107.48 167.68,109.16 168.02,109.5 170.08,109.5 170.6,108.98 RV740.1 ; RV825.2 147.15,116.36 146.89,116.63 v2(146.89,116.87) 146.67,116.65 145.88,116.65 145.02,117.52 145.02,118.46 146.14,119.57 v2(146.89,119.57) 147.05,119.41 RV823.2 ; RV825.2 RV828.2 ; RV825.2 RV824.2 ; v2(144.88,130.89) RV900.1 ; v2(293.47,74.23) 293.79,74.23 RV65.1 ; v2(290.93,82.21) 290.83,82.31 290.83,83.26 291.67,84.09 RV57.1 ; RH214.1 116.04,46.62 v2(115.8,46.39) ; RD88.2 192.36,91.03 RD46.1 192.84,91.03 193.04,91.23 v2(193.04,91.24) ; v2(339.39,50.54) 339.39,49.9 CZ72.1 ; RZ508.1 120.55,76.17 121.39,75.32 v2(121.39,73.82) 121.37,73.8 RZ505.1 ; v2(308.71,68.59) 308.51,68.59 306.37,66.46 303.94,66.46 303.58,66.82 RZ504.1 ; RD94.2 v2(201.69,89.32) ; 46.8,46.1 46.8,46.76 50.76,50.72 RV891.2 50.54,51.93 50.54,54.9 RV855.2 ; v2(309.9,42.03) 309.88,42.05 PR1114.1 ; RD92.2 v2(179.65,91.33) ; v2(84.38,50.48) 84.07,50.18 RV888.2 RV887.2 ; RT643.2 39.79,56.98 39.32,57.45 36.91,57.45 v2(36.46,57.9) ; v2(146.91,121.95) RV827.2 RV826.2 ; RH90.1 342.87,46.83 342.87,53.64 341.22,55.29 v2(341.22,55.41) ; v2(146.82,132.03) 146.49,131.7 RV901.1 ; v2(273.32,75.11) 273.32,74.65 RZ542.2 ; v2(115.33,39.2) 115.94,39.2 RH360.1 RH361.1
  IN1 w0.508: v2(170.54,63) 170.41,63.14 170.41,64.28 171.02,64.89 171.73,64.89 172.36,65.52 172.36,70.8 170.47,72.7 170.47,73.54 170.97,74.03 170.97,75.34 v2(169.65,76.65)
  IN2 w0.508: v2(28.22,61.76) 29.59,61.76 33.45,57.9 v2(36.46,57.9) ; v2(113.56,66.38) 113.56,66.85 116.29,69.59 118.67,69.59 121.39,72.31 v2(121.39,73.82)
  IN3 w0.508: v2(131.23,76.43) 130.67,75.87 128.8,75.87 128.26,75.33 v2(127.47,75.33) 127.21,75.07 126.69,75.07 126.36,75.4 124.12,75.4 123.08,74.36 121.93,74.36 v2(121.39,73.82) ; v2(169.65,76.65) 168.08,75.07 v2(164.92,75.07) ; v2(170.54,63) 170.95,63.41 172.54,63.41 173.2,62.75 182.71,62.75 183.76,61.69 192.9,61.69 193.96,62.75 198.07,62.75 198.84,61.98 v2(198.84,61.71) ; v2(166.57,106.68) 166.57,107.14 169,109.57 169,121.97 164.72,126.25 v2(162.51,126.25) ; v2(147.19,15.45) 147.26,15.51 147.26,17.28 146.5,18.03 145.14,18.03 144.36,18.81 143.28,18.81 142.67,19.42 140.58,19.42 140.14,19.87 v2(137.15,19.87) ; v2(341.22,55.41) 340.09,54.28 340.09,51.21 339.42,50.54 v2(339.39,50.54) ; v2(273.32,75.11) 273.32,74.84 274.46,73.7 292.94,73.7 v2(293.47,74.23) ; v2(309.9,42.03) 310.19,41.74 314.11,41.74 314.65,41.2 v2(314.65,40.91) 314.65,39.63 312.93,37.9 311.49,37.9 308.71,35.13 308.71,31.36 310.32,29.75 310.32,24.02 309.19,22.89 308.63,22.89 ; v2(275.76,92.98) 275.76,93.05 275.21,93.61 274.41,93.61 273.74,92.94 273.74,92.14 273.22,91.62 272.16,91.62 271.26,92.52 269.84,92.52 268.26,90.94 268.26,86.64 267.26,85.64 254.61,85.64 253.91,86.35 253.91,87.32 253.58,87.65 250.87,87.65 250.06,88.46 245.77,88.46 245.5,88.72 244.41,88.72 243.84,89.3 243.84,92.99 243.78,93.05 243.77,93.05 243.42,93.41 243.42,93.41 242.74,94.09 v2(240.14,94.09)
  IN4 w0.508: v2(127.84,135.27) 127.84,134.51 129.55,132.79 134.33,132.79 v2(137.06,130.06) ; v2(164.92,75.07) 163.63,76.36 163.63,83.37 167.99,87.73 167.99,90.03 170.36,92.4 v2(175.84,92.4)
  BOTTOM w0.203: CV64.1 294.01,79.21 293.81,79.01 v2(293.81,78.8) ; v2(304.09,82.21) 304.06,82.18 CV60.1 ; v2(294.27,82.33) 294.27,81.69 CV61.1
  BOTTOM w0.305: RH355.1 127.52,39.01 v2(127.52,39.3) 126.66,39.3 RC370.2 ; JESPI.2 99.83,14.59 v2(100.12,14.29) 100.33,14.49 JESPI.1 ; LGA1.9 307.63,23.74 ; LGA1.3 304.37,24.24 v2(304.15,24.02) 304.43,23.74 LGA1.2 ; LGA1.10 307.55,23.24
  BOTTOM w0.356: v2(303.91,76.77) 304.06,76.93 CV62.1 ; v2(160.81,119.4) 160.73,119.33 CV815.1 160.08,118.9 v2(160.8,118.17) ; CV817.1 156.6,121.97 157.07,121.97 v2(157.7,122.61)
  BOTTOM w0.457: v2(128.89,20.78) 128.89,20.19 RT644.1
  BOTTOM w0.508: RV893.2 69.21,58.33 68.93,58.61 64.8,58.61 64.63,58.44 v2(64.46,58.44) ; v2(175.84,92.4) 177.16,92.4 178.16,91.4 ; v2(169.65,76.65) 169.26,76.65 168.3,77.62 RD16.2 ; 122.5,55.39 121.54,54.42 121.54,51.37 118.86,48.7 118.12,48.7 v2(115.8,46.39) ; v2(368.86,14.01) 368.88,13.98 RN203.2 ; v2(296.64,76.55) 296.66,76.55 296.82,76.71 CV63.1 297.03,77.94 RV55.1 ; v2(313.97,15.81) 314.3,16.14 RN200.2 ; v2(126.72,99.05) 127.15,99.48 RN211.2 ; 208.84,81.24 208.84,88.38 206.78,90.44 203.99,90.44 202.86,89.31 201.69,89.31 201.69,89.31 ; 208.84,81.24 205.63,78.02 RD86.2 205.11,76.8 204.08,75.76 202.21,75.76 200.45,77.52 RD85.2 ; 208.84,81.24 211.75,78.33 221.52,78.33 227.78,84.58 234.59,84.58 235.9,85.89 237.31,85.89 238.13,86.71 238.13,92.48 239.74,94.09 v2(240.14,94.09) ; RN208.2 v2(314.65,40.91) ; v2(131.23,76.43) 130.73,76.93 RZ507.1 ; RV879.2 RV878.2 RV877.2 RV848.2 v2(58.49,39.18) ; RZ89.1 144.9,15.37 145.37,14.9 146.81,14.9 147.19,15.28 v2(147.19,15.45) 147.79,15.45 148.13,15.1 RD17.1 ; 201.69,89.31 199.15,91.85 193.38,91.85 193.04,91.51 v2(193.04,91.24) 193.03,91.22 192.35,91.22 191.73,91.84 184.86,91.84 184.38,91.36 182.92,91.36 ; 201.69,89.31 v2(201.69,89.32) ; v2(333.32,55.41) 333.02,55.11 RH380.1 ; RH76.1 128.85,21.39 128.89,21.35 v2(128.89,20.78) ; RV904.1 v2(164.92,75.07) ; v2(150.96,124.3) 150.96,123.18 149.73,121.95 v2(146.91,121.95) 147.83,121.02 147.83,119.98 147.42,119.57 v2(146.89,119.57) ; v2(179.65,91.33) 179.47,91.15 RD14.1 ; v2(198.84,61.71) 199.28,61.27 RD40.1 ; RN2.1 v2(304.16,21.83) ; RH350.2 118.7,36.35 118.4,36.64 v2(118.34,36.64) ; v2(146.89,116.87) 147.11,117.1 149.27,117.1 149.85,117.67 149.92,117.67 CV814.1 150.16,117.45 v2(150.16,117.02)
  vias: v2(5.2,32.4) v2(5.48,31.69) v2(6.02,32.12) v2(6.09,31.28) v2(6.53,30.85) v2(6.78,32.2) v2(6.8,31.46) v2(27.17,7.27) v2(27.23,6.65) v2(27.31,7.85) v2(27.47,62.6) v2(27.81,7.15) v2(28.37,62.64) v2(29.03,62.62) v2(36.39,2.2) v2(37.03,2.18) v2(37.62,2.15) v2(37.89,2.81) v2(46.71,45.19) v2(47.16,45.59) v2(58.04,58.03) v2(58.23,10) v2(58.62,57.8) v2(59.1,10.01) v2(59.87,9.96) v2(60.14,35.27) v2(60.78,35.3) v2(61.49,35.27) v2(61.48,34.65) v2(62.22,35.27) v2(62.21,34.65) v2(63.04,35.28) v2(63.03,34.66) v2(66.37,41.29) v2(67.76,41.04) v2(69.11,41.49) v2(69.54,41.04) v2(71.54,41.2) v2(82.5,60.47) v2(83.51,60.47) v2(108.91,24.27) v2(123.2,32.27) v2(124.46,57.95) v2(124.47,57.34) v2(127.89,34.23) v2(128.46,34.23) v2(135.01,21.67) v2(137.06,129.3) v2(147.39,135.3) v2(147.93,134.86) v2(277.52,86.68) v2(278.15,86.83) v2(279.6,93.87) v2(280.22,94.05) v2(308.1,23.27) v2(308.1,22.68) v2(308.19,16.21) v2(308.19,15.62) v2(308.68,23.27) v2(308.68,22.68) v2(308.77,16.21) v2(308.77,15.62) v2(372.56,32.4) v2(372.56,31.76) v2(372.56,31.13) v2(372.56,30.49) v2(373.2,32.4) v2(373.2,31.76) v2(373.2,31.13) v2(373.2,30.49) v2(373.83,32.4) v2(373.83,31.76) v2(373.83,31.13) v2(373.83,30.49) v2(374.47,32.4) v2(374.47,31.76) v2(374.47,31.13) v2(374.47,30.49) v2(388.93,13.63) v2(388.91,13.04) v4(138.25,129.3)
+3.3V_RUN_AUDIO: length 105.9
  TOP w0.356: v2(376.39,22.49) 376.33,22.43 376.14,22.43 374.68,20.96 LA14.1
  TOP w0.381: v2(376.14,27.03) 376.64,26.52 LA12.1
  TOP w0.508: RA224.1 341.76,8.75 v2(341.86,8.65)
  IN1 w0.508: v2(376.14,27.03) 376.34,26.82 376.34,24.35 376.9,23.79 376.9,23 v2(376.39,22.49) 376.71,22.18 376.71,21.03 375.48,19.8 375.48,19.44 375.02,18.97 375.02,16.68 375.92,15.78 375.92,15.32 376.34,14.9 376.34,14.14 375.98,13.78 374.97,13.78 373.83,14.91 367.94,14.91 365.83,12.81 365.83,12.09 365.06,11.32 363.9,11.32 362.77,10.19 355.65,10.19 354.01,8.55 354.01,3.05 352.63,1.67 350.21,1.67 349.54,2.34 346.06,2.34 345.84,2.55 343.61,2.55 342.15,4.02 342.15,8.36 v2(341.86,8.65)
  IN2 w0.508: v2(390.8,13.98) 390.73,13.91 390.73,12.88 390.05,12.21 386.28,12.21 385.85,12.64 381.91,12.64 381.55,13 381.55,13.84 382.32,14.61 382.32,15.94 381.93,16.32 381.11,16.32 380.63,16.8 380.63,17.56 381.61,18.54 381.61,19.21 380.86,19.97 379.77,19.97 377.25,22.49 v2(376.39,22.49) ; v2(390.9,20.59) 390.9,20.46 391.44,19.93 391.44,19.51 393.46,17.49 393.46,16.65 391.44,14.63 v2(391.44,13.96)
  BOTTOM w0.109: 390.7,12.8 v4(390.7,11.58)
  BOTTOM w0.508: v2(390.9,20.59) 391.21,20.89 RA219.1
+3.3V_RUN_AUDIO_DVDD:
  vias: v1(376.35,24.48)
+3.3V_RUN_AUDIO_IO: length 10
  TOP w0.203: UA1.18 381.53,19.52 381,18.99 v2(381,18.85)
  TOP w0.356: v2(376.12,19.32) 376.21,19.23 CA10.1 CA61.1
  TOP w0.508: LA14.2 376.69,20.21 CA61.1
  IN1 w0.508: v2(376.12,19.32) 378.9,19.32 378.91,19.33 380.64,19.33 381,18.97 v2(381,18.85)
  BOTTOM w0.109: v2(381,18.85) v1(381,19.36)
+3.3V_RUN_DIMM1:
  vias: v1(170.95,80.34)
+3.3V_RUN_DIMM2: length 8.4
  TOP w0.109: CD63.1 181.75,88.92 181.75,89.41
  TOP w0.305: 180.48,82.82 180.48,81.45 180.7,81.23 JDIMM2.255
  TOP w0.508: 180.48,82.82 180.48,87.88
+3.3V_RUN_DIMM3: length 13.8
  BOTTOM w0.305: JDIMM3.255 186.17,81.22 185.79,81.61 185.79,81.8
  BOTTOM w0.508: 182.61,87.6 180.89,87.6 180.44,87.14 180.44,85.57 181.55,84.46 184.91,84.46 185.79,83.58 185.79,81.8
+3.3V_RUN_DIMM4: length 1.6
  TOP w0.109: RD94.1 200.29,88.6 200.68,88.99 v1(200.68,89.31)
+3.3V_RUN_PWR: length 1.9
  TOP w0.109: 370.47,30.76 370.47,30.03 370.22,29.77 v1(370.22,28.92)
+3.3V_RUN_R: length 21.1
  TOP w0.254: JEDP1.10 117.7,119.91 118.58,120.79 v2(121.82,120.79)
  BOTTOM w0.508: RZ551.1 132.37,126.19 v1(128.95,126.19) 123.71,126.19 121.23,123.71 121.23,121.38 v2(121.82,120.79)
+3.3V_RUN_R_F: length 1.5
  BOTTOM w0.109: QZ1.3 v1(131.98,128.36)
+3.3V_SPI: length 121.1
  IN1 w0.508: v2(124.82,21.19) 124.13,21.88 124.13,22.3 125.94,24.1 125.94,24.73 125.43,25.24 122.18,25.24 121.59,24.66 121.59,23.85 122.3,23.14 v2(122.3,23.05) ; v2(136.04,21.3) 136.29,21.3 136.6,21 136.6,20.44 136.27,20.11 135.76,20.11 135.38,19.73 135.38,15.79 135.91,15.25 135.91,12.71 135.42,12.22 130.81,12.22 130.26,12.77 v2(121.44,12.77) 119.1,12.77 117.4,14.47 112.82,14.47 110.19,11.84 107.34,11.84 104.89,14.29 v2(104.89,14.4) 104.33,14.4 103.73,13.81 103.01,13.81 100.21,16.6 100.21,18.54 100.91,19.24 100.91,20.78 103.11,22.98 103.11,24.98 101.75,26.34 v2(101.75,27.09) ; v2(114.44,20.65) 113.93,20.65 113.33,20.06 112.51,20.06 v2(111.9,20.67) 111.4,20.17 111.36,20.17 111.31,20.12 108.91,20.12 106.47,17.68 v2(106.47,17.06)
  IN2 w0.508: v2(124.82,21.19) 125.04,20.97 125.04,19.06 123.14,17.16 123.14,14.47 v2(121.44,12.77)
  IN4 w0.508: v2(106.47,17.06) 106.47,16.49 105.52,15.53 105.52,15.04 v2(104.89,14.4)
  BOTTOM w0.127: v4(99.79,27.83) 100.04,28.07 101.32,28.07 101.53,27.85 CH270.1
  BOTTOM w0.356: v2(122.3,23.05) 122.64,22.71 CH9.1
  BOTTOM w0.381: UC5.8 123.98,21.6 123.01,22.57 CH9.1 ; v2(101.75,27.09) 101.75,27.24 101.53,27.46 CH270.1 102.23,28.39 UC6.8
  BOTTOM w0.457: RH335.1 111.9,21.99 v2(111.9,20.67) 111.41,20.18 RH600.1
  BOTTOM w0.508: RH185.2 103.15,16.77 106.19,16.77 v2(106.47,17.06) 106.47,19.57 106.08,19.97 101.23,19.97 100.42,20.78 JSPI1.15 ; v2(114.44,20.65) 114.01,21.08 RH30.1
+3.3V_SSD3:
  vias: v2(328.24,14.32) v2(328.25,13.7) v2(328.36,30.74) v2(328.5,28.34) v2(328.5,27.45) v2(328.99,13.84) v2(329.02,30.78) v2(329.13,28.34) v2(329.15,27.44) v4(314.07,13.02)
+3.3V_SSD3_PWR:
  vias: v1(331.79,15.94)
+3.3V_SSD4: length 6.1
  IN4 w0.508: v2(364.42,13.94) 364.44,13.92 364.44,13.68 365.32,12.8 365.32,9.49 365.63,9.17
  BOTTOM w0.381: v2(364.42,13.94) 364.42,13.91 364.11,13.6 364.11,13.25 RN202.2
  vias: v2(361.09,7.48) v2(361.09,6.84) v2(361.09,6.21) v2(361.13,8.14) v2(361.76,8.26) v2(361.76,7.53) v2(361.76,6.9) v2(361.76,6.26) v2(361.76,5.63) v2(383.16,8.94) v2(384.33,8.7) v2(384.93,8.95) v4(360.58,9.51)
+3.3V_SSD4_PWR:
  vias: v1(355.2,11.19)
+3.3V_SSD5:
  vias: v2(326.54,36.98) v2(326.54,36.4) v2(327.12,36.98) v2(327.12,36.4) v2(327.78,56.31) v2(327.72,53.35) v2(327.71,36.98) v2(327.71,36.4) v2(328.25,52.96) v2(328.29,36.98) v2(328.29,36.4) v2(328.35,53.59) v2(328.5,56.33) v2(328.99,52.98) v2(329.01,53.59) v2(332.33,28.54) v2(332.33,27.95) v2(332.92,28.54) v2(332.92,27.95) v2(333.5,28.54) v2(333.5,27.95) v2(334.08,28.56) v2(334.08,27.98) v4(319.33,64.09)
+3.3V_SSD5_PWR:
  vias: v1(331.09,22.19)
+3.3V_SSD6:
  vias: v2(124.01,92.46) v2(124.01,91.85) v2(134.45,92.15) v2(135.02,92.54) v2(135.02,91.96) v2(135.61,92.54) v2(135.61,91.96) v2(136.19,92.54) v2(136.19,91.96) v4(134.29,84.91)
+3.3V_SSD6_PWR: length 1
  BOTTOM w0.127: 129.7,83.25 v1(129.7,82.3)
+3.3V_TBT:
  vias: v1(23.99,58.93)
+3.3V_TBT_ANA: length 2.9
  TOP w0.109: CT302.1 32.87,45.04 v1(31.77,45.04)
  TOP w0.305: CT302.1 33.34,45.4 v2(33.83,45.9)
  BOTTOM w0.254: v2(33.83,45.9) UT1.E16
+3.3V_TBT_ANA_PCIE: length 8.9
  TOP w0.305: v2(37.74,41.01) 37.17,41.01 v1(36.79,41.39) 35.8,42.38 RT554.2 35.17,42.38 35.13,42.34 CT301.1
  IN3 w0.254: 37.49,44.48 37.21,44.48 36.45,45.24 v2(36.44,45.24)
  IN3 w0.305: v2(37.74,41.01) 37.74,41.06 37.69,41.11 37.69,44.27 37.49,44.48
  BOTTOM w0.254: v2(36.44,45.24) UT1.L16
+3.3V_TBT_ANA_USB2: length 1.1
  TOP w0.305: CT300.1 35.83,45.19 v2(35.79,45.24)
  BOTTOM w0.254: UT1.H18 v2(35.79,45.24)
+3.3V_TBT_FLASH_R: length 31.3
  TOP w0.508: RT578.1 56.22,33.62 v1(55.2,34.64) v2(54.57,35.27)
  IN2 w0.508: v2(54.57,35.27) 52.15,35.27 47.24,40.19 v2(47.24,41.89) 47.24,42.48 45.66,44.07 45.66,48.9 48.48,51.73 48.48,52.89 47.99,53.38 v2(47.72,53.38)
  BOTTOM w0.508: RT9.1 46.04,51.45 46.58,52 46.58,52.96 47,53.38 v2(47.72,53.38)
+3.3V_TBT_LC: length 22.4
  TOP w0.381: v2(40.34,49.79) 40.47,49.65 CT303.1
  TOP w0.508: v2(42.24,40.76) 42.34,40.86 42.34,41.37 41.86,41.85 RT5.2 RT7.2 RT8.2 40.03,41.8 RT6.2
  IN1 w0.508: v2(42.24,40.76) 41.68,41.32 41.68,48.78 41.32,49.14 40.59,49.14 40.34,49.39 v2(40.34,49.79)
  IN2 w0.508: v2(42.95,51.12) 42.5,51.12 42.19,50.81 42.19,49.75 41.6,49.16 40.67,49.16 40.34,49.5 v2(40.34,49.79)
  BOTTOM w0.109: v1(44.35,52.44) 44.22,52.31 RT9.2
  BOTTOM w0.254: UT1.V6 v2(40.34,49.79)
  BOTTOM w0.381: v2(42.95,51.12) 43.36,51.12 43.69,51.45 RT9.2
+3.3V_TBT_S0: length 7.4
  TOP w0.203: CT327.1 37.72,51.78 38.16,51.34 38.16,50.86 37.47,50.18 37.35,50.18 v2(37.09,50.44)
  TOP w0.254: CT325.1 32.92,50.69 v2(33.83,49.78)
  BOTTOM w0.178: UT1.H2 UT1.G2 UT1.G1 35.11,53.06 v2(35.13,53.07)
  BOTTOM w0.203: v2(37.09,50.44) 36.76,50.11 UT1.L6 ; v2(33.83,49.78) 34.16,50.11 UT1.E6
  vias: v1(25.05,56.42) v2(25.58,56.5) v2(25.63,55.88) v2(25.6,55.26) v2(35.13,54.62)
+3.3V_TBT_SX: length 14.7
  TOP w0.254: CT314.1 35.14,45.66 35.14,45.27 35.15,45.27 v2(35.15,45.25) ; RT503.2 42.52,48.94 43.46,48.94 43.69,49.16 v2(43.69,49.44)
  TOP w0.356: RT592.2 40.33,53.56 RT372.2 ; RT16.2 37.06,53.56 RT17.2 37.06,54.01 v2(36.73,54.35)
  TOP w0.381: RT503.2 RT502.2 ; CT315.1 38.31,49.79 v2(39.04,49.79)
  TOP w0.508: 43.56,55.65 42.61,54.7 41.65,54.7 41.08,54.13 40.62,54.13 40.23,53.74 RT372.2 ; v2(41.22,56.21) 41.46,56.45 RT593.2
  BOTTOM w0.203: UT1.R6 v2(39.04,49.79)
  BOTTOM w0.254: UT1.F18 v2(35.15,45.25)
  BOTTOM w0.356: RT613.2 v2(45.51,54.85)
  BOTTOM w0.508: v2(41.22,56.21) 41.55,56.54 RT20.2 ; v2(31.32,57.42) 31.86,57.42 RT11.2
  vias: v1(44.87,56.3) v2(47.12,57.17) v2(47.95,57.16)
+3.3V_TP: length 9
  TOP w0.381: JKBTP1.12 18.84,6.65 17.57,7.91 v2(17.04,7.91)
  BOTTOM w0.109: v2(34.69,4.35) v4(34.06,4.35)
  BOTTOM w0.381: CZ90.1 17.19,7.76 v2(17.04,7.91)
  BOTTOM w0.508: RZ117.1 31.63,8.97 RZ116.1 ; RZ117.1 31.42,9.92 30.93,9.92 v2(30.81,10.05) ; RZ117.1 31.69,9.76 RZ20.1 32.42,9.77 RZ21.1 ; RZ19.1 29.2,9.88 RZ18.1 v2(29.85,10.63)
  vias: v2(35.35,4.37)
+3.3V_VDD_PIC: length 183.5
  TOP w0.254: CT371.2 40.99,18.67 v2(40.71,18.39)
  TOP w0.305: PR2029.2 51.54,18.68 v2(51.41,18.68)
  TOP w0.381: PR71.1 v2(66.52,30.22) ; PR70.1 v2(78.43,16.72) ; PC5.2 84.69,17.64 PU1.5
  TOP w0.508: v2(51.94,13.78) 52.14,13.98 52.14,16.88 52.04,16.98 PR2029.2 ; v2(87.5,16.65) 87.75,16.9 PR20.1 ; v2(43.86,10.78) 43.58,11.06 RT547.2 ; v2(84.68,16.68) 84.44,16.92 PC5.2 ; v2(50.24,23.03) 50.47,22.8 PR2025.2 ; RT578.2 56.5,32.54 v2(56.5,32) 56.15,31.65 PR39.1
  IN1 w0.381: v2(40.71,18.39) 40.42,18.39 39.49,19.32 v2(39.49,19.65) 39.08,19.65 38.27,18.84 v2(34.08,18.84) 33.93,18.99 30.63,18.99 30.05,19.57 27.89,19.57 26.19,21.27 24.94,21.27 24.61,20.94 20.95,20.94 20.41,21.48 20.41,23.75 v2(20.37,23.79)
  IN1 w0.508: v2(76.11,29.65) 76.11,29.72 75.97,29.86 74.06,29.86 73.1,28.89 68.1,28.89 67.41,29.58 67.16,29.58 v2(66.52,30.22) ; 43.71,20.16 43.76,20.21 43.76,21.15 43.18,21.73 43.18,22.45 43.81,23.08 45.51,23.08 v2(45.77,23.33) ; 43.71,20.16 42.48,20.16 v2(40.71,18.39) ; 43.71,20.16 v2(43.79,20.16)
  IN2 w0.508: v2(9.81,32.2) 9.81,35.68 9.6,35.89 v2(9.6,36.46) ; v2(51.94,13.78) 51.94,14.32 51.51,14.75 49.48,14.75 48.87,15.36 v2(48.05,15.36) 47.6,15.36 47.24,15 41.4,15 41.05,14.66 v2(40.9,14.66) ; v2(45.77,23.33) 46.14,23.7 48.88,23.7 49.2,24.02 50.11,24.02 50.24,23.89 v2(50.24,23.03)
  IN3 w0.381: 40.24,14 39.61,14 38.3,15.31 33.5,15.31 32.95,14.76 v2(32.49,14.76)
  IN3 w0.508: v2(20.37,23.79) 20.02,24.14 v2(16.96,24.14) 15.69,25.42 11.94,25.42 10.49,26.86 10.49,31.52 v2(9.81,32.2) ; v2(40.9,14.66) v2(40.9,14) 40.24,14 ; v2(66.52,30.22) 63.4,33.34 57.84,33.34 v2(56.5,32) 56.5,28.4 54.42,26.33 v2(54.23,26.33) 54.23,26.08 54.58,25.73 55.38,25.73 55.73,25.38 55.73,24.61 54.44,23.33 51.53,23.33 51.23,23.03 v2(50.24,23.03) 50.24,21.71 50.9,21.05 50.9,19.19 v2(51.41,18.68)
  BOTTOM w0.254: PR2037.2 72.51,25.11 73.33,25.11 73.47,25.25 73.7,25.25 74.14,25.69 74.14,26.25 74.34,26.46 74.52,26.46 PR2041.1
  BOTTOM w0.305: PU2001.8 51.34,17.29 50.44,17.29 PC2007.1 PC2008.1 49.35,18.17 49.66,18.48 PR2024.2 50.29,18.48 50.49,18.68 v2(51.41,18.68) ; UT12.5 45.05,24.38 45.77,23.66 v2(45.77,23.33)
  BOTTOM w0.356: v2(34.08,18.84) 34.08,19.06 33.32,19.83 33.32,20.79 CT370.2 33.45,21.53 33.45,21.93 33.94,22.43 UT10.5
  BOTTOM w0.381: PR72.1 66.52,30.09 v2(66.52,30.22) ; v2(32.49,14.76) 32.54,14.81 PR2048.1 ; PR2027.1 51.23,14.37 51.26,14.34 51.29,14.34 51.42,14.21 51.42,14.09 51.73,13.78 v2(51.94,13.78)
  BOTTOM w0.508: PR72.1 66.5,28.84 67.63,28.84 PR2038.2 68.9,27.13 68.54,26.78 68.54,26.05 69.07,25.52 v4(70.05,25.52) 71.81,25.52 PR2037.2 ; v2(48.05,15.36) 47.56,15.36 PR2050.1 ; PR2147.1 82.85,29.73 82.64,29.52 78.17,29.52 ; RT564.1 11.24,37.2 10.5,36.46 v2(9.6,36.46) ; PR57.1 53.54,26.73 53.94,26.33 v2(54.23,26.33) ; RT569.2 17.79,24.59 17.35,24.14 v2(16.96,24.14) ; PR2028.2 50.72,14.48 PR2027.1 ; v2(43.79,20.16) 43.8,20.17 PR2064.1 ; v2(39.49,19.65) 39.55,19.7 39.55,20.5 PR2063.1 ; v2(50.24,23.03) 50.16,23.1 50.16,23.89 50.58,24.31 PR2023.1
  vias: v2(45.67,11.27) v2(46.25,11.27) v2(46.86,11.27) v2(62.15,11.08) v2(62.15,10.49) v2(62.81,11.1) v2(62.81,10.49)
