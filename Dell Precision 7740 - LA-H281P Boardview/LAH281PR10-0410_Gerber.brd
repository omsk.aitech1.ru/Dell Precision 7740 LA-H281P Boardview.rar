# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
AUD_AZACPU_SDI_R: length 184.7
  TOP w0.102: v2(128.98,49.16) 128.98,49.08 129.38,48.68 129.38,48.34 129.05,48.02 129.05,47.67 129.16,47.56 129.29,47.56 129.5,47.35 UH1.AN3
  TOP w0.109: RC66.2 265.12,66.75 265.66,66.22 265.66,65.92 265.34,65.6 v2(265.03,65.6)
  IN2 w0.081: v2(258.32,77.16) 258.32,76.75 257.99,76.41 257.99,76.12 262.98,71.13 263.92,71.13 264.61,70.44 264.61,67.24 265.55,66.31 265.55,65.84 265.3,65.6 v2(265.03,65.6)
  VCC w0.086: v2(258.32,77.16) 258.16,77.33 256.21,77.33 254.41,75.53 239.35,75.53 237.96,76.91 232.64,76.91 229.63,79.92 221.71,79.92 215.66,85.97 197.59,85.97 196.55,87.01 180.73,87.01 179.25,88.49 178.54,88.49 178.02,89.01 175.4,89.01 174.5,88.1 168.68,88.1 164.99,84.42 164.99,76.44 164.42,75.87 164.42,73.93 165.14,73.22 165.14,69.15 162.58,66.6 v2(162.58,66.45)
  IN3 w0.081: v2(128.98,49.16) 129.49,49.67 131.09,49.67 131.21,49.8 133.68,49.8 134.01,50.13 134.01,51.3 136.21,53.49 139.08,53.49 139.41,53.16 141.7,53.16 143.4,54.86 144.86,54.86 146.97,56.96 148.15,56.96 148.83,57.65 150.65,57.65 154.63,61.64 157.1,61.64 159.68,64.22 160.72,64.22 161.91,65.41 161.91,65.78 v2(162.58,66.45)
  BOTTOM w0.109: v2(258.32,77.16) 257.89,77.16 v1(257.72,77.33)
AUD_AZACPU_SDO: length 166.4
  TOP w0.109: v2(249.44,63.73) 249.12,64.05 UC1.G25 ; RH39.1 129.49,53.75 v2(129.38,53.86) ; v2(150.63,53.34) v1(151.2,53.34)
  IN2 w0.081: v2(129.38,53.86) 129.38,53.69 129.74,53.33 132.2,53.33 133.01,52.52 133.01,50.01 133.33,49.69 134.03,49.69 135.54,51.2 135.54,52.55 137.18,54.19 139.16,54.19 139.75,53.61 141.23,53.61 142.97,55.35 145.13,55.35 145.77,54.7 148.77,54.7 150.13,53.34 v2(150.63,53.34)
  VCC w0.086: v2(150.63,53.34) 151.14,52.84 154.04,52.84 154.4,53.2 158.27,53.2 163.52,58.46 163.52,60.6 168.11,65.19 168.11,71.94 168.68,72.51 169.57,72.51 170.13,73.07 170.13,81.96 172.17,84 176.07,84 177.41,82.65 179.26,82.65 179.44,82.48 188.4,82.48 189.33,81.54 204.3,81.54 205.15,80.69 212.33,80.69 221.59,71.43 228.68,71.43 v2(228.72,71.39)
  IN3 w0.081: v2(249.44,63.73) 249.44,63.43 249.18,63.17 240.84,63.17 240.37,63.63 240.37,66.55 239.53,67.39 236.86,67.39 235.88,66.41 234.93,66.41 233.93,67.41 231.45,67.41 230.53,68.34 230.53,70.3 230.22,70.61 229.67,70.61 229.3,70.98 229.13,70.98 v2(228.72,71.39)
AUD_AZACPU_SDO_R: length 4.2
  TOP w0.102: RH39.2 129.21,51.48 v1(129.21,50.75) 129.21,50.38 129.49,50.1 129.49,50.09 129.7,49.87 129.7,49.13 129.92,48.91 129.92,48.35 130.14,48.13 UH1.AM2
AUD_HP_NB_SENSE: length 19.9
  TOP w0.109: v4(389.91,19.22) 390.01,19.32 v2(390.61,19.32)
  TOP w0.254: v2(390.61,19.32) 390.92,19.62 DA2.3 394.57,19.62 395.8,18.4 JHP1.6 ; v2(387.86,16.78) 387.87,16.76 QA10.2
  BOTTOM w0.254: RA220.1 386.08,15.84 387.02,16.78 v2(387.86,16.78) 388.58,17.5 388.58,19.27 389.44,20.13 390.5,20.13 390.77,19.85 391.13,19.85 391.49,19.5 CA41.1 391.32,19.48 391.16,19.32 v2(390.61,19.32)
AUD_HP_OUT_L: length 6.5
  TOP w0.381: RA7.1 387.8,21.1 v2(388.06,21.35)
  BOTTOM w0.381: v2(388.06,21.35) 389.61,22.9 389.61,23.4 v1(390.77,24.57) LA15.1
AUD_HP_OUT_L1: length 9.7
  TOP w0.109: v2(393.99,27.21) v4(394.41,27.62)
  TOP w0.381: JHP1.1 395.23,26 395.23,26.01 394.84,25.62 DA1.3 393.8,27.02 v2(393.99,27.21)
  BOTTOM w0.381: LA15.2 394.09,25.54 CA3.1 394.24,26.95 v2(393.99,27.21)
AUD_HP_OUT_R: length 5.3
  TOP w0.381: v2(388.05,20.51) 387.87,20.33 RA8.1
  BOTTOM w0.381: LA16.1 390.85,23.13 v1(390.48,22.75) 388.24,20.51 v2(388.05,20.51)
AUD_HP_OUT_R1: length 21.4
  TOP w0.109: DA1.2 390.66,23.69 v4(389.9,22.93)
  TOP w0.381: v2(394.99,22.87) 394.19,22.87 393.8,23.27 DA1.2 397.38,23.69 402.57,18.5 JHP1.2
  BOTTOM w0.381: v2(394.99,22.87) 394.87,23 CA2.1 392.47,23 LA16.2
AUD_PC_BEEP: length 3.9
  TOP w0.203: UA1.34 385.29,24.41 386.67,25.8 CA28.2 CA27.2
AUD_SENSE_A: length 16.7
  TOP w0.203: UA1.48 378.94,25.96 378.74,25.77 v2(378.74,25.73)
  TOP w0.254: QA10.1 387.36,17.49 v2(386.53,18.32)
  IN1 w0.254: v2(378.74,25.73) 378.41,25.4 378.41,21.6 379.49,20.52 383.69,20.52 385.17,19.04 385.81,19.04 v2(386.53,18.32)
  BOTTOM w0.109: v1(385.9,17.99) 386.23,18.32 v2(386.53,18.32)
AUX_EN_WOWL: length 32.8
  TOP w0.109: UE1.D3 v2(134.04,77.25) ; v2(144.98,100.83) 144.98,100.95 RZ379.2 146.37,100.47 RZ70.1 147.25,100.16 DZ9.2
  IN1 w0.102: v2(134.04,77.25) 134.04,77.25 134.47,77.68 134.47,79.77 135.09,80.4 135.09,81.33 134.7,81.72 134.7,84.18 136.62,86.11 136.62,86.59 142.14,92.1 142.14,96.81 144.22,98.9 144.22,100.07 v2(144.98,100.83)
BARREL_DISC: length 119.3
  TOP w0.109: UE1.E7 v2(137.27,76.42)
  IN1 w0.102: v2(99.79,27.26) 99.79,27.86 101.51,29.58 102.98,29.58 103.79,30.4 103.79,31.31 104.34,31.85 104.34,34.21 102.28,36.26 100.04,36.26 99.34,36.97 98.32,36.97 97.31,37.98 97.31,45.8 96.71,46.39 96.71,51.64 101.52,56.45 v2(102.14,56.45)
  IN3 w0.081: v2(102.14,56.45) 105.38,56.45 109.28,60.35 110.85,60.35 111.52,61.03 111.52,61.04 111.52,63.34 112.08,63.9 112.49,63.9 113.74,65.15 114.06,65.15 115,66.08 115,67.08 116.38,68.47 117,68.47 119.72,71.19 121.07,71.19 121.22,71.34 122.12,71.34 125.24,74.46 125.87,74.46 126.21,74.11 126.98,74.11 127.8,73.3 129.58,73.3 131.27,74.98 135.58,74.98 136.08,75.48 136.08,75.79 136.29,76.01 136.85,76.01 v2(137.27,76.42)
  IN4 w0.102: v2(99.79,27.26) 99.39,26.86 97.57,26.86 95.72,25.01 90.85,25.01 89.28,23.44 86.41,23.44 v2(86.19,23.22)
  BOTTOM w0.109: PR2149.2 80.13,28.84 80.65,28.33 81.83,28.33 PC2106.1 82.32,27.83 82.14,27.65 PU2004.1 80.66,27.65 79.96,26.94 79.96,24.6 80.12,24.44 80.12,24.24 81.77,22.58 83.98,22.58 PR2148.2 84.82,22.16 v1(85.55,22.89) 85.88,23.22 v2(86.19,23.22)
BAT1_LED#: length 334
  TOP w0.109: UE1.D10 v2(140.41,77.22)
  IN2 w0.081: v2(140.41,77.22) 140.79,76.85 140.79,75.12 141.37,74.55 142.08,74.55 143.81,72.82 143.81,70.14 145.16,68.8 145.16,68.3 146.51,66.96 147,66.96 147.27,66.69 147.27,66.56 147.76,66.07 148.78,66.07 148.92,65.93 148.92,64.48 150.11,63.29 151.93,63.29 152.67,62.55 154.6,62.55 158.1,59.04 158.92,59.04 163,54.97 163,53.37 163.85,52.52 165.15,52.52 v2(165.3,52.67)
  IN3 w0.081: v2(165.3,52.67) 165.27,52.64 164.66,52.64 162.27,50.24 162.27,43.96 161,42.69 161,38.12 164.98,34.14 164.98,31.17 165.64,30.52 165.64,27.08 165.12,26.56 165.12,22.91 166.28,21.74 166.28,16.06 172.11,10.23 228.58,10.23 234.04,15.69 240.46,15.69 240.52,15.76 247.86,15.76 247.97,15.87 261.11,15.87 261.54,15.44 262.99,15.44 263.48,14.95 266.36,14.95 270.78,10.53 277.13,10.53 278.17,9.49 300.7,9.49 301.32,10.11 311.07,10.11 311.12,10.16 314.78,10.16 320.16,15.54 332.06,15.54 333.3,14.3 341.86,14.3 342.21,13.96 344.02,13.96 345.18,15.12 345.98,15.12 346.71,15.85 349.84,15.85 350.03,15.66 356.45,15.66 356.6,15.81 364.99,15.81 365.34,16.17 371.19,16.17 375.84,11.52 375.84,11 376.92,9.92 395.53,9.92 399.81,14.2 v2(399.81,15.36)
  BOTTOM w0.109: RZ28.1 v2(399.81,15.36)
BAT1_LED#_R: length 369.5
  TOP w0.109: QZ22.1 v1(102.54,65.29) 104.56,65.29 106.85,63.01 106.85,60.68 105.65,59.48 105.65,53.08 103.59,51.02 100.35,51.02 97.79,48.46 97.79,36.74 98.15,36.38 99,36.38 99.36,36.03 99.36,35.41 100.27,34.5 101.6,34.5 102.21,33.89 102.21,31.8 103.07,30.94 103.07,30.37 102.21,29.51 v2(102.21,29.1)
  TOP w0.254: QZ3.2 v2(389.21,11.07)
  IN3 w0.081: v2(389.21,11.07) 388.52,10.38 377.7,10.38 377.26,10.81 377.26,11.88 375.56,13.58 374.89,13.58 371.85,16.63 365.15,16.63 364.8,16.27 356.41,16.27 356.26,16.12 350.22,16.12 350.03,16.31 346.52,16.31 345.79,15.58 344.99,15.58 343.83,14.42 342.4,14.42 342.05,14.76 333.48,14.76 332.25,15.99 319.97,15.99 314.84,10.86 311.07,10.86 310.79,10.57 301.1,10.57 300.48,9.95 278.41,9.95 277.37,10.99 270.97,10.99 266.55,15.41 263.67,15.41 263.18,15.9 261.73,15.9 261.05,16.58 256.71,16.58 256.22,17.06 254.23,17.06 253.5,16.33 248.16,16.33 247.41,17.08 245.85,17.08 245.68,16.92 244.48,16.92 243.78,16.22 240.33,16.22 240.27,16.15 233.85,16.15 233.31,15.61 233.29,15.61 229.37,11.69 215.81,11.69 214.81,10.69 174.17,10.69 v2(173.8,11.06)
  IN4 w0.102: v2(102.21,29.1) 102.21,25.96 105.36,22.81 106.77,22.81 108.42,21.17 108.42,17.56 108.96,17.02 109.91,17.02 110.82,16.11 112.37,16.11 112.77,16.51 115.65,16.51 118.49,13.68 126.26,13.68 v2(126.88,14.3)
  BOTTOM w0.109: v2(126.88,14.3) 127.5,14.3 131.38,10.43 137.85,10.43 138.91,11.49 140.15,11.49 140.83,10.81 152.54,10.81 153.44,11.71 155.25,11.71 155.51,11.44 162.52,11.44 163.22,10.74 171.4,10.74 171.72,11.06 v2(173.8,11.06)
BAT2_LED#: length 329.2
  TOP w0.109: v2(141.22,77.25) 140.84,76.87 UE1.D11
  IN2 w0.081: v2(165.63,53.3) 165.4,53.08 164.82,53.08 164.62,52.87 163.94,52.87 163.23,53.58 163.23,55.09 159.05,59.27 158.2,59.27 154.69,62.78 152.76,62.78 152.02,63.51 150.2,63.51 149.35,64.37 149.35,65.83 147.23,67.95 145.84,67.95 145.41,68.37 145.41,68.93 144.03,70.31 144.03,72.92 141.63,75.32 141.63,76.84 v2(141.22,77.25)
  IN3 w0.081: v2(165.63,53.3) 165.71,53.23 165.71,52.14 165.2,51.63 163.98,51.63 163.48,51.13 163.48,50.55 163.74,50.29 163.74,49.73 162.58,48.57 162.58,43.73 162.16,43.31 162.16,37.29 165.21,34.24 165.21,31.27 165.87,30.61 165.87,26.98 165.35,26.47 165.35,23 166.51,21.84 166.51,16.16 172.21,10.46 214.91,10.46 215.9,11.46 229.48,11.46 233.94,15.92 240.36,15.92 240.43,15.99 247.76,15.99 247.88,16.1 261.21,16.1 261.64,15.67 263.09,15.67 263.58,15.18 266.46,15.18 270.88,10.76 277.27,10.76 278.31,9.72 300.61,9.72 301.23,10.35 310.91,10.35 311.12,10.56 314.86,10.56 320.07,15.77 332.16,15.77 333.39,14.53 341.96,14.53 342.3,14.19 343.92,14.19 345.09,15.35 345.88,15.35 346.61,16.08 349.93,16.08 350.12,15.89 356.36,15.89 356.51,16.04 364.89,16.04 365.25,16.4 371.75,16.4 374.91,13.24 375.44,13.24 376.93,11.75 376.93,10.64 377.42,10.15 393.11,10.15 v2(395.3,12.33)
  BOTTOM w0.109: RZ361.1 394.54,13.1 v2(395.3,12.33) 395.3,11.24 v1(394.64,10.58)
BATDRV: length 3.7
  TOP w0.203: PU700.18 70.08,20.59 69.52,20.03 69.52,17.97 PR701.1
BATDRV_GATE: length 116
  TOP w0.109: v1(71.24,15.83) 70.84,15.42 v2(70.37,15.42)
  TOP w0.381: PD11.3 87.48,28.05 v2(86.97,27.54) ; v2(63.85,17.59) 63.85,19.23 63.21,19.87 63.21,22.53 62.52,23.22 60.96,23.22 60.18,23.99 58.95,23.99 58.58,23.62 55.79,23.62 v2(55.76,23.6) 55.66,23.7 53.15,23.7 53,23.85 PD12.3
  TOP w0.508: PQ701.4 v2(81.85,11.36) ; v2(70.37,15.42) PC725.1 69.7,16.09 PR701.2
  IN4 w0.381: v2(81.85,11.36) 84.91,11.36 88.14,8.13 95.97,8.13 96.11,7.99 99.62,7.99 100.16,8.54 100.16,11.24 97.13,14.28 93.74,14.28 91.73,16.28 89.91,16.28 89.44,15.81 88.71,15.81 88.19,16.33 88.19,17.19 87.73,17.64 85.84,17.64 83.21,20.27 83.21,25.14 85.61,27.54 v2(86.97,27.54) ; v2(55.76,23.6) 55.76,23.82 56.03,24.08 56.03,31.59 55.94,31.68 55.94,32.47 56.18,32.71 56.18,34.3 v2(56.46,34.58)
  IN4 w0.508: v2(70.37,15.42) 75.52,15.42 76.6,14.34 80.67,14.34 81.85,13.16 v2(81.85,11.36)
  BOTTOM w0.381: v2(56.46,34.58) 54.39,34.58 53.97,35 51.21,35 50.68,34.47 PD13.3 ; v2(63.85,17.59) 64.81,17.59 65.86,16.54 69.25,16.54 v2(70.37,15.42)
BATSRC: length 3.7
  TOP w0.203: PR735.1 69.14,18.05 v1(69.14,18.86) 69.14,20.14 69.68,20.69 PU700.17
BATT_WHITE#: length 16.3
  TOP w0.381: v2(396.57,9.96) 401.23,9.96 401.5,10.23 JLED1.3
  IN1 w0.254: v2(396.57,9.96) 395.96,10.57 392.62,10.57 v2(391.77,11.42)
  BOTTOM w0.109: v2(391.77,11.42) 391.77,10.21 v1(392.31,9.67)
  BOTTOM w0.254: v2(391.77,11.42) 393.69,11.42 RZ361.2
BATT_YELLOW#: length 14.6
  TOP w0.109: JLED1.2 401,15.26 v2(400.92,15.33) 400.37,15.89 397.77,15.89 395.36,13.48 394.85,13.48 394.66,13.29 393.2,13.29 392.29,12.37 QZ3.3
  BOTTOM w0.109: RZ28.2 400.72,15.13 v2(400.92,15.33)
BBS_BIT6: length 1.3
  TOP w0.109: UH1.BA26 126.31,36.37 v2(126.31,36.59)
  BOTTOM w0.109: v2(126.31,36.59) 126.31,36.37 126.16,36.22 RH311.2
BC_CLK_ECE1117: length 215.3
  TOP w0.109: UE1.D13 142.55,76.97 143.33,76.97 v2(143.48,76.81) ; JKBTP1.10 v2(17.84,4.84)
  IN3 w0.081: v2(143.48,76.81) 143.82,76.84 144,76.69 144.38,76.69 144.52,76.82 145.26,76.82 145.77,76.32 145.77,72.98 146.66,72.09 146.66,70.91 146.88,70.69 146.88,68.97 144.75,66.84 144.75,65.53 143,63.78 143,63.31 140.95,61.26 135.36,61.26 134.74,60.64 134.74,59.2 134.11,58.56 133.03,58.56 132.5,58.03 125.67,58.03 125.06,58.64 122.81,58.64 119.63,55.46 118.06,55.46 117.19,54.58 114.92,54.58 113.73,53.39 113.73,53.22 113.73,50.18 112.91,49.36 112.91,39.74 111.65,38.48 111.65,32.21 109.78,30.34 109.78,28.81 108.01,27.04 107.5,27.04 106.27,25.81 106.27,23.8 108.23,21.84 108.23,21.59 110.39,19.43 110.39,18.8 110.06,18.47 110.06,12.82 112.62,10.26 112.62,3.85 110.24,1.47 71.14,1.47 66.98,5.63 61.62,5.63 58.47,2.48 56.54,2.48 55.5,1.44 25.61,1.44 23.67,3.38 22.46,3.38 20.8,5.04 18.78,5.04 18.04,4.31 17.68,4.31 17.45,4.53 17.45,4.74 17.55,4.84 v2(17.84,4.84)
  BOTTOM w0.109: v1(145.74,77.42) 145.13,76.81 v2(143.48,76.81)
BC_DAT_ECE1117: length 216
  TOP w0.109: RE365.1 144.24,77.65 v2(143.94,77.35) 143.89,77.35 143.75,77.48 143.12,77.48 142.84,77.2 142.13,77.2 141.78,76.85 UE1.D12 ; JKBTP1.8 16.84,4.84 v2(16.84,4.84)
  IN3 w0.081: v2(143.94,77.35) 143.97,77.01 144.08,76.92 144.29,76.92 144.42,77.05 145.36,77.05 146,76.41 146,73.07 146.89,72.19 146.89,71.01 147.09,70.8 147.09,68.88 144.96,66.75 144.96,65.44 143.2,63.69 143.2,63.23 141.03,61.06 135.45,61.06 134.95,60.56 134.95,59.08 134.2,58.33 133.12,58.33 132.59,57.8 125.57,57.8 124.97,58.41 122.88,58.41 119.72,55.25 118.15,55.25 117.27,54.37 115.01,54.37 113.94,53.3 113.94,50.07 113.12,49.24 113.12,39.66 111.86,38.39 111.86,32.12 109.99,30.25 109.99,28.72 108.2,26.93 108.08,26.81 107.59,26.81 106.5,25.72 106.5,23.89 108.46,21.93 108.46,21.68 110.61,19.53 110.61,18.7 110.28,18.37 110.28,12.92 112.85,10.35 112.85,3.76 110.33,1.24 71.04,1.24 66.88,5.4 61.71,5.4 58.56,2.25 56.63,2.25 55.62,1.23 25.52,1.23 23.58,3.17 22.35,3.17 20.71,4.82 18.87,4.82 18.13,4.08 17.58,4.08 17.22,4.44 17.22,4.74 17.12,4.84 v2(16.84,4.84)
BC_INT#_ECE1117: length 188.8
  TOP w0.109: JKBTP1.7 16.34,4.13 v2(16.15,4.32) ; UE1.E2 v2(133.27,76.42)
  IN3 w0.081: v2(133.27,76.42) 132.02,76.42 131.47,76.98 130.73,76.98 130.27,76.52 127.01,76.52 126.31,75.82 123.81,75.82 123.11,75.12 122.1,75.12 119.1,72.13 119.1,71.45 117.57,69.92 116.4,69.92 115.85,69.36 115.85,69.11 113.72,66.99 113.61,66.99 113.34,66.71 112.24,66.71 110.89,65.37 110.89,61.31 110.88,61.29 110.88,61.29 110.65,61.06 110.57,60.98 106.89,60.98 103.55,57.64 100.77,57.64 96.73,53.6 96.73,45.18 95.5,43.95 95.5,35.91 v2(96.21,35.19) ; v2(16.15,4.32) 16.42,4.59 16.42,5.16 16.71,5.45 23.47,5.45 26.69,8.68 31.15,8.68 31.68,8.14 35.38,8.14 38.05,10.81 43.03,10.81 43.94,11.72 47.14,11.72 47.27,11.6 51.46,11.6 52.32,10.73 v2(54.11,10.73)
  IN4 w0.102: v2(96.21,35.19) 95.66,35.75 95.66,39.05 93.98,40.73 90.68,40.73 89.11,39.16 75.58,39.16 75.15,38.72 65.2,38.72 62.68,36.21 59.38,36.21 58.39,35.22 55.73,35.22 55.05,34.55 55.05,30.81 55.66,30.2 55.66,24.23 55.36,23.93 55.36,23.32 55.8,22.87 55.8,18.91 57.5,17.21 57.5,16.57 57.99,16.07 57.99,15.39 57.29,14.68 56.12,14.68 55.8,14.37 55.8,13.35 54.11,11.66 v2(54.11,10.73)
  BOTTOM w0.109: v4(96.44,35.73) 96.21,35.51 v2(96.21,35.19)
BCM5882_ALERT#: length 284.5
  TOP w0.109: UE1.G10 140.41,74.82 143.44,74.82 v2(143.66,74.6) 143.99,74.93 144.36,74.93 RE532.2 ; v2(332.47,53.72) 333.26,52.92 334.92,52.92 335.05,53.05 JUSH1.14
  IN2 w0.081: v2(150.47,64.15) 150.09,64.53 150.09,66.63 148.31,68.4 146.24,68.4 145.87,68.77 145.87,69.13 144.6,70.4 144.6,74.28 144.28,74.6 v2(143.66,74.6)
  VCC w0.086: v2(332.47,53.72) 332.78,53.4 332.78,51.65 326.51,45.37 326.51,44.42 322.1,40.01 322.1,39.06 321.23,38.19 320.73,38.19 319.16,36.62 315.67,36.62 315.24,36.19 313.39,36.19 300.09,22.89 300.09,17.84 298.26,16.01 296.63,16.01 293.42,12.8 293.42,11.91 292.19,10.69 268.12,10.69 265.41,13.4 249.88,13.4 249.34,13.94 245.45,13.94 244.96,14.43 242.63,14.43 241.78,15.28 240.05,15.28 239.84,15.5 237.51,15.5 232.13,10.12 221.61,10.12 220.96,9.48 217.83,9.48 217.15,10.16 165.13,10.16 156.95,18.34 156.95,20.45 159.99,23.48 159.99,33.64 159.33,34.3 159.33,41.38 149.65,51.06 148.74,51.06 148.31,51.49 148.31,56.32 148.61,56.62 148.61,59.1 150.47,60.95 v2(150.47,64.15)
BEEP: length 318.3
  TOP w0.109: RA13.2 389.51,25.39 v2(389.51,25.19) ; UE1.H11 v2(141.21,73.28)
  IN2 w0.081: v2(141.21,73.28) 141.03,73.28 140.64,72.89 140.26,72.89 140.03,72.66 140.03,70.7 140.23,70.5 140.61,70.5 140.82,70.3 140.82,69.56 141.55,68.82 141.55,67.9 142.1,67.35 144.33,67.35 145.84,65.84 145.84,65.43 146.5,64.77 147.98,64.77 149.92,62.83 151.74,62.83 152.76,61.81 153,61.81 154.92,59.9 156.05,59.9 157.36,58.59 158.73,58.59 162.54,54.78 162.54,53.18 163.76,51.96 165.43,51.96 165.73,51.66 165.73,50.76 v2(165.76,50.73)
  IN3 w0.081: v2(389.51,25.19) 389.44,25.26 384.77,25.26 383.12,23.61 379.27,23.61 376.11,20.46 373.59,20.46 369.99,16.86 365.01,16.86 364.73,16.58 356.4,16.58 356.17,16.35 350.31,16.35 350.12,16.54 346.42,16.54 345.69,15.81 344.9,15.81 344.43,15.34 342.4,15.34 342.28,15.22 333.67,15.22 332.43,16.46 319.8,16.46 314.9,11.57 310.86,11.57 310.32,11.03 300.91,11.03 300.29,10.4 278.63,10.4 277.59,11.45 271.16,11.45 266.74,15.86 263.86,15.86 263.37,16.36 261.92,16.36 260.53,17.75 256.37,17.75 256.25,17.63 248.08,17.63 247.48,18.23 243.88,18.23 243.13,17.49 240.73,17.49 240.33,17.09 239.85,16.61 233.65,16.61 229.23,12.19 215.53,12.19 214.49,11.15 175.09,11.15 173.72,12.53 171.16,12.53 167.2,16.49 167.2,22.12 166.03,23.28 166.03,26.18 166.9,27.05 166.9,35.1 163.29,38.7 163.29,46.71 165.01,48.43 165.01,48.87 165.76,49.62 v2(165.76,50.73)
  BOTTOM w0.109: v2(389.51,25.19) 389.51,24.91 v1(389.28,24.68)
BEEP_R: length 4.4
  TOP w0.254: RA13.1 389.25,26.3 v2(388.6,26.3) 388.09,25.8 CA28.1
  BOTTOM w0.109: v2(388.6,26.3) 388.6,26.6 v1(388.38,26.82)
  BOTTOM w0.254: v2(388.6,26.3) 389.23,26.3 CA227.1 389.53,26.15 RA209.1
BGPO0: length 8.5
  TOP w0.109: UE1.D6 v2(136.47,77.22)
  BOTTOM w0.109: RE749.1 139.55,81.36 v1(139.1,80.91) 138.83,80.91 136.86,78.94 136.86,78.65 137.07,78.44 137.49,78.44 137.74,78.18 137.74,77.87 137.49,77.61 136.85,77.61 v2(136.47,77.22)
BIA_PWM: length 62.7
  TOP w0.109: DV39.1 167.76,126.02 v2(167.36,126.43) 166.62,127.17 v1(166.23,127.17) 165.73,127.17 165.26,127.64 165.26,129.31 164.94,129.63 RV839.1 163.5,129.63 DV38.1 DV40.1 ; v2(124.04,117.8) 125.09,116.76 LV1.2
  IN2 w0.081: v2(167.36,126.43) 166.79,126.43 164.68,124.32 156.19,124.32 154.76,122.89 153.72,122.89 153.25,122.41 151.23,122.41 146.06,127.59 136.06,127.59 126.91,118.43 124.68,118.43 v2(124.04,117.8)
BIA_PWM_EC: length 115.1
  TOP w0.109: DV40.2 160.95,131.24 v2(160.47,131.71) ; v2(132.32,69.4) 132.57,69.65 UE1.N1
  IN1 w0.102: v2(132.32,69.4) 132.8,69.88 132.8,70.28 132.87,70.35 132.87,70.65 131.98,71.54 131.98,72.44 130.85,73.57 130.85,75.9 130.58,76.17 130.58,83.82 132.01,85.25 132.01,94.87 130.48,96.4 130.48,97.65 124.46,103.67 124.46,107.58 123.26,108.78 123.26,115.25 125.11,117.1 125.11,119.04 124.76,119.38 124.76,136.77 v2(124.91,136.92)
  IN2 w0.081: v2(160.47,131.71) 159.2,131.71 156.66,134.25 150.19,134.25 150.16,134.28 148.71,134.28 148.44,134 138.58,134 135.87,136.7 129.1,136.7 127.63,138.17 126.45,138.17 125.21,136.92 v2(124.91,136.92)
  BOTTOM w0.109: v2(160.47,131.71) v1(160.47,131.16)
BIA_PWM_PCH: length 184.3
  TOP w0.109: UH1.AU48 127.94,25.55 128.22,25.83 128.22,26.11 128.5,26.39 v2(128.5,26.48) ; DV38.2 160.95,129.27 161.62,129.94 v2(161.62,131.71)
  IN1 w0.102: v2(122.86,141.47) 119.01,141.47 117.08,139.54 117.08,119.05 116.28,118.25 116.28,116.68 114.18,114.59 114.18,107.2 113.58,106.59 112.51,106.59 111.85,105.93 111.85,100.44 114.12,98.17 114.12,96.92 114.86,96.18 116.01,96.18 117.03,95.17 117.03,85.41 118.46,83.97 118.46,82.09 118.11,81.73 118.11,79.18 117.31,78.38 117.31,75.58 117.57,75.31 117.57,73.71 118.01,73.27 118.01,72.9 118.57,72.33 118.57,71.26 118.95,70.88 118.95,69.26 118.07,68.37 118.07,66.68 117.71,66.32 117.71,63.7 118.59,62.83 118.59,60.46 119.38,59.67 119.38,58.01 119.81,57.58 119.81,57.58 120.22,57.18 120.22,55.21 120.6,54.83 120.6,52.28 121.05,51.84 121.05,47.59 120.7,47.24 120.7,38.75 121.99,37.46 121.99,36.55 121.1,35.67 121.1,34.47 121.7,33.87 121.7,30.75 122.59,29.86 127.27,29.86 127.71,29.42 127.71,27.98 127.45,27.72 127.45,27.19 127.66,26.99 127.99,26.99 v2(128.5,26.48)
  IN2 w0.081: v2(161.62,131.71) 161.11,132.22 159.2,132.22 156.92,134.51 148.56,134.51 148.33,134.28 138.59,134.28 135.96,136.91 129.55,136.91 126.72,139.74 123.67,139.74 122.86,140.54 v2(122.86,141.47)
  BOTTOM w0.109: v2(161.62,131.71) v1(162.16,131.71)
BIOS_REC: length 8.9
  TOP w0.109: UH1.AR42 128.45,28.51 v2(128.27,28.51)
  BOTTOM w0.109: RH76.2 128.85,23.38 128.3,23.93 127.99,23.93 127.88,23.82 127.36,23.82 127.06,24.12 127.06,25.4 127.17,25.51 127.17,27.56 127.32,27.71 127.32,28.21 127.63,28.51 v2(128.27,28.51)
BL_PWR_SRC_ON: length 12.6
  TOP w0.109: v2(140.85,133.43) v1(140.42,133)
  TOP w0.254: CV14.1 RV5.1 143.22,137.92 v2(143.27,137.87) 143.6,137.54 RV4.2 143.6,136.55 144.35,135.8 QV1.3 ; CV13.2 141.17,133.75 v2(140.85,133.43)
  IN1 w0.254: v2(140.85,133.43) 140.85,135.46 v2(143.27,137.87)
BOARD_ID: length 15.2
  TOP w0.109: UE1.J13 142.44,72.87 v2(142.81,73.24)
  IN2 w0.081: v2(142.81,73.24) 142.81,72.17 142.42,71.77 142.42,69.03 142.67,68.77 143.18,68.77 143.78,68.17 144.26,68.17 146.14,66.29 146.34,66.29 146.7,65.92 147.08,65.92 147.37,65.63 v2(148.37,65.63)
  BOTTOM w0.109: RE79.2 148.84,64 CE40.1 149.25,65.04 v1(148.92,65.37) 148.65,65.63 v2(148.37,65.63)
BQ24780_REGN: length 11.3
  TOP w0.508: PR712.1 71.12,28.95 71.12,29.53 v2(71.12,29.53)
  IN4 w0.508: v2(74.78,21.66) 74.19,22.24 73,22.24 71.91,23.33 71.91,24.84 71.12,25.63 v2(71.12,29.53)
  BOTTOM w0.109: v2(71.12,29.53) v1(71.12,30.06)
BREATH_LED#: length 331.2
  TOP w0.109: v2(395.25,9.28) 395.25,9.77 394.85,10.17 394.09,10.17 393.76,10.51 QZ7.3 ; UE1.C11 v2(141.21,78.02)
  IN2 w0.081: v2(141.21,78.02) 141.21,77.83 142.42,76.62 142.42,74.86 144.22,73.06 144.22,70.5 145.64,69.08 145.64,68.67 146.14,68.18 148.22,68.18 149.84,66.55 149.84,64.2 150.3,63.74 152.12,63.74 152.85,63.01 154.79,63.01 158.29,59.5 159.15,59.5 163.46,55.2 163.46,54.21 v2(164.36,53.3)
  IN3 w0.081: v2(164.36,53.3) 162.51,53.3 161.19,51.99 161.19,43.86 160.55,43.21 160.55,37.6 164.53,33.62 164.53,30.98 165.18,30.33 165.18,27.27 164.66,26.75 164.66,22.72 165.6,21.78 165.6,15.87 171.69,9.78 230.07,9.78 235.53,15.24 240.65,15.24 240.71,15.3 248.23,15.3 248.34,15.42 256.09,15.42 257.93,13.58 267.09,13.58 270.59,10.07 276.94,10.07 277.98,9.03 300.89,9.03 301.49,9.63 314.92,9.63 320.37,15.08 331.87,15.08 333.11,13.85 341.6,13.85 341.95,13.5 344.21,13.5 345.37,14.67 346.17,14.67 346.9,15.39 349.65,15.39 349.84,15.2 355.95,15.2 357.43,13.73 360.88,13.73 361.31,13.3 363.12,13.3 364.31,14.49 372.1,14.49 375.39,11.21 375.39,10.81 376.78,9.41 386.61,9.41 388.08,7.94 389.63,7.94 391.34,9.64 394.89,9.64 v2(395.25,9.28)
  BOTTOM w0.109: v2(395.25,9.28) 395.25,9.33 v1(395.7,9.78)
BREATH_LED#_Q: length 2.3
  TOP w0.109: QZ7.1 394.41,8.19 RZ32.1 394.46,7.75 394.49,7.68 394.51,7.57 v1(394.93,7.15)
BREATH_LED#_R: length 67.3
  TOP w0.109: RZ32.2 396.12,8.89 396.12,10.19 396.47,10.53 v2(396.47,11.55) 396.47,11.7 v4(396,12.17) ; JPB1.4 371.4,46.7 371.36,46.74 371.36,47.21 v2(371.77,47.62)
  IN1 w0.102: v2(396.47,11.55) 396.47,12.46 395.42,13.5 392.8,13.5 391.74,12.44 381.94,12.44 380.53,13.85 380.53,17.59 381.43,18.5 381.43,19.25 380.7,19.98 378.68,19.98 377.85,20.81 377.85,23.71 376.78,24.78 376.78,26.99 376.3,27.47 376.07,27.47 375.76,27.79 375.76,28.79 377.41,30.44 377.41,36.5 376.15,37.77 376.15,46.05 374.58,47.62 v2(371.77,47.62)
BST_1.2V: length 2.4
  TOP w0.203: PR200.2 116.32,13.27 115.64,13.27 115.57,13.2 PU200.18
BST_1.2V_R: length 2.4
  TOP w0.109: v1(119.33,11.17) 119.05,11.45 PC201.2
  TOP w0.508: PC201.2 PR200.1
BST_3V: length 3.1
  TOP w0.109: v1(141.4,112.21) 140.9,112.7 139.35,112.7 138.95,112.3 138.95,112.05
BST_3VR: length 1.5
  TOP w0.109: v1(322.07,10.05) 322.77,9.35 PR514.1
BST_5V: length 2.8
  BOTTOM w0.109: v1(49.49,11.39) 49.53,11.36 51.1,11.36 51.83,10.63 PR111.1
BST_5VR: length 1.3
  TOP w0.109: PR501.1 v1(354.33,45.24)
BST_+1VSP: length 3.9
  TOP w0.109: PR802.1 104.86,33.13 104.21,32.49 v1(104.21,32.02)
  TOP w0.254: PU800.10 106.17,31.47 104.98,32.65 PR802.1
BST_IO: length 3.3
  TOP w0.109: PR302.1 308.3,55.49 308.8,54.99 308.8,53.43 v1(308.26,52.9)
BST_IO_R: length 1.3
  TOP w0.109: PC305.1 v1(306.93,52.89)
BT_RADIO_DIS#: length 67.9
  TOP w0.109: UE1.C2 v2(133.27,78.02) ; RE11.1 130.62,81.16 131.34,80.43 132.28,80.43 v2(132.66,80.05)
  IN1 w0.102: v2(133.27,78.02) 132.61,78.68 132.61,80 v2(132.66,80.05) 132.66,80.15 134.01,81.5 134.01,88.03 137.82,91.84 137.82,93.47 143.49,99.14 143.49,104.71 142.34,105.86 142.34,110.93 141.85,111.41 141.85,114.17 141.11,114.91 135.27,114.91 135.01,115.17 v2(135.01,117.11)
  BOTTOM w0.109: v2(135.01,117.11) 134.82,116.92 131.09,116.92 129.85,118.15 127.73,118.15 v1(127.45,118.43) 127.16,118.73 123.81,118.73 123.42,118.34 123.42,117.68 123.64,117.46 DZ2.1
BT_RADIO_DIS#_R: length 3.3
  BOTTOM w0.109: DZ2.2 123.64,114.86 123.44,114.66 v1(123.44,114.34) 123.44,113.81 124,113.25 JNGFF1.46
C10_PWR_GATE#: length 9.2
  TOP w0.109: RC562.2 278.84,73.17 278.41,72.74 276.94,72.74 276.78,72.9 276.78,74.13 276.5,74.41 UZ61.4 274.48,74.41 RZ542.1 274.48,75.43 274.72,75.68 UZ35.1 276.23,75.68 v1(276.49,75.94)
CAM_MIC_CBL_DET#: length 91.9
  TOP w0.109: v2(120.81,119.97) 121.07,119.97 121.2,119.84 JEDP1.17 121.2,118.35 122.22,117.33 122.22,116.75 RH319.2 ; UH1.AW13 126.59,42.61 v2(126.59,42.29)
  IN1 w0.102: v2(126.59,42.29) 126.59,44.88 125.91,45.55 125.91,47.62 124.86,48.67 124.86,53.88 124.54,54.2 124.54,55.09 123.37,56.27 123.37,61.5 122.81,62.06 122.81,68.44 122.27,68.97 122.27,71.31 120.53,73.06 120.53,75.91 119.75,76.69 119.75,79.42 119.78,79.45 119.78,80.19 119.38,80.6 119.38,84.35 117.94,85.79 117.94,97.2 116.65,98.49 115.67,98.49 113.8,100.35 113.8,102.19 114.6,102.99 114.6,104.97 117.4,107.77 117.4,110.94 118.95,112.49 118.95,117.78 120.81,119.64 v2(120.81,119.97)
  BOTTOM w0.109: v2(120.81,119.97) v1(121.41,119.97)
CCG5_AR_RST#: length 45.2
  IN3 w0.081: v2(29.36,56.07) 29.65,55.78 29.65,52.6 29.11,52.05 27.95,52.05 27.11,51.22 27.11,42.86 26.36,42.12 25.98,42.12 v2(25.89,42.2) ; v2(18.53,31.7) 19.43,30.8 21.5,30.8 22.18,31.48 22.18,37.4 20.98,38.59 20.98,41.88 20.5,42.37 20.5,42.85 v2(20.83,43.18)
  BOTTOM w0.109: v2(20.83,43.18) JCCG1.4 20.83,45.29 20.91,45.38 23.21,45.38 25.86,42.73 25.86,42.24 v2(25.89,42.2) ; v2(18.53,31.7) 18.49,31.66 18.49,31.63 UT5.B2 ; v2(29.36,56.07) 29.35,56.09 29.35,56.85 v1(29.5,57) 29.74,57.24 RT37.2
CCG5_I2C_INT1#: length 213.8
  TOP w0.109: v2(19.12,40.88) 19.12,41.71 v1(19.54,42.13) ; RE91.1 144.46,76.86 143.94,76.34 143.94,76.08 v2(143.94,76.08) ; UE1.F10 v2(140.41,75.62)
  IN1 w0.102: v2(19.12,40.88) 18.97,40.88 18.62,40.53 17.22,40.53 16.16,39.47 12.48,39.47 10.39,37.38 10.39,30.16 15.67,24.88 15.67,24.61 16.55,23.73 18.17,23.73 18.87,24.43 21.16,24.43 22.06,23.54 23.64,23.54 24.46,22.72 26.72,22.72 26.92,22.52 29.11,22.52 29.67,23.09 31.26,23.09 31.47,22.87 31.47,22.44 31.87,22.04 32.69,22.04 33.65,21.07 35.71,21.07 36.19,20.59 36.19,20.39 36.5,20.08 36.97,20.08 38.62,21.73 40.07,21.73 40.74,22.41 42.13,22.41 43.84,24.12 45.06,24.12 45.19,24.25 46.12,24.25 46.68,23.69 49.77,23.69 50.02,23.43 50.75,23.43 52.07,22.11 55.06,22.11 57.99,25.04 57.99,26.01 58.47,26.49 62.47,26.49 62.95,26.98 64.51,26.98 65.1,26.38 67.89,26.38 68.83,27.32 77.55,27.32 79.75,29.52 85.71,29.52 87.67,31.49 87.77,31.49 89.77,33.49 89.77,34.14 91.92,36.29 95.7,36.29 96.63,35.35 96.63,33.45 97,33.09 98.57,33.09 99.21,33.72 100.04,33.72 100.57,33.19 v2(100.93,33.19)
  IN3 w0.081: v2(140.41,75.62) 140.41,75.43 139.43,74.45 138.33,74.45 138.06,74.17 138.06,69.46 138,69.4 138,67.91 137.89,67.81 137.89,67.79 137.41,67.31 136.44,67.31 135.73,66.6 133.69,66.6 133.37,66.29 133.37,65.08 133.07,64.77 129.01,64.77 128.56,65.23 126.85,65.23 126.47,65.61 122.95,65.61 122.72,65.38 121.53,65.38 119.05,62.9 118.8,62.9 115.21,59.3 115.21,58.45 107.94,51.18 101.01,51.18 100.28,50.45 100.28,44.71 99.23,43.66 99.23,41.6 100.47,40.36 100.47,33.65 v2(100.93,33.19)
  IN4 w0.102: v2(143.94,76.08) 143.43,76.08 143.32,75.96 141.53,75.96 141.46,76.03 140.82,76.03 v2(140.41,75.62)
  BOTTOM w0.109: v2(19.12,40.88) 19.78,40.22 19.78,38.11 19.47,37.8 19.47,37.04 19.43,37 19.43,36.1 19.54,36 UT5.L5
CCG5_ILIM1#: length 7.2
  BOTTOM w0.109: QT9.2 25.18,25.83 v1(24.5,25.83) 24.41,25.83 23.89,25.31 21.93,25.31 21.66,25.58 21.66,26.14 21.8,26.28 21.88,26.28 RT584.2 21.5,26.99 RT589.2
CCG5_ILIM2#: length 8.9
  BOTTOM w0.109: QT8.2 28.33,26.44 28.33,27.28 27.93,27.69 27.16,27.69 v1(27.04,27.57) 26.49,27.02 25.51,27.02 24.73,26.23 22.84,26.23 RT583.2 22.62,26.46 22.62,27.24 22.65,27.28 RT590.2
CCG5_SMBCLK: length 199.3
  TOP w0.109: RE303.1 127.08,82.01 126.85,82.23 v2(126.17,82.23) 126.16,82.23 125.24,81.31 123.07,81.31 122.45,80.7 120.36,80.7 120.15,80.48 120.15,79.78 119.28,78.91 116.36,78.91 115.79,79.48 113.97,79.48 113.4,78.91 108.99,78.91 108.28,78.2 v2(107.57,78.2) ; v2(50.11,38.34) 49.48,38.98 45.62,38.98 45.37,39.22 37.15,39.22 v1(36.7,39.66) 36.68,39.69 35,39.69 34.52,40.17 34.52,40.78 34.07,41.22 v2(30.92,41.22) ; UE1.C3 v2(134.07,78.02)
  IN1 w0.102: v2(107.57,78.2) 107.57,77.48 107.06,76.98 107.06,70.25 106.57,69.76 104.16,69.76 99.1,64.7 99.1,58.47 90.18,49.55 90.18,41.79 89.81,41.42 88.11,41.42 87.42,42.11 77.41,42.11 74.38,39.08 59.41,39.08 57.34,37.01 51.45,37.01 v2(50.11,38.34) ; v2(19.86,45.79) 19.94,45.71 21.21,45.71 26.26,40.65 27.54,40.65 27.93,40.27 29.97,40.27 v2(30.92,41.22) ; v2(21.92,27.21) 20.58,28.54 20.58,30.44 19.89,31.14 19.89,36.51 20.01,36.64 20.38,36.64 v2(20.57,36.82) 20.57,37.67 21.69,38.8 25.03,38.8 27.19,36.64 27.28,36.64 27.54,36.38 27.54,35.97 27.26,35.7 26.85,35.7 v2(26.78,35.63)
  IN3 w0.081: v2(19.86,45.79) 19.14,45.07 19.14,43.34 18.17,42.37 18.17,38.97 17.4,38.19 17.4,36.96 18.15,36.21 19.95,36.21 v2(20.57,36.82)
  IN4 w0.102: v2(134.07,78.02) 134.07,78.15 133.78,78.43 131.99,78.43 129.74,80.69 128.52,80.69 128.25,80.42 128.25,80.17 127.77,79.69 127.15,79.69 126.82,80.02 126.82,81.88 126.46,82.23 v2(126.17,82.23)
  BOTTOM w0.109: RT580.2 22.08,27.37 v2(21.92,27.21) ; RT582.1 24.87,34.75 25.56,35.44 26.58,35.44 v2(26.78,35.63) ; UT5.L6 20.04,36.62 20.23,36.82 v2(20.57,36.82) ; v2(19.86,45.79) 19.86,45.35 19.83,45.32 JCCG1.6
CCG5_SMBDAT: length 179
  TOP w0.109: UE1.B4 v2(134.84,78.85) ; RE302.1 126.58,77.82 v2(126.46,77.94)
  IN1 w0.102: v2(26.99,36.22) 26.99,36.27 24.86,38.39 21.86,38.39 21.06,37.6 21.06,36.24 20.29,35.47 20.29,34.75 v2(20.34,34.7) 20.34,34.3 20.76,33.89 21.98,33.89 22.27,33.59 22.27,28.55 23.19,27.64 v2(23.19,27.19)
  IN2 w0.081: v2(126.46,77.94) 126.46,76.72 124.33,74.59 124.33,69.1 123.72,68.49 119.94,68.49 119.8,68.63 117.84,68.63 115.04,65.83 113.52,65.83 112.65,66.69 111.2,66.69 110.12,65.61 110.12,64.85 108,62.73 106.61,62.73 105.06,61.19 105.06,60.58 105.06,60.19 103.54,58.66 v2(102.17,58.66)
  IN4 w0.102: v2(22.11,42.47) 22.48,42.84 26.08,42.84 v2(26.3,42.63) 26.66,42.63 26.79,42.76 29.21,42.76 30.34,41.63 31.14,41.63 31.38,41.39 32.01,41.39 33.06,42.43 41.09,42.43 42.49,43.83 42.49,44.64 42.82,44.97 44.65,44.97 49.86,50.18 51.48,50.18 51.94,50.64 53.23,50.64 53.52,50.92 59.93,50.92 61.05,52.03 64.32,52.03 64.94,52.65 65.99,52.65 66.61,52.03 71.27,52.03 71.5,51.81 80.47,51.81 81.03,52.36 81.53,52.36 83.49,54.32 90.96,54.32 95.3,58.66 v2(102.17,58.66)
  BOTTOM w0.076: UT5.K6 20.29,35.43 20.29,35.94
  BOTTOM w0.109: v2(23.19,27.19) 23.19,27.73 RT579.2 ; v2(26.3,42.63) 26.3,42.64 23.32,45.62 20.82,45.62 20.33,45.13 JCCG1.5 ; v2(126.46,77.94) 127.49,76.9 129.52,76.9 130.25,77.64 130.25,78.36 130.93,79.03 132.23,79.03 132.85,78.41 134.41,78.41 134.48,78.49 v2(134.84,78.85) ; v2(22.11,42.47) 21.19,41.55 21.19,37.89 21.08,37.78 21.08,36.73 20.29,35.94 ; RT581.1 25.2,35.33 25.48,35.62 26.26,35.62 26.86,36.22 v2(26.99,36.22) ; UT5.K6 20.04,35.01 v2(20.34,34.7)
CCG5_SWD_CLK1: length 30.8
  IN3 w0.081: v2(14.56,29.73) 16.82,29.73 17.59,30.51 21.63,30.51 22.48,31.36 22.48,37.52 21.28,38.71 21.28,42.14 v2(20.91,42.51)
  BOTTOM w0.076: UT5.C2 17.79,31.43 17.79,31.07 17.64,30.92 17.42,30.92 17.22,30.72
  BOTTOM w0.109: JCCG1.3 21.33,42.92 v2(20.91,42.51) ; 17.22,30.72 16.74,30.24 v1(15.93,30.24) 15.42,29.73 v2(14.56,29.73) 13.92,29.73 13.38,30.27 12.24,30.27 RT526.1 RT527.1
CCG5_VBUS_5V_ON1#: length 48.5
  IN4 w0.102: v2(34.08,29.2) 34.44,29.2 34.74,29.5 34.74,30.93 35.1,31.28 35.1,32.63 34.56,33.17 34.56,38.84 36.03,40.3 36.03,41.12 35.56,41.59 33.41,41.59 31.34,39.52 27.96,39.52 26.71,40.77 26.1,40.77 24.71,42.15 23.23,42.15 22.55,41.48 17.52,41.48 v2(16.38,40.34)
  BOTTOM w0.076: UT5.K3 18.79,35.43 18.79,36.29 18.78,36.31
  BOTTOM w0.109: UT10.2 34.59,25.38 33.96,26.01 PR2150.1 33.96,26.75 34.29,27.08 34.29,29 v2(34.08,29.2) ; 18.78,36.31 18.78,36.75 18.77,36.76 18.77,37.58 18.5,37.85 17.19,37.85 16.96,38.08 RT517.2 16.67,38.08 16.06,38.69 v1(16.06,39.5) 16.06,40.02 v2(16.38,40.34)
CCG5_VBUS_5V_ON2#: length 38.3
  IN1 w0.102: v2(16.2,26.97) 15.88,26.65 15.88,25.64 16.13,25.39 17.45,25.39 17.73,25.12 21.47,25.12 22.37,24.22 24.06,24.22 24.87,23.41 25.76,23.41 26.25,23.9 33.54,23.9 34.12,24.48 35.27,24.48 v2(36.1,23.65)
  BOTTOM w0.076: UT5.B4 18.79,30.93 18.4,30.93 18.29,30.82 18.29,30.48
  BOTTOM w0.109: v2(36.1,23.65) 36.11,23.65 36.53,24.07 37.69,24.07 38.01,24.38 38.01,24.61 39.03,25.64 PR2106.1 39.78,25.58 40.83,25.58 41.37,25.03 UT12.2 ; 18.29,30.48 18.29,29.91 17.73,29.35 16.72,29.35 16.46,29.1 16.46,27.92 RT519.2 16.2,27.66 v2(16.2,26.97) 16.43,26.97 16.91,27.46 v1(17.12,27.46)
CCG5_VBUS_DISCHARGE_P1: length 27.3
  IN4 w0.102: v2(29.16,30.01) 29.35,30.2 29.35,30.79 33.32,34.76 33.32,38.03 33.17,38.18 29.05,38.18 27.68,36.82 27.68,35.28 26.87,34.47 26.29,34.47 26.02,34.2 24.62,34.2 23.57,35.26 v2(23.21,35.26)
  BOTTOM w0.076: v2(23.21,35.26) 23.12,35.26 22.8,34.93 22.3,34.93 UT5.J10
  BOTTOM w0.109: RT567.1 23.33,35.33 23.28,35.33 v2(23.21,35.26) ; v1(28.56,29.56) 29.02,30.01 v2(29.16,30.01) 29.7,30.56 QT6.2
CCG5_VBUS_DISCHARGE_P2: length 32.2
  IN4 w0.102: v2(33.68,29.89) 33.5,29.71 32.12,29.71 32.04,29.78 32.04,33.12 33.56,34.63 33.56,39.05 33.35,39.26 32.55,39.26 31.79,38.5 29.03,38.5 27.46,36.93 27.46,35.38 26.81,34.74 25.39,34.74 v2(25.26,34.61)
  BOTTOM w0.076: UT5.H10 22.29,33.92 22.7,33.92
  BOTTOM w0.109: v2(33.68,29.89) 33.5,29.89 QT7.2 32.98,31.78 34.74,31.78 v1(35.01,31.51) ; RT568.1 25.78,35.12 v2(25.26,34.61) 25.05,34.4 23.17,34.4 22.7,33.92
CCG5_XRES1: length 12
  BOTTOM w0.076: UT5.H6 19.78,34.43 19.78,36.03 19.63,36.18
  BOTTOM w0.109: 19.63,36.18 19.63,36.54 v1(20.61,37.52) 20.81,37.73 CT350.2 20.81,38.89 RT525.2 20.42,39.31 20.92,39.81 20.92,41.93 21.83,42.84 JCCG1.2
CFG0: length 38.9
  TOP w0.109: v2(249.21,29.6) 249.15,29.6 UC1.BN25
  BOTTOM w0.109: v2(249.21,29.6) 249.78,29.6 v1(249.94,29.44) 250.21,29.17 250.98,29.17 251.18,29.38 251.76,29.38 251.97,29.17 251.97,28.28 253.2,27.06 255.39,27.06 255.65,26.8 255.65,26.48 256.04,26.08 256.04,24.2 256.63,23.61 256.63,22.21 257.52,21.32 257.52,19.43 262.12,14.83 262.12,14.09 262.81,13.4 RC126.1 262.81,12.26 261.27,10.72 258.58,10.72 256.07,13.23 254.67,13.23 RC321.1 254.38,14.56 253.88,15.06 JXDP1.9
CFG1: length 40
  TOP w0.109: v2(250.79,29.6) 250.72,29.6 UC1.BN27
  BOTTOM w0.109: JXDP1.11 253.28,15.12 252.71,14.54 RC436.1 253.08,13 255.96,13 258.47,10.48 261.4,10.48 263.25,12.33 263.25,13.3 262.35,14.19 262.35,14.93 257.76,19.52 257.76,21.42 256.94,22.23 256.94,25.52 255.88,26.58 255.88,27.08 255.59,27.37 253.44,27.37 252.21,28.6 252.21,29.29 251.74,29.76 v1(251.41,29.76) 250.95,29.76 v2(250.79,29.6)
CFG2: length 21.7
  TOP w0.109: v2(252.44,16.91) 251.72,17.63 249.32,17.63 247.45,19.5 247.45,22.88 v1(247.83,23.26) 248.39,23.82 248.39,24.61 248.08,24.92 248.08,25.85 248.39,26.15 248.39,27.4 248.61,27.62 248.98,27.62 249.21,27.86 249.21,28.95 249.54,29.28 UC1.BN26
  BOTTOM w0.109: v2(252.44,16.91) 252.08,16.55 JXDP1.15 252.08,15.08 251.95,14.95 251.51,14.95 250.93,14.37 RC181.1
CFG3: length 33.8
  TOP w0.109: v2(251.56,28.95) 251.51,28.95 UC1.BN28 ; v2(251.79,16.88) 251.79,16.42 252.04,16.16 254.2,16.16 254.31,16.05 254.8,16.05 257.76,13.1 260.3,13.1 260.42,13.22 260.42,13.97 v2(260.49,14.04)
  BOTTOM w0.109: v2(251.56,28.95) 251.56,28.03 253.07,26.52 253.12,26.52 254.72,24.93 254.72,24.55 256.27,23.01 256.27,22.24 257.28,21.22 257.28,19.18 260.83,15.63 v1(260.83,15.14) 260.83,14.8 260.49,14.46 v2(260.49,14.04) 260.49,14.03 260.06,13.6 259.7,13.6 259.27,14.03 RC121.2 ; JXDP1.17 251.48,16.5 251.79,16.8 v2(251.79,16.88)
CFG4: length 22.6
  TOP w0.089: 245.01,26.43 245.01,26.97 245.18,27.14 245.18,27.68 UC1.BR20
  TOP w0.109: 245.01,26.43 245.01,26.12 245.55,25.58 245.55,24.53 244.42,23.4 RC322.1 244.93,22.44 244.93,20.64 244.73,20.44 v1(244.73,19.89) 244.73,19.14 245.9,17.97 245.9,17.44 245.49,17.03 245.06,17.03 244.94,16.91 244.94,14.5 245.46,13.98 247.07,13.98 247.33,14.23 247.33,15.72 v2(248.35,16.74)
  BOTTOM w0.109: JXDP1.27 248.48,16.6 v2(248.35,16.74)
CFG5: length 24.5
  TOP w0.089: 243.01,26.11 243.01,26.59 243.61,27.19 243.61,28.34 243.74,28.46 243.74,29.4 243.96,29.63 244.59,29.63 UC1.BM20
  TOP w0.109: 243.01,26.11 243.01,24.75 v1(242.59,24.33) 242.22,23.96 242.22,22.57 241.7,22.05 241.7,20.58 243.12,19.16 243.12,16.87 244.63,15.37 244.63,14.48 245.36,13.74 247.17,13.74 v2(247.88,14.45)
  BOTTOM w0.109: JXDP1.29 v2(247.88,14.45) 247.88,13.47 RC323.1
CFG6: length 16.6
  TOP w0.102: UC1.BT20 244.88,27.15 244.8,27.07 244.8,25.99 245.33,25.46 245.33,24.69 244.9,24.25 v1(244.69,24.25) v2(244.27,23.84) 243.9,23.47 243.9,22.61 243.2,21.91 RC324.1
  IN1 w0.102: v2(246.45,16.62) 246.45,16.63 246.45,19.07 246.77,19.39 246.77,20.86 244.48,23.15 244.48,23.65 244.3,23.84 v2(244.27,23.84)
  BOTTOM w0.109: JXDP1.33 246.68,16.39 v2(246.45,16.62)
CFG7: length 17.4
  TOP w0.089: 245.29,26.51 245.29,26.91 245.36,26.99 245.36,27.93 244.88,28.41 UC1.BP20
  TOP w0.109: v2(246.92,14.54) 246,15.46 246,17.08 246.43,17.52 v1(246.43,18.35) 246.61,18.53 246.61,21.07 RC325.1 245.56,22.17 245.56,23.17 245.31,23.42 245.31,23.89 245.8,24.39 245.8,25.72 245.29,26.23 245.29,26.51
  BOTTOM w0.109: v2(246.92,14.54) 246.08,15.37 JXDP1.35
CFG8: length 18.3
  TOP w0.089: UC1.BR23 246.94,27.67 246.94,26.96 246.86,26.89 246.86,26.3 246.98,26.19 247.5,26.19 v2(247.69,26)
  IN1 w0.102: v2(247.69,26) 249.84,23.85 249.84,21.9 250.34,21.4 250.61,21.4 251,21.01 254.07,21.01 254.62,21.56 v2(254.62,21.89)
  BOTTOM w0.109: v2(247.69,26) v1(247.69,25.2) ; JXDP1.10 253.58,19.25 253.98,19.64 RC437.1 254.37,20.35 254.62,20.61 v2(254.62,21.89)
CFG9: length 18.4
  TOP w0.089: UC1.BR22 246.76,27.68 246.76,27.12 246.57,26.93 246.57,25.91 246.72,25.76 v2(247.14,25.76)
  IN1 w0.102: v2(253.28,19.85) 252.48,20.65 251.02,20.65 250.5,21.17 250.26,21.17 249.6,21.82 248.48,21.82 248,22.3 248,23.82 247.55,24.28 247.55,25.36 v2(247.14,25.76)
  BOTTOM w0.109: v2(253.28,19.85) 253.28,21.01 RC439.1 253.15,21.13 RC438.1 252.75,20.58 v1(252.75,20.12) 252.75,19.75 253.15,19.35 253.15,19.06 252.98,18.89 JXDP1.12
CFG10: length 12.7
  TOP w0.109: v2(248.03,26.55) UC1.BT23
  BOTTOM w0.109: v2(248.03,26.55) 248.65,25.92 v1(249.21,25.92) 250.48,25.92 252.17,24.23 252.17,23.17 251.74,22.74 251.74,21.64 251.28,21.18 RC440.1 252.04,20.35 252.04,19.1 251.78,18.84 JXDP1.16
CFG11: length 12.6
  TOP w0.109: UC1.BT22 246.17,27.04 246.17,25.69 247.54,24.32 v2(248.02,24.32)
  BOTTOM w0.109: JXDP1.18 251.18,18.98 251.12,19.05 251.12,19.61 251.28,19.77 v1(251.28,20.16) 250.33,21.11 RC441.1 250.33,21.37 250.79,21.84 250.79,22.96 250.49,23.26 249.57,23.26 249.32,23.5 248.85,23.5 v2(248.02,24.32)
CFG12: length 15.6
  TOP w0.109: v2(244.49,30.25) 244.17,29.93 UC1.BM19
  BOTTOM w0.109: JXDP1.28 248.18,19.42 v1(249.02,20.25) 249.39,20.62 RC442.1 249.85,21.7 249.85,22.64 249.26,23.22 248.47,23.22 246.22,25.48 246.22,26.82 245.19,27.85 245.19,29.55 v2(244.49,30.25)
CFG13: length 14
  TOP w0.089: 243.22,25.59 243.22,26.55 243.79,27.11 243.79,27.67 UC1.BR19
  TOP w0.109: 243.22,25.59 243.22,25.29 243.65,24.86 v2(244.91,24.86)
  BOTTOM w0.109: JXDP1.30 247.58,19.44 248.49,20.35 RC443.1 248.47,21.24 248,21.7 248,23.36 246.5,24.86 v1(245.79,24.86) v2(244.91,24.86)
CFG14: length 13.7
  TOP w0.109: v2(244.23,26.29) 244.28,26.29 244.42,26.43 244.42,28.3 UC1.BP19
  BOTTOM w0.109: v2(244.23,26.29) 244.55,25.97 v1(244.55,25.35) 244.34,25.14 244.34,24.73 244.72,24.35 246.68,24.35 247.77,23.26 247.77,20.47 246.38,19.08 JXDP1.34
CFG15: length 12.7
  TOP w0.109: v2(243.64,26.21) 243.64,26.35 244.1,26.81 UC1.BT19
  BOTTOM w0.109: JXDP1.36 245.78,19.08 v1(246.42,19.72) 246.66,19.72 247.53,20.59 247.53,23.16 246.58,24.11 244.63,24.11 244.1,24.63 244.1,25.83 243.72,26.21 v2(243.64,26.21)
CFG16: length 15.1
  TOP w0.109: UC1.BP23 247.28,28.63 247.61,28.3 v2(247.64,28.3)
  BOTTOM w0.109: JXDP1.6 254.78,18.88 255.33,19.43 255.33,22.91 254.67,23.57 253.16,23.57 250.09,26.65 250.09,26.72 v1(249.12,27.7) 248.51,28.3 v2(247.64,28.3)
CFG17: length 15.9
  TOP w0.109: v2(247.64,28.95) 247.31,29.28 UC1.BN23
  BOTTOM w0.109: v2(247.64,28.95) v1(248.35,28.95) 248.63,28.95 250.36,27.22 250.36,26.7 253.07,24 254.61,24 255.65,22.96 255.65,19.24 255.38,18.98 JXDP1.4
CFG18: length 13.5
  TOP w0.109: v2(249.39,19.41) 249.39,19.91 v1(249.24,20.06) ; UC1.BN22 v2(246.06,28.95)
  IN1 w0.102: v2(246.06,28.95) 245.5,28.39 245.5,27.43 246.37,26.56 246.37,25.74 247.17,24.95 247.17,21.63 v2(249.39,19.41)
  BOTTOM w0.109: v2(249.39,19.41) 249.38,19.41 JXDP1.24
CFG19: length 12.6
  TOP w0.109: UC1.BP22 v2(246.06,28.3) ; v2(250.1,19.55) 250.1,19.08 v1(250.01,18.99)
  IN1 w0.102: v2(246.06,28.3) 246.77,27.59 246.77,25.61 247.36,25.03 247.36,22.29 v2(250.1,19.55)
  BOTTOM w0.109: JXDP1.22 249.98,19.43 v2(250.1,19.55)
CHR_USB20_N1: length 4.1
  TOP w0.102: UI1.11 383.39,62.94 383.84,63.4 383.89,63.4 384.47,63.97 v3(384.77,63.97) LI3.3
CHR_USB20_N2: length 2.2
  TOP w0.102: LI4.3 385.45,36.98 385.32,36.84 385.04,36.84 384.74,36.54 384.51,36.32 384.29,36.32 384.13,36.47 UI2.11
CHR_USB20_N3: length 5.3
  TOP w0.102: UI3.11 116.05,152.72 116.21,152.88 116.21,153.1 116.43,153.32 v3(117.47,153.32) 118.84,153.32 118.88,153.36 119.42,153.36 119.64,153.58 119.64,153.93 119.48,154.09 LI7.3
CHR_USB20_P1: length 4.1
  TOP w0.102: UI1.10 383.89,62.11 383.58,62.42 383.58,62.81 v3(383.8,63.03) 384.51,63.74 385.14,63.74 385.25,63.63 385.25,63.56 385.34,63.47 LI3.2
CHR_USB20_P2: length 2.2
  TOP w0.102: UI2.10 384.18,35.97 384.33,36.13 384.59,36.13 385.12,36.65 385.29,36.65 385.46,36.48 LI4.2
CHR_USB20_P3: length 5.3
  TOP w0.102: LI7.2 119.98,154.12 119.83,153.97 119.83,153.5 119.46,153.13 v3(119.17,153.13) 117.83,153.13 117.79,153.1 117.18,153.1 117.14,153.13 116.51,153.13 116.4,153.02 116.4,152.87 116.55,152.71 UI3.10
CLK_CNV_PRX_DTX_N: length 82.6
  TOP w0.109: UH1.BD4 v2(124.76,47.23)
  IN4 w0.102: v2(124.76,47.23) 125.21,47.68 125.21,48.22 124.7,48.73 123.67,48.73 121.81,50.6 119.67,50.6 118.35,51.92 118.35,54.44 117.3,55.49 113.93,55.49 111.38,58.03 110.57,58.03 107.24,61.36 107.24,62.09 106.37,62.97 106.37,63.94 107.12,64.7 107.12,68.9 105.71,70.32 105.71,74.59 108.76,77.63 108.76,78.68 112.02,81.95 112.02,82.33 116.45,86.76 116.45,88.3 117.84,89.69 117.84,95.52 117.21,96.15 114.88,96.15 114.56,96.47 114.56,99.08 113.84,99.8 113.84,101.34 114.48,101.99 117.39,101.99 117.47,101.91 117.47,100.9 117.38,100.8 117.22,100.8 v2(116.99,101.04)
  BOTTOM w0.109: RZ526.1 117.42,101.17 117.29,101.04 v2(116.99,101.04)
CLK_CNV_PRX_DTX_P: length 82.6
  TOP w0.109: UH1.BE3 v2(124.43,47.73)
  IN4 w0.102: v2(124.43,47.73) 124.56,47.61 124.87,47.61 125.02,47.76 125.02,48.14 124.62,48.54 123.59,48.54 121.73,50.41 119.59,50.41 118.16,51.84 118.16,54.37 117.23,55.3 113.85,55.3 111.31,57.85 110.49,57.85 107.06,61.28 107.06,62.01 106.18,62.89 106.18,63.86 106.18,64.02 106.94,64.77 106.94,68.83 105.52,70.24 105.52,74.67 108.57,77.71 108.57,78.76 111.84,82.02 111.84,82.41 116.27,86.84 116.27,88.38 117.65,89.77 117.65,95.44 117.13,95.96 114.81,95.96 114.37,96.4 114.37,99 113.65,99.73 113.65,101.42 114.4,102.17 117.47,102.17 117.66,101.98 117.66,101.34 v2(117.96,101.04)
  BOTTOM w0.109: RZ525.1 117.64,101.41 117.64,101.21 117.81,101.04 v2(117.96,101.04)
CLK_CNV_PTX_DRX_N: length 94.1
  TOP w0.109: UH1.BC5 124.73,46.37 124.51,46.58 v2(124.51,46.7)
  IN4 w0.102: v2(114.94,93.55) 115.28,93.2 115.46,93.2 115.69,92.97 115.69,91.92 115.16,91.39 113.68,91.39 110.26,87.97 110.26,87.86 109.08,86.67 109.08,86.1 108.26,85.28 108.26,82.28 104.7,78.72 104.7,77.26 104.12,76.68 103.58,76.68 101.83,74.93 101.83,73.69 101.54,73.4 101.24,73.4 101.06,73.22 101.06,72.97 101.24,72.79 101.54,72.79 101.83,72.5 101.83,72.1 101.54,71.81 101.18,71.81 101,71.63 101,71.38 101.18,71.2 101.54,71.2 101.83,70.91 101.83,70.84 102.8,69.86 103.64,69.86 105.34,68.16 105.34,65.46 104.28,64.39 104.28,61.17 104.85,60.59 104.85,59.59 106.63,57.81 107.64,57.81 109.67,55.77 110.88,55.77 113.93,52.72 113.93,52.07 115.01,50.99 115.01,48.06 115.6,47.47 116.36,47.47 117.18,48.3 120.98,48.3 123.6,45.68 124.05,45.68 124.51,46.14 v2(124.51,46.7)
  BOTTOM w0.109: RZ524.1 127.58,101.58 127.58,101.31 126.7,100.43 125.41,100.43 124.21,99.24 122.99,99.24 122.78,99.02 119.1,99.02 118.4,98.33 118.4,96.18 116.63,94.42 116.63,94.08 115.66,93.11 115.07,93.11 114.94,93.24 v2(114.94,93.55)
CLK_CNV_PTX_DRX_N_R: length 3.2
  BOTTOM w0.109: JNGFF1.63 128.26,104.05 128.39,103.91 128.39,103.57 128.3,103.48 127.79,103.48 127.52,103.21 127.52,102.61 RZ524.2
CLK_CNV_PTX_DRX_P: length 94.1
  TOP w0.109: UH1.BB6 124.95,45.82 v2(124.87,45.89)
  IN4 w0.102: v2(124.87,45.89) 124.87,46.02 124.81,46.09 124.72,46.09 124.13,45.5 123.52,45.5 120.9,48.11 117.26,48.11 116.43,47.28 115.52,47.28 114.82,47.98 114.82,50.91 113.74,51.99 113.74,52.64 110.8,55.58 109.6,55.58 107.56,57.62 106.56,57.62 104.66,59.51 104.66,60.52 104.09,61.09 104.09,64.47 105.15,65.53 105.15,68.09 103.57,69.67 102.72,69.67 101.64,70.76 101.64,70.83 101.46,71.01 101.1,71.01 100.82,71.3 100.82,71.71 101.1,71.99 101.46,71.99 101.64,72.17 101.64,72.43 101.46,72.6 101.16,72.6 100.88,72.89 100.88,73.3 101.16,73.59 101.46,73.59 101.64,73.77 101.64,75.01 103.5,76.87 104.05,76.87 104.51,77.33 104.51,78.79 108.07,82.35 108.07,85.36 108.89,86.17 108.89,86.75 110.08,87.93 110.08,88.05 113.61,91.58 115.09,91.58 115.5,92 115.5,92.89 115.38,93.01 115.22,93.01 v2(114.94,92.72)
  BOTTOM w0.109: RZ523.1 127.79,101.66 127.79,101.22 126.79,100.22 125.5,100.22 124.3,99.02 123.08,99.02 122.87,98.81 119.19,98.81 118.62,98.24 118.62,96.09 116.85,94.33 116.85,93.99 115.75,92.9 115.11,92.9 v2(114.94,92.72)
CLK_CNV_PTX_DRX_P_R: length 3.2
  BOTTOM w0.109: JNGFF1.65 128.75,104.03 128.61,103.88 128.61,103.48 128.39,103.26 127.88,103.26 127.74,103.12 127.74,102.64 RZ523.2
CLK_PCIE_N1: length 142.3
  TOP w0.094: v2(131.46,44.65) UH1.AH9
  IN2 w0.094: v2(23.54,16.22) 23.4,16.08 23.19,16.08 23.11,16.16 23.11,16.64 23.64,17.16 24.45,17.16 25.04,17.75 25.04,19.24 26.12,20.32 27.26,20.32 27.98,19.6 29.13,19.6 29.57,19.17 33.3,19.17 33.46,19.33 38.34,19.33 39.19,20.18 39.44,20.18 39.55,20.28 41.64,20.28 43.08,18.85 44.44,18.85 45.07,19.47 46.99,19.47 47.25,19.74 51.34,19.74 51.68,19.4 52.86,19.4 53.16,19.7 56.08,19.7 58.22,17.57 59.93,17.57 62.15,15.35 63.4,15.35 63.77,15.71 66.71,15.71 69.39,18.39 76.1,18.39 81.16,23.45 81.91,23.45 82.29,23.83 83.51,23.83 84.64,24.96 88.06,24.96 90.13,27.03 93.75,27.03 96.58,29.86 96.58,30.44 97.34,31.21 98.91,31.21 99.97,32.27 99.97,33.51 101.02,34.55 102.25,34.55 105.04,37.35 105.04,38.4 105.84,39.2 109.23,39.2 112.85,42.82 112.85,47.15 113.8,48.1 114.86,48.1 115.55,47.41 116.46,47.41 117.01,47.96 117.69,47.96 118.15,47.96 123.03,47.96 123.75,48.68 124.98,48.68 125.77,47.89 127.14,47.89 128.39,46.64 128.39,46.09 129.04,45.44 131.54,45.44 132.05,44.93 132.05,44.45 131.9,44.29 131.47,44.29 131.38,44.38 131.38,44.57 v2(131.46,44.65)
  BOTTOM w0.102: UR1.8 21,15.43 21.02,15.45 22.88,15.45 23.26,15.83 23.26,15.95 v2(23.54,16.22)
CLK_PCIE_N2: length 113.8
  TOP w0.102: UH1.AE14 133.18,42.3 v2(132.97,42.51)
  IN1 w0.102: v2(159.92,103.39) 159.6,103.07 159.37,103.07 158.95,102.65 158.95,101.73 160.59,100.09 165.59,100.09 168.48,97.21 168.48,96.28 169.19,95.57 169.19,91.44 169.66,90.97 169.66,82.06 164.94,77.33 164.94,76.17 164.22,75.45 164.22,73.62 164.73,73.11 164.73,67.52 163.81,66.59 163.81,59.28 161.3,56.77 161.3,52.53 159.58,50.8 159.58,43.7 155.08,39.21 155.08,38.15 152.68,35.76 149.52,35.76 149.29,35.99 145.11,35.99 144.24,35.13 140.92,35.13 140.47,35.58 140.47,36.33 138.76,38.04 138.76,38.7 138.45,39 137.46,39 136.37,40.1 135.91,40.1 134.81,41.2 134.25,41.2 133.7,41.74 133.7,42 133.48,42.22 133.26,42.22 v2(132.97,42.51)
  BOTTOM w0.102: JNGFF2.45 158.24,106.33 160.65,103.92 160.65,103.28 160.35,102.98 160.07,102.98 159.92,103.13 v2(159.92,103.39)
CLK_PCIE_N3: length 203
  TOP w0.102: UH1.AE6 133.63,46.09 v2(133.26,45.72) ; v2(155.05,133.01) 154.69,133.38 154.69,134.86 154.07,135.48 154.07,136.26 154.18,136.37 UL1.45
  IN4 w0.102: v2(155.05,133.01) 154.77,133.29 154.77,133.61 154.32,134.06 151.28,134.06 149.36,135.98 149.36,137.43 145.58,141.21 135.98,141.21 120.12,157.07 111.05,157.07 110.39,156.41 110.39,154.76 110.84,154.31 110.84,150.11 112.55,148.39 112.55,145.59 113.74,144.4 113.74,141 113.17,140.43 113.17,134.88 117.5,130.55 117.5,109.57 120.22,106.85 120.93,106.85 122.8,104.99 123.79,104.99 124.47,104.31 124.47,95.93 125.4,95.01 125.4,90.94 117.02,82.56 116.33,82.56 112.6,78.82 112.6,76.86 109.88,74.14 109.88,73.73 109.02,72.86 109.02,70.4 109.52,69.89 109.52,66.08 109.92,65.68 109.92,64.4 112.03,62.29 112.03,61.42 112.73,60.72 118.12,60.72 118.88,59.96 120.98,59.96 123.12,57.81 123.12,56.05 124.53,54.64 124.53,51.93 126.64,49.81 126.88,49.81 129.13,47.56 132.24,47.56 133.55,46.26 133.55,46.01 v2(133.26,45.72)
CLK_PCIE_N4: length 133.9
  TOP w0.089: v2(134.03,53.95) 134.03,54.24 134.12,54.33 134.42,54.33 134.68,54.07 134.68,52.03 135.03,51.68 135.03,48.33 135.01,48.31 135.01,47.63 134.93,47.55 134.73,47.55 134.67,47.62 134.67,47.76 UH1.AC2
  IN2 w0.094: v2(134.03,53.95) 133.86,54.12 132.34,54.12 130.39,56.07 119.65,56.07 119.46,56.26 117.72,56.26 117.36,55.89 114.56,55.89 113.4,54.73 110.82,54.73 109.88,53.79 106.11,53.79 105.04,52.72 101.01,52.72 99.02,50.73 99.02,50.64 99.02,45.37 95.04,41.39 95.04,39.6 89.99,34.54 89.04,34.54 84.19,29.69 80.16,29.69 76.68,26.21 72.34,26.21 71.78,25.65 69.15,25.65 65.78,22.27 63.75,22.27 62.62,23.4 62.62,24.01 60.76,25.87 60.76,26.15 54.53,32.38 53.41,32.38 52.7,33.09 50.84,33.09 45.96,37.97 45.96,40.35 44.61,41.7 41.19,41.7 39.31,43.58 39.31,43.67 v2(39.04,43.94)
  BOTTOM w0.102: v2(39.04,43.94) UT1.T19
