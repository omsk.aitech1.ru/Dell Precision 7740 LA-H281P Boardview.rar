# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLK_PCIE_N6: length 75.5
  TOP w0.089: v2(136.3,48.65) 136.51,48.86 136.69,48.86 136.78,48.77 136.78,48.43 136.45,48.11 136.45,47.59 136.35,47.49 136.35,47.21 136.48,47.08 UH1.W4
  IN1 w0.102: v2(122.74,103.2) 122.74,103.93 122.33,104.34 120.64,104.34 119.8,103.5 119.8,102.31 120.12,101.99 120.12,100.57 126.13,94.55 126.13,89.77 126.99,88.92 126.99,81.74 126.1,80.85 126.1,78.85 125.07,77.82 125.07,76.24 125.45,75.86 125.45,74.85 126.87,73.44 127.07,73.44 128.14,72.37 128.14,71.67 128.62,71.19 128.62,67.03 128.47,66.88 128.47,66.13 129.58,65.03 130.45,65.03 131.36,64.11 132.12,64.11 133.78,62.45 135.21,62.45 136.66,61 136.66,52.67 135.38,51.38 135.38,48.98 135.71,48.65 v2(136.3,48.65)
  BOTTOM w0.102: v2(122.74,103.2) 122.46,103.48 122.46,103.6 122.64,103.78 122.64,104 122.75,104.11 JNGFF1.41
CLK_PCIE_N7: length 227.3
  TOP w0.076: v2(138.52,49.53) 138.52,49.82 138.45,49.89 138.24,49.89 138.1,49.75 138.1,49.04 137.85,48.79 137.85,48.39 138,48.24 138,47.17 137.74,46.92 137.74,46.75 137.39,46.4 137.39,45.8 137.13,45.54 136.76,45.54 UH1.W7
  IN2 w0.094: v2(138.52,49.53) 138.65,49.66 139.27,49.66 139.5,49.89 140.21,50.6 140.21,51.07 141.22,52.07 142.01,52.07 142.24,52.3 142.68,52.3 143.88,53.5 144.31,53.5 145.88,51.92 147.11,51.92 149.62,49.41 150.87,49.41 159.81,40.47 159.81,32.37 161.69,30.49 161.69,28.79 162.82,27.66 162.82,24.66 165.55,21.93 165.55,16.09 173.35,8.29 237.92,8.29 239.22,9.6 243.19,9.6 244.57,10.98 256.94,10.98 258.45,9.47 292.44,9.47 295.75,12.78 307.25,12.78 313.11,18.64 313.11,19.16 312.89,19.37 312.3,19.37 v2(312.04,19.63)
  BOTTOM w0.102: JNGFF3.53 318.6,19.04 318.44,18.89 315.66,18.89 315.27,19.27 312.4,19.27 v2(312.04,19.63)
CLK_PCIE_N8: length 273.2
  TOP w0.102: v2(134.28,42.6) 134.58,42.3 UH1.AC14
  IN2 w0.094: v2(134.28,42.6) 134.55,42.33 134.8,42.33 135.22,41.91 135.22,41.21 136.53,39.9 137.89,39.9 138.87,38.92 141.32,38.92 142.02,39.62 143.68,39.62 148.3,35 149.77,35 152.25,32.52 152.25,26.49 152.15,26.39 152.15,23.53 154.41,21.26 154.41,18.88 170.23,3.06 245.47,3.06 248.13,5.72 253.03,5.72 256.18,2.56 268.74,2.56 269.4,1.9 318.23,1.9 318.43,2.11 319.41,2.11 320.04,1.47 334.19,1.47 334.82,2.09 343.27,2.09 343.71,2.53 356.43,2.53 358.3,4.4 358.3,6.57 361.25,9.52 362.37,9.52 363.65,10.79 364.74,10.79 365.92,11.97 367.17,11.97 367.69,12.49 371.1,12.49 371.27,12.32 371.27,11.83 v2(371.36,11.74)
  BOTTOM w0.102: v2(371.36,11.74) 371.1,11.48 371.1,10.86 371.25,10.7 JNGFF4.53
CLK_PCIE_N9: length 244.2
  TOP w0.076: 137.47,49.13 137.47,49.11 137.45,49.09 137.45,48.27 137.32,48.14 137.32,47.74 137.39,47.66 137.55,47.66 137.64,47.76 137.64,47.88 UH1.U2
  TOP w0.102: 137.47,49.13 137.47,49.3 137.77,49.6 137.77,50.23 137.5,50.5 137.37,50.5 v2(137.17,50.7)
  IN2 w0.094: v2(137.17,50.7) 137.46,50.41 137.68,50.41 137.77,50.5 137.77,51.49 139.16,52.89 141.93,52.89 143.42,54.37 144.68,54.37 146.01,53.03 148.91,53.03 160.73,41.21 160.73,32.68 163.41,30 163.41,28.81 163.75,28.46 163.75,24.95 166.42,22.28 166.42,16.45 173.71,9.16 235.77,9.16 237.09,10.48 242.46,10.48 244.94,12.95 256.54,12.95 259.16,10.34 291.11,10.34 295.17,14.4 302.38,14.4 312.13,24.14 312.13,32.11 316.08,36.06 316.08,43.96 316.34,44.22 316.54,44.22 v2(316.78,44.46)
  BOTTOM w0.102: JNGFF5.53 318.1,44.36 317.94,44.2 317.05,44.2 v2(316.78,44.46)
CLK_PCIE_N10: length 77.9
  TOP w0.102: v2(135.23,44.16) 135.23,44.19 134.83,44.58 UH1.AC9
  BOTTOM w0.102: JNGFF6.53 126.28,96.86 126.13,96.71 126.13,96.51 125.93,96.31 123.92,96.31 122.62,95.01 118.92,95.01 117.68,93.77 117.68,93.15 116.48,91.95 116.48,86.18 115.53,85.23 v3(115.53,80.71) 115.53,80.4 117.14,78.78 119.49,78.78 121.86,76.42 121.86,75.09 121.87,75.08 120.81,74.02 120.81,73.47 122.46,71.83 122.46,68.53 122.69,68.29 122.69,66.31 125.5,63.5 126.06,63.5 127.34,62.22 131.01,62.22 131.29,62.5 133.33,62.5 135.01,60.83 135.01,58.82 136.59,57.24 136.59,55.33 135.94,54.68 135.94,54.17 135.42,53.65 135.42,48.77 134.85,48.2 134.85,45.09 134.92,45.02 134.92,44.47 v2(135.23,44.16)
CLK_PCIE_P1: length 142.3
  TOP w0.094: v2(131.65,43.91) UH1.AH10
  IN2 w0.094: v2(131.65,43.91) 131.84,44.1 131.98,44.1 132.25,44.37 132.25,45.01 131.63,45.63 129.12,45.63 128.59,46.17 128.59,46.72 127.22,48.08 125.85,48.08 125.06,48.88 123.67,48.88 122.95,48.16 117.77,48.16 117.77,48.16 116.93,48.16 116.37,47.61 115.63,47.61 114.94,48.29 113.72,48.29 112.66,47.23 112.66,42.9 109.15,39.39 105.76,39.39 104.85,38.48 104.85,37.43 102.17,34.75 100.94,34.75 99.78,33.59 99.78,32.35 98.83,31.4 97.26,31.4 96.39,30.53 96.39,29.94 93.67,27.23 90.05,27.23 87.98,25.16 84.56,25.16 83.43,24.02 82.21,24.02 81.83,23.64 81.08,23.64 76.02,18.59 69.31,18.59 66.63,15.91 63.69,15.91 63.32,15.54 62.23,15.54 60.01,17.76 58.3,17.76 56.16,19.9 53.08,19.9 52.77,19.59 51.76,19.59 51.42,19.93 47.17,19.93 46.91,19.67 44.99,19.67 44.36,19.04 43.16,19.04 41.72,20.48 39.46,20.48 39.36,20.38 39.11,20.38 38.26,19.53 33.38,19.53 33.22,19.36 29.65,19.36 29.22,19.79 28.06,19.79 27.34,20.51 26.03,20.51 24.85,19.33 24.85,17.83 24.37,17.36 23.56,17.36 22.92,16.72 22.92,16.46 22.65,16.19 v2(22.63,16.19)
  BOTTOM w0.102: v2(22.63,16.19) 22.98,16.19 23.07,16.1 23.07,15.91 22.8,15.64 21.18,15.64 20.99,15.83 UR1.7
CLK_PCIE_P2: length 113.9
  TOP w0.102: v2(132.96,41.74) 133.16,41.53 UH1.AE15
  IN1 w0.102: v2(132.96,41.74) 132.97,41.74 133.26,42.03 133.41,42.03 133.52,41.92 133.52,41.66 134.17,41.01 134.73,41.01 135.84,39.91 136.29,39.91 137.38,38.82 138.37,38.82 138.57,38.62 138.57,37.96 140.28,36.25 140.28,35.5 140.84,34.94 144.32,34.94 145.18,35.8 149.21,35.8 149.44,35.57 152.76,35.57 155.27,38.08 155.27,39.13 159.76,43.63 159.76,50.73 161.49,52.45 161.49,56.7 163.99,59.2 163.99,66.51 164.92,67.44 164.92,73.19 164.41,73.7 164.41,75.38 165.12,76.09 165.12,77.26 169.85,81.98 169.85,91.05 169.38,91.52 169.38,95.64 168.67,96.36 168.67,97.28 165.67,100.28 160.67,100.28 159.14,101.81 159.14,102.57 159.45,102.88 159.56,102.88 v2(159.92,102.52)
  BOTTOM w0.102: JNGFF2.47 158.74,106.1 160.84,104 160.84,103.2 160.43,102.79 160.19,102.79 v2(159.92,102.52)
CLK_PCIE_P3: length 203
  TOP w0.102: v2(134.03,45.71) 133.67,45.34 UH1.AE7 ; UL1.44 153.78,136.38 153.88,136.28 153.88,135.4 154.49,134.78 154.49,133.33 v2(154.17,133.01)
  IN4 w0.102: v2(134.03,45.71) 134.03,45.72 133.74,46.01 133.74,46.34 132.32,47.75 129.21,47.75 126.96,50 126.72,50 124.72,52.01 124.72,54.72 123.31,56.13 123.31,57.89 121.06,60.15 118.96,60.15 118.2,60.91 112.81,60.91 112.21,61.5 112.21,62.37 110.11,64.48 110.11,65.76 109.71,66.16 109.71,69.97 109.21,70.47 109.21,72.79 110.07,73.65 110.07,74.07 112.78,76.78 112.78,78.75 116.41,82.37 117.1,82.37 125.59,90.86 125.59,95.08 124.66,96.01 124.66,104.39 123.87,105.17 122.88,105.17 121.01,107.04 120.3,107.04 117.69,109.65 117.69,130.63 113.36,134.96 113.36,140.35 113.93,140.92 113.93,144.48 112.74,145.67 112.74,148.47 111.02,150.19 111.02,154.39 110.57,154.84 110.57,156.33 111.13,156.89 120.04,156.89 135.9,141.03 145.5,141.03 149.17,137.35 149.17,135.9 151.2,133.87 154.24,133.87 154.58,133.53 154.58,132.92 154.44,132.78 154.27,132.78 154.17,132.87 v2(154.17,133.01)
CLK_PCIE_P4: length 133.9
  TOP w0.089: UH1.AC3 135.18,47.56 135.18,48.24 135.19,48.26 135.19,51.75 134.84,52.1 134.84,54.13 134.49,54.49 134.25,54.49 v2(134.02,54.73)
  IN2 w0.094: v2(134.02,54.73) 134.18,54.57 134.18,54.41 134.09,54.32 132.42,54.32 130.47,56.27 119.73,56.27 119.54,56.45 117.64,56.45 117.28,56.09 114.48,56.09 113.32,54.93 110.74,54.93 109.8,53.99 106.03,53.99 104.96,52.92 100.93,52.92 98.83,50.81 98.83,50.72 98.83,50.72 98.83,50.06 98.83,50.06 98.83,45.45 94.85,41.47 94.85,39.68 89.91,34.74 88.96,34.74 84.11,29.88 80.08,29.88 76.6,26.41 72.26,26.41 71.7,25.85 69.07,25.85 65.7,22.47 63.83,22.47 62.81,23.48 62.81,24.09 60.96,25.95 60.96,26.23 54.61,32.58 53.49,32.58 52.78,33.29 50.92,33.29 46.16,38.05 46.16,40.43 44.69,41.9 41.27,41.9 39.5,43.66 39.5,43.76 v2(39.69,43.94)
  BOTTOM w0.102: UT1.V19 v2(39.69,43.94)
CLK_PCIE_P6: length 75.5
  TOP w0.089: v2(136.3,49.29) 136.57,49.02 136.76,49.02 136.94,48.83 136.94,48.36 136.64,48.06 136.64,47.75 136.84,47.56 136.84,47.41 136.78,47.35 UH1.W3
  IN1 w0.102: v2(136.3,49.29) 136.13,49.29 135.95,49.11 135.95,48.9 135.89,48.84 135.78,48.84 135.56,49.06 135.56,51.3 136.85,52.59 136.85,61.08 135.29,62.64 133.86,62.64 132.2,64.3 131.44,64.3 130.53,65.22 129.65,65.22 128.66,66.21 128.66,66.8 128.81,66.95 128.81,71.26 128.32,71.75 128.32,72.45 127.15,73.62 126.95,73.62 125.64,74.93 125.64,75.93 125.26,76.32 125.26,77.74 126.29,78.77 126.29,80.77 127.17,81.66 127.17,88.99 126.32,89.84 126.32,94.63 120.31,100.64 120.31,102.07 119.99,102.39 119.99,103.42 120.72,104.15 122.25,104.15 122.55,103.86 122.55,103.69 122.46,103.6 122.31,103.6 122.19,103.71 122.08,103.71 122.02,103.65 v2(122.02,103.2)
  BOTTOM w0.102: v2(122.02,103.2) 122.27,103.45 122.27,103.68 122.45,103.86 122.45,104.03 122.31,104.17 122.26,104.23 JNGFF1.39
CLK_PCIE_P7: length 227.3
  TOP w0.076: v2(138.52,50.25) 138.32,50.04 138.17,50.04 137.95,49.81 137.95,49.1 137.7,48.85 137.7,48.33 137.84,48.18 137.84,47.23 137.59,46.98 137.59,46.81 137.23,46.46 137.23,45.86 137.07,45.69 136.82,45.69 136.7,45.81 136.7,46.03 UH1.W6
  IN2 w0.094: v2(138.52,50.25) 138.52,50.03 138.69,49.86 139.19,49.86 140.02,50.69 140.02,51.15 141.14,52.27 141.93,52.27 142.16,52.5 142.6,52.5 143.8,53.7 144.39,53.7 145.96,52.12 147.19,52.12 149.7,49.61 150.95,49.61 160,40.56 160,32.45 161.88,30.57 161.88,28.87 163.01,27.74 163.01,24.74 165.75,22.01 165.75,16.17 173.43,8.49 237.84,8.49 239.14,9.79 243.11,9.79 244.49,11.17 257.03,11.17 258.53,9.67 292.36,9.67 295.67,12.97 307.17,12.97 312.92,18.72 312.92,19.08 312.81,19.18 312.19,19.18 311.96,18.95 311.96,18.79 v2(312.04,18.72)
  BOTTOM w0.102: v2(312.04,18.72) 312.4,19.08 315.19,19.08 315.58,18.7 318.42,18.7 318.58,18.54 JNGFF3.55
CLK_PCIE_P8: length 273.2
  TOP w0.102: v2(134.26,41.75) 134.47,41.53 UH1.AC15
  IN2 w0.094: v2(370.64,11.74) 371.07,12.17 371.07,12.24 371.02,12.3 367.77,12.3 367.25,11.78 366,11.78 364.82,10.6 363.73,10.6 362.45,9.32 361.33,9.32 358.5,6.49 358.5,4.32 356.51,2.34 343.79,2.34 343.35,1.89 334.9,1.89 334.27,1.27 319.96,1.27 319.32,1.91 318.52,1.91 318.31,1.71 269.32,1.71 268.66,2.37 256.1,2.37 252.94,5.53 248.21,5.53 245.55,2.87 170.15,2.87 154.22,18.8 154.22,21.18 151.95,23.45 151.95,26.47 152.06,26.57 152.06,32.44 149.69,34.8 148.22,34.8 143.59,39.43 142.1,39.43 141.4,38.72 138.79,38.72 137.81,39.7 136.45,39.7 135.03,41.13 135.03,41.83 134.72,42.14 134.52,42.14 134.26,41.87 v2(134.26,41.75)
  BOTTOM w0.102: JNGFF4.55 370.75,10.71 370.9,10.87 370.9,11.48 v2(370.64,11.74)
CLK_PCIE_P9: length 244.2
  TOP w0.076: UH1.U3 137.5,47.51 137.33,47.51 137.17,47.68 137.17,48.2 137.3,48.33 137.3,49.09 137.28,49.11 137.28,49.13
  TOP w0.102: 137.28,49.13 137.28,49.38 137.58,49.68 137.58,50.15 137.42,50.31 137.24,50.31 137.2,50.26 v2(137.2,49.89)
  IN2 w0.094: v2(137.2,49.89) 137.52,50.21 137.76,50.21 137.96,50.42 137.96,51.41 139.25,52.69 142.01,52.69 143.5,54.18 144.59,54.18 145.93,52.84 148.83,52.84 160.53,41.13 160.53,32.59 163.21,29.92 163.21,28.73 163.56,28.38 163.56,24.87 166.22,22.2 166.22,16.37 173.63,8.96 235.85,8.96 237.17,10.28 242.54,10.28 245.02,12.76 256.46,12.76 259.07,10.14 291.19,10.14 295.25,14.21 302.46,14.21 312.32,24.06 312.32,32.03 316.27,35.98 316.27,43.88 316.42,44.03 316.51,44.03 v2(316.78,43.75)
  BOTTOM w0.102: JNGFF5.55 318.06,43.85 317.9,44.01 317.05,44.01 v2(316.78,43.75)
CLK_PCIE_P10: length 77.9
  TOP w0.102: UH1.AC11 134.78,43.82 v2(134.41,44.19)
  BOTTOM w0.102: JNGFF6.55 125.78,96.88 125.94,96.72 125.94,96.59 125.85,96.5 123.84,96.5 122.54,95.2 118.84,95.2 117.49,93.85 117.49,93.23 116.29,92.03 116.29,86.26 115.34,85.31 115.34,81.04 115.3,81 115.3,80.42 115.34,80.38 115.34,80.32 117.06,78.59 119.41,78.59 121.66,76.34 121.66,75.14 120.62,74.1 120.62,73.4 122.27,71.75 122.27,68.45 122.5,68.21 122.5,66.24 125.43,63.31 125.98,63.31 127.26,62.03 131.09,62.03 131.37,62.31 133.25,62.31 134.82,60.75 134.82,58.74 136.4,57.16 136.4,55.41 135.75,54.76 135.75,54.25 135.23,53.73 135.23,48.85 134.66,48.28 134.66,45.02 134.73,44.94 134.73,44.28 134.64,44.19 v2(134.41,44.19)
CLK_PEG_N0: length 168.9
  TOP w0.102: v2(133.63,51.01) 133.45,50.84 133.28,50.84 132.98,50.54 132.98,49.64 133.06,49.57 133.06,49.17 132.95,49.07 132.95,48.58 132.57,48.2 132.57,47.37 132.67,47.06 132.96,46.77 132.96,46.42 132.39,45.85 131.69,45.85 131.62,45.91 UH1.AJ6 ; JDGFF1.H8 227.81,91.72 227.56,91.47 223.29,91.47 222.92,91.11 222.92,89.51 223.31,89.12 223.31,88.26 220.27,85.21 220.27,80.24 220.15,80.12 220.02,80.12 v2(219.79,80.35)
  IN2 w0.094: v2(133.63,51.01) 133.89,50.75 134.03,50.75 134.68,51.4 134.68,54.97 134.18,55.48 133.41,55.48 132.14,56.74 123.51,56.74 123.21,57.04 123.21,60.16 126.32,63.27 128.96,63.27 130.58,64.89 130.58,66.53 129.38,67.73 129.38,71.87 127.85,73.4 127.85,75.02 129.55,76.72 129.55,80.67 131.84,82.96 133.39,82.96 134.55,84.12 137.14,84.12 138.09,83.17 141.46,83.17 141.71,82.92 154.21,82.92 154.33,82.8 155.63,82.8 155.84,83.01 158.57,83.01 159.14,82.44 162.76,82.44 163.76,83.43 166.87,83.43 167.35,82.95 170.68,82.95 172.45,84.72 180.16,84.72 180.32,84.56 194.32,84.56 195.98,82.89 209.35,82.89 211.52,80.72 212.15,80.09 219.52,80.09 v2(219.79,80.35)
CLK_PEG_P0: length 168.9
  TOP w0.102: v2(133.63,50.3) 133.72,50.39 133.72,50.5 133.58,50.64 133.36,50.64 133.17,50.46 133.17,49.72 133.25,49.65 133.25,49.09 133.14,48.99 133.14,48.5 132.76,48.12 132.76,47.4 132.84,47.17 133.15,46.85 133.15,46.34 132.47,45.66 132.08,45.66 UH1.AJ7 ; v2(219.79,79.64) 220.07,79.93 220.23,79.93 220.46,80.16 220.46,85.14 223.5,88.18 223.5,89.2 223.11,89.59 223.11,91.03 223.36,91.28 227.64,91.28 227.8,91.12 JDGFF1.H7
  IN2 w0.094: v2(219.79,79.64) 219.53,79.9 212.07,79.9 211.38,80.59 209.27,82.7 195.9,82.7 194.24,84.36 180.24,84.36 180.08,84.53 172.53,84.53 170.76,82.76 167.27,82.76 166.79,83.24 163.84,83.24 162.84,82.24 159.06,82.24 158.49,82.81 155.92,82.81 155.71,82.61 154.25,82.61 154.13,82.73 141.62,82.73 141.38,82.97 138.01,82.97 137.06,83.92 134.63,83.92 133.47,82.77 131.92,82.77 129.74,80.59 129.74,76.64 128.04,74.94 128.04,73.48 129.57,71.95 129.57,67.81 130.77,66.61 130.77,64.81 129.04,63.08 126.4,63.08 123.41,60.08 123.41,57.12 123.59,56.94 132.22,56.94 133.49,55.68 134.26,55.68 134.88,55.05 134.88,51.32 134.12,50.55 133.88,50.55 v2(133.63,50.3)
CLK_TP_SIO_I2C_DAT: length 179.2
  TOP w0.109: v2(140.4,76.46) 140.04,76.11 UE1.E10
  IN1 w0.102: v2(74.5,20.05) 75.2,20.74 75.2,23.24 75.64,23.69 78.43,23.69 81.32,26.58 82.6,26.58 84.38,28.36 86.22,28.36 87.29,29.42 87.8,29.42 88.16,29.79 88.16,30.59 90.69,33.11 90.69,33.59 91.2,34.1 92.16,34.1 92.21,34.05 94.94,34.05 96.4,32.59 101.57,32.59 v2(101.79,32.37)
  IN3 w0.081: v2(29.92,9.92) 30.3,10.3 30.3,11.06 30.17,11.19 30.17,12.89 30.96,13.68 34.62,13.68 34.74,13.81 35.48,13.81 35.94,13.35 36.62,13.35 36.85,13.58 39.05,13.58 40.08,12.55 41.39,12.55 41.64,12.8 41.64,13.52 42.47,14.36 44.28,14.36 44.42,14.21 47.62,14.21 47.8,14.04 49.95,14.04 50.71,14.8 53.3,14.8 54.94,16.43 55.28,16.43 55.67,16.83 55.67,22.91 58.1,25.34 63.57,25.34 64.33,26.1 67.01,26.1 v2(67.75,26.83) ; v2(140.4,76.46) 140,76.07 140,75.38 139.29,74.66 138.24,74.66 137.87,74.29 137.87,69.54 137.81,69.48 137.81,67.99 137.7,67.89 137.7,67.87 137.33,67.5 136.31,67.5 135.63,66.83 133.59,66.83 133.14,66.38 133.14,65.17 132.97,65 129.11,65 128.66,65.45 126.96,65.45 126.58,65.84 122.85,65.84 122.62,65.61 121.46,65.61 118.96,63.11 118.69,63.11 114.98,59.4 114.98,58.55 107.84,51.41 100.89,51.41 100.05,50.57 100.05,44.78 99,43.73 99,41.51 100.26,40.24 100.26,32.96 100.85,32.37 v2(101.79,32.37)
  BOTTOM w0.109: v2(67.75,26.83) v1(67.75,25.71) 67.75,24.72 71.53,20.94 73.54,20.94 74.44,20.05 v2(74.5,20.05) ; CZ81.1 29.14,9.03 RZ23.2 29.86,9.08 RZ346.1 29.92,9.67 29.92,9.67 v2(29.92,9.92)
CLK_TP_SIO_R: length 16.1
  TOP w0.109: v2(27.18,9.21) 26.62,8.65 24.83,8.65 24.72,8.76 24.72,9.38 24.61,9.49 24.4,9.49 24.29,9.38 24.29,8.76 24.18,8.65 23.96,8.65 23.85,8.76 23.85,9.38 23.74,9.49 23.52,9.49 23.41,9.38 23.41,8.76 23.3,8.65 23.09,8.65 22.98,8.76 22.98,9.38 22.87,9.49 22.65,9.49 22.54,9.38 22.54,8.76 21.49,7.71 20.5,7.71 19.84,7.06 JKBTP1.14
  BOTTOM w0.109: v1(26.72,9.66) v2(27.18,9.21) 27.31,9.08 RZ23.1 28.26,9.08 RZ19.2
CLKDET#: length 2.7
  TOP w0.076: 121.88,31.31 122.29,31.71 123.52,31.71 UH1.BF35
  TOP w0.109: T258.1 121.15,31.31 121.88,31.31
CLKREQ_CNV: length 109.4
  TOP w0.109: QZ18.2 135.39,100.28 134.97,100.7 RZ4.1 134.38,100.98 134.99,101.59 134.99,102.59 134.38,103.2 v2(134.38,106.5) ; v2(126.17,41.11) 126.07,41.01 UH1.BA17
  IN1 w0.102: v2(120,75.62) 119.61,75.23 119.61,73.56 120.81,72.35 120.81,70.53 121.82,69.52 121.82,68.78 122.35,68.25 122.35,61.87 122.91,61.31 122.91,56.08 124.09,54.9 124.09,54.01 124.41,53.69 124.41,48.41 125.23,47.59 125.23,46.93 124.9,46.6 124.9,46.44 124.51,46.04 124.51,45.74 124.51,45.74 124.51,45.38 124.2,45.07 124.2,43.56 126.17,41.6 v2(126.17,41.11)
  BOTTOM w0.109: RH733.1 124.65,41.79 124.79,41.92 125.38,41.92 126.17,41.14 v2(126.17,41.11) ; v2(134.38,106.5) 133.36,107.52 125.61,107.52 123.45,109.68 121.91,109.68 121.67,109.43 120.29,109.43 117.96,107.11 114.97,107.11 113.97,106.1 113.97,103.22 113.59,102.84 113.59,97.82 113.83,97.59 113.83,95.43 113.82,95.43 113.82,94.74 113.83,94.74 113.83,94.07 113.85,94 114.01,93.22 114.02,92.42 113.87,91.63 113.83,91.53 113.83,90.34 114.68,89.49 115.02,89.49 115.24,89.49 115.36,89.37 115.36,87.56 114.14,86.34 114.14,83.93 114.05,83.84 114.05,79.59 v1(114.5,79.14) 118.04,75.59 119.85,75.59 119.88,75.62 v2(120,75.62)
CLKREQ_CNV_R: length 45.8
  TOP w0.109: QZ18.3 135.47,99.63 135.33,99.77 v2(134.92,99.77) ; RZ376.2 135.01,98.69 134.82,98.88 134.82,99.68 v2(134.92,99.77) ; RZ4.2 134.57,100.12 v2(134.92,99.77)
  IN1 w0.102: v2(134.92,99.77) 134.92,101.91 132.88,103.95 132.88,108.22 132.25,108.84 130.93,108.84 130.64,108.55 128.08,108.55 127.16,109.46 127.16,117.95 126.86,118.25 126.86,121.78 v2(126.95,121.87)
  BOTTOM w0.109: v2(126.95,121.87) v1(125.66,121.87) 123.77,121.87 122.22,120.32 122.22,119.56 121.78,119.12 120.39,119.12 120.01,118.74 117.59,118.74 115.83,116.98 RZ532.2
CLKREQ_PCIE#1: length 124.2
  TOP w0.102: UH1.BE31 123.87,33.84 123.8,33.77 123.32,33.77 123.02,33.47 122.29,33.47 121.15,32.32 120.94,32.32
  TOP w0.109: v2(111.71,30.49) 111.53,30.67 v1(111.53,31.36) 112.6,31.36 112.83,31.12 115.11,31.12 RH124.1 115.6,31.59 117.58,31.59 117.8,31.82 120.09,31.82 120.59,32.32 120.94,32.32
  IN2 w0.081: v2(40.37,16.36) 40.86,16.85 42.38,16.85 43,16.23 47.57,16.23 47.79,16.44 51.07,16.44 52.59,14.92 54.3,14.92 55.65,16.27 56.32,16.27 56.7,15.89 56.7,15.46 57.24,14.92 58.89,14.92 60.68,13.13 76.21,13.13 82.23,19.16 84.57,19.16 85.28,19.87 87.76,19.87 88.58,20.68 88.58,22.26 90.33,24.02 93.79,24.02 94.83,25.06 96.37,25.06 97.73,26.43 97.73,27.37 98.8,28.44 100.21,28.44 100.35,28.58 108.23,28.58 110.14,30.49 v2(111.71,30.49)
  IN3 w0.081: v2(40.37,16.36) 39.82,16.91 39.03,16.91 38.72,17.21 32.32,17.21 31.21,18.32 31.21,19.17 30.18,20.2 30.18,21.71 29.41,22.48 24.8,22.48 v2(24.18,21.86)
  BOTTOM w0.109: UR1.2 20.99,17.83 21.97,18.82 21.97,19.27 22.5,19.8 22.5,19.93 24.18,21.61 v2(24.18,21.86)
CLKREQ_PCIE#2: length 141.9
  TOP w0.102: UH1.AR32 v2(129.05,32.93)
  TOP w0.109: v1(161.38,112.44) 161.03,112.78 v2(160.59,112.78)
  IN1 w0.102: v2(122.3,107.81) 122.3,107 120.69,105.39 119.57,105.39 118.26,104.08 118.26,102.66 119.28,101.64 119.28,100.01 125.04,94.25 125.04,86.5 124.68,86.14 124.68,83.39 124.8,83.26 124.8,79.34 123.85,78.39 123.85,75.42 124.24,75.02 124.24,73.17 125.41,72 125.41,71.38 126.74,70.04 126.74,67.81 127.4,67.15 127.4,65.66 127.54,65.53 127.54,64.12 128.05,63.6 128.51,63.6 129.19,62.92 129.19,62.07 131.52,59.74 132.17,59.74 132.53,59.38 132.53,57.12 131.4,56 131.4,53.69 130.82,53.1 130.82,49.46 129.79,48.43 129.79,46.24 127.77,44.22 127.77,42.62 128.34,42.05 128.34,40.06 127.94,39.65 127.94,37.5 128.78,36.67 128.78,35.07 129.56,34.28 129.56,33.44 v2(129.05,32.93)
  IN2 w0.081: v2(160.59,112.78) 160,113.37 142.9,113.37 141.78,114.49 136.24,114.49 133.72,111.97 132.67,111.97 132.48,111.77 132.48,109.27 130.66,107.46 124.79,107.46 124.36,107.03 124.36,105.55 124.1,105.3 122.86,105.3 122.15,106.01 122.15,107.66 v2(122.3,107.81)
  BOTTOM w0.109: JNGFF2.44 157.99,113.34 158.29,113.04 160.32,113.04 v2(160.59,112.78) ; RH126.1 128.93,33.04 v2(129.05,32.93)
CLKREQ_PCIE#3: length 157.2
  TOP w0.109: v2(156.16,136.67) 155.78,136.29 155.53,136.29 155.38,136.44 UL1.48 ; UH1.BB30 125.31,33.61 v2(125.29,33.59)
  IN1 w0.102: v2(124.14,140.71) 123.91,140.48 123.91,136.81 120.72,133.62 120.72,123.73 117.58,120.59 117.58,118.85 116.78,118.05 116.78,116.54 114.64,114.4 114.64,105.65 114.15,105.16 114.15,103.18 113.35,102.38 113.35,100.16 115.48,98.03 116.46,98.03 117.49,97.01 117.49,85.6 118.92,84.16 118.92,81.78 118.62,81.47 118.62,77.18 119.15,76.65 119.15,73.37 120.36,72.16 120.36,70.23 121,69.59 121,68.98 120.72,68.7 120.72,66.57 121.66,65.63 121.66,61.72 121.11,61.17 121.11,60.08 121.82,59.37 121.82,55.88 122.2,55.49 122.2,52.65 123.09,51.76 123.09,47.79 122.65,47.35 122.65,46.29 123.44,45.5 123.44,43.25 123.82,42.87 123.82,41.62 124.12,41.33 124.12,38.05 124.08,38.01 124.08,35.01 125.29,33.8 v2(125.29,33.59)
  IN2 w0.081: v2(156.16,136.67) 156.08,136.59 150.24,136.59 149.45,135.8 147.33,135.8 146.01,137.12 141.63,137.12 141.21,137.54 138.76,137.54 138.34,137.12 129.63,137.12 126.05,140.71 v2(124.14,140.71)
  BOTTOM w0.109: v2(156.16,136.67) v1(155.61,136.67) ; v2(125.29,33.59) 125.12,33.59 124.91,33.8 124.41,33.8 124.28,33.67 RH127.1
CLKREQ_PCIE#4: length 137.1
  TOP w0.109: UH1.BA30 126.05,33.99 125.88,33.81 v2(125.88,33.73) ; RT502.1 42.19,47.72 41.65,48.25 41.65,49.47 41.33,49.79 v2(40.99,49.79)
  IN1 w0.102: v2(49.8,35.65) 49.8,36.35 44.2,41.95 43.1,41.95 42.34,42.71 42.34,48.78 41.33,49.79 v2(40.99,49.79)
  IN2 w0.081: v2(125.88,33.73) 125.93,33.79 125.93,35.19 125.8,35.32 125.17,35.32 124.84,35 124.26,35 124.03,35.23 124.03,36.01 123.31,36.72 121.1,36.72 120.77,37.05 117.3,37.05 116.94,37.4 114.87,37.4 114.34,36.88 114.34,35.73 113.69,35.08 111.85,35.08 111.33,34.56 111.33,33.39 110.41,32.47 110.41,31.3 108.89,29.78 107.88,29.78 107.41,29.31 106.93,29.31 106.7,29.54 106.45,29.78 105.81,29.78 105.56,30.04 105.56,30.56 105.1,31.02 103.73,31.02 102.8,30.08 101.2,30.08 100.02,28.89 98.61,28.89 97.28,27.56 97.28,26.64 96.15,25.52 94.39,25.52 93.53,24.65 90.07,24.65 88.38,22.96 87.68,22.96 86.15,21.44 84.97,21.44 83.13,19.6 80.23,19.6 74.36,13.73 60.7,13.73 58.79,15.64 v2(57.5,15.64)
  IN4 w0.102: v2(57.5,15.64) 57.5,16.24 57.27,16.47 57.27,17.07 55.57,18.77 55.57,22.78 55.13,23.22 55.13,24.02 55.43,24.33 55.43,30.11 54.82,30.72 54.82,34 53.17,35.65 v2(49.8,35.65)
  BOTTOM w0.109: RH128.1 125.42,32.91 125.88,33.36 v2(125.88,33.73) ; UT1.Y6 v2(40.99,49.79)
CLKREQ_PCIE#6: length 150.5
  TOP w0.109: RH130.1 134.69,23.12 134.3,23.51 134.3,24.01 v2(133.89,24.42) 133.42,24.88 133.42,25.76 133.52,25.85 UH1.AE47 ; v2(113.97,88.87) 113.54,89.3 112.89,89.3 v1(112.47,88.87)
  IN1 w0.102: v2(133.89,24.42) 133.4,23.94 133.4,23.44 132.42,22.46 131.52,22.46 130.69,21.63 130.69,20.72 130.06,20.08 130.06,16.69 129.53,16.16 126.12,16.16 125.35,15.39 122.46,15.39 118,19.85 118,20.35 116.98,21.38 116.47,21.38 116.43,21.42 116.11,21.56 116.07,21.57 115.18,22.46 112.95,22.46 111.92,23.48 110.84,23.48 110.28,24.05 110.28,26.07 109.52,26.82 109.52,30.45 109.83,30.75 109.83,31.87 109.4,32.3 109.4,37.09 107.29,39.19 101.29,39.19 98.68,41.81 98.68,51.96 101.17,54.46 104.9,54.46 106.98,56.54 106.98,57.1 107.86,57.98 107.86,62.2 106.3,63.76 106.3,66.29 109.29,69.29 109.29,72.41 109.92,73.03 109.92,75.71 110.81,76.6 110.81,81.9 110.07,82.64 110.07,84.71 109.59,85.2 109.59,86.68 111.17,88.26 113.4,88.26 113.97,88.83 v2(113.97,88.87)
  IN3 w0.081: v2(123.06,106.55) 122.15,106.55 119.48,103.88 119.48,97.35 117.59,95.46 117.59,91.05 116.07,89.53 114.63,89.53 v2(113.97,88.87)
  BOTTOM w0.109: JNGFF1.45 123.75,106.41 123.61,106.55 v2(123.06,106.55)
CLKREQ_PCIE#7: length 225.3
  TOP w0.109: RH131.1 135.27,23.44 135.46,23.63 135.46,24.57 v2(134.99,25.04) 134.78,25.25 134.78,25.59 UH1.AC48
  IN3 w0.081: v2(134.99,25.04) 135.11,25.16 143.59,25.16 144.72,24.03 145.53,24.03 147.14,22.42 147.97,22.42 148.39,22.84 151.27,22.84 153.43,20.68 156.53,20.68 161.58,15.62 165.34,15.62 171.55,9.42 230.21,9.42 234.79,14 241.38,14 241.97,14.59 242.4,14.59 242.67,14.33 244,14.33 244.62,14.95 248.38,14.95 248.49,15.06 255.97,15.06 257.79,13.25 266.92,13.25 270.45,9.72 276.79,9.72 277.83,8.68 301.04,8.68 301.64,9.28 305.15,9.28 v2(305.66,8.77)
  BOTTOM w0.109: v2(305.66,8.77) 302.97,11.46 302.97,17.62 303.92,18.57 v1(309.26,18.57) 310.65,18.57 311.13,18.1 312.93,18.1 313.22,17.81 317.57,17.81 318.53,16.85 327.17,16.85 327.93,17.61 327.93,19 327.63,19.29 JNGFF3.52
CLKREQ_PCIE#8: length 270.4
  TOP w0.109: UH1.AE41 v2(133.1,28.88)
  IN2 w0.081: JNGFF4.52 371.5,9.72 372.64,10.87 372.64,12.33 371.52,13.45 366.04,13.45 364.34,11.75 363.25,11.75 362.49,10.99 360.6,10.99 v2(360.07,11.52)
  IN3 w0.081: v2(360.07,11.52) 360.07,11.54 358.33,13.27 357.31,13.27 355.74,14.85 349.69,14.85 349.5,15.04 347.17,15.04 345.2,13.07 341.87,13.07 341.53,13.42 337.86,13.42 337.17,12.73 335.79,12.73 335.52,12.99 333.45,12.99 331.72,14.72 320.76,14.72 315.06,9.03 306.62,9.03 305.96,8.37 304.99,8.37 304.44,8.92 301.79,8.92 301.19,8.32 277.68,8.32 276.64,9.36 270.3,9.36 267.3,12.36 266.63,12.36 266.08,12.91 257.65,12.91 256.59,13.97 243.06,13.97 242.74,13.65 234.94,13.65 230.36,9.07 170.02,9.07 166.71,12.38 166.71,13.49 164.93,15.27 161.44,15.27 156.38,20.32 148.84,20.32 147.11,22.06 146.2,22.06 145.84,21.71 140.82,21.71 139.41,23.12 137.71,23.12 v2(137,23.83) 136.7,24.12 135.86,24.12 135.85,24.13 134.7,24.13 134.38,24.45 134.38,26.7 133.1,27.98 v2(133.1,28.88)
  BOTTOM w0.109: v2(360.07,11.52) 360.07,11.74 v1(360.53,12.19) ; v2(137,23.83) 136.47,23.3 RH132.1
CLKREQ_PCIE#9: length 239.2
  TOP w0.109: RH133.1 134.12,23.12 133.93,23.31 v2(133.93,23.76) 133.93,23.81 133.23,24.51 133.23,25.33 UH1.AF48
  IN1 w0.102: v2(320.94,34.24) 320.94,36.82 322.41,38.29 322.41,43.12 v2(323.9,44.6)
  IN3 w0.081: v2(133.93,23.76) 134.74,22.95 139.34,22.95 140.75,21.54 146.06,21.54 146.22,21.7 146.96,21.7 148.7,19.97 156.23,19.97 161.29,14.91 163.67,14.91 169.87,8.71 230.51,8.71 235.09,13.29 242.88,13.29 243.21,13.62 256.47,13.62 257.51,12.58 265.91,12.58 266.49,12 267.16,12 270.17,8.98 276.52,8.98 277.54,7.97 301.33,7.97 301.93,8.57 302.56,8.57 v2(303.08,8.05)
  BOTTOM w0.109: v2(320.94,34.24) 320.74,34.04 318.14,34.04 317.29,33.2 v1(312.63,33.2) 311.85,33.2 301.43,22.78 301.43,15.9 299.46,13.93 299.46,11.23 302.22,8.47 302.66,8.47 v2(303.08,8.05) ; JNGFF5.52 v2(323.9,44.6)
CLKREQ_PCIE#10: length 79.4
  TOP w0.109: UH1.AC41 v2(134.16,28.88)
  IN1 w0.102: v2(134.16,28.88) 134.16,29.21 133.36,30.01 132.48,30.01 132.28,30.22 132.28,35.6 131.9,35.98 131.9,40.63 131.24,41.29 131.24,44.13 130.99,44.39 130.99,46.17 131.23,46.41 131.23,48.51 132.95,50.23 132.95,54.09 133.3,54.43 133.3,59.62 132.3,60.62 131.95,60.62 130.33,62.24 130.33,63.39 129.93,63.78 129.06,63.78 128.68,64.16 128.14,64.16 128,64.31 128,65.72 127.86,65.85 127.86,67.34 127.62,67.58 127.62,69.45 127.79,69.61 127.79,70.04 127.14,70.69 127.14,72.09 126.85,72.38 126.13,72.38 124.84,73.66 124.84,75.39 124.38,75.85 124.38,77.99 125.49,79.1 125.49,79.99 v2(125.58,80.08)
  BOTTOM w0.109: JNGFF6.52 126.53,88.66 125,87.13 125,84.78 124.35,84.12 124.35,82.83 v1(124.76,82.41) 125.13,82.05 125.13,80.53 v2(125.58,80.08) ; RH134.1 137.23,23.23 137.37,23.37 137.37,25.53 135.89,27.01 135.41,27.01 134.52,27.9 134.52,28.53 v2(134.16,28.88)
CLKREQ_PEG#0: length 233
  TOP w0.102: 121.03,32.52 121.08,32.52 122.21,33.66 122.94,33.66 123.28,34 UH1.BF31
  TOP w0.109: 121.03,32.52 120.51,32.52 120.06,32.07 118.15,32.07 117.82,32.4 RH123.1 117.75,32.31 117.45,32.01 116.2,32.01 116.15,32.05 v2(116.15,32.05)
  VCC w0.086: v2(161.59,68.93) 161.7,69.04 161.7,70.76 162.74,71.8 162.74,76.3 163.51,77.07 163.51,85.35 167.78,89.63 167.78,90.24 169.09,91.55 178.68,91.55 181.7,88.53 197.46,88.53 197.98,88.01 216.31,88.01 222.03,82.29 230.74,82.29 234.44,78.59 239.41,78.59 240.99,77.01 253.75,77.01 255.83,79.1 258.91,79.1 v2(259.84,78.16)
  IN3 w0.081: v2(116.15,32.05) 115.28,32.05 114.81,32.52 114.81,34.28 115.95,35.42 115.95,37.18 116.73,37.96 116.73,46.85 121.18,51.29 121.18,53.59 122.86,55.26 124.84,55.26 125.52,55.95 133.2,55.95 133.25,55.9 140.18,55.9 145.51,61.23 148.21,61.23 148.92,60.52 150.37,60.52 154.43,64.58 157.17,64.58 159.15,66.56 159.78,66.56 160.73,67.52 160.73,68.32 161.33,68.93 v2(161.59,68.93) ; v2(259.84,78.16) 260.2,78.16 261.62,79.58 269.2,79.58 270.33,78.45 284.01,78.45 v2(284.43,78.03)
  BOTTOM w0.109: v2(284.43,78.03) 284.5,78.11 QV42.1 ; v1(259.56,78.73) 259.84,78.45 v2(259.84,78.16)
CLKRUN#: length 3.4
  TOP w0.109: v2(127.09,33.66) 127.28,33.47 UH1.AV32
  BOTTOM w0.109: T318.1 124.75,34.42 126.63,34.42 127.09,33.96 v2(127.09,33.66)
CMPIN: length 2.7
  TOP w0.203: PR730.1 PR729.1 66.68,21.54 67.57,22.43 PU700.13
CMPOUT: length 9.8
  TOP w0.203: PU700.14 67.68,22.03 67.38,21.73 v2(67.38,21.48)
  BOTTOM w0.254: v2(59.38,22.49) 59.78,22.9 v1(60.78,22.9) 63.09,22.9 63.92,22.06 66.8,22.06 v2(67.38,21.48)
CNV_BRI_PRX_DTX: length 6.3
  TOP w0.102: 126.23,49.95 126.34,49.84 126.34,48.01 UH1.AY2
  TOP w0.109: 126.23,49.95 126.23,49.97 125,51.2 123.94,51.2 RH614.2 RZ533.2
CNV_BRI_PTX_DRX: length 90.5
  TOP w0.109: UH1.AV4 127.23,47.14 127.23,47.58 127.33,47.69 127.33,48.07 127.27,48.13 127.27,48.69 v2(126.92,49.04) 126.92,49.84 126.31,50.45 126.31,50.99 126.02,51.28 126.02,51.49 125.74,51.77 RH603.1
  IN1 w0.102: v2(126.92,49.04) 127.34,49.04 129.32,51.02 129.32,52.59 130.42,53.69 130.42,59.8 129.32,60.9 129.32,61.21 127.08,63.44 127.08,65.31 126.2,66.19 126.2,69.8 124.83,71.16 124.83,71.74 123.63,72.94 123.63,74.71 123.26,75.08 123.26,78.66 124.22,79.61 124.22,82.84 123.87,83.18 123.87,89 123.35,89.52 123.35,94.62 122.04,95.92 122.04,96.53 118.83,99.75 118.83,101.45 117.7,102.58 117.7,104.43 120.67,107.4 120.67,116.72 v2(121.06,117.11)
  BOTTOM w0.109: RH604.2 125.37,51.46 125.37,49.53 125.86,49.04 v2(126.92,49.04) ; v1(121.38,118.26) 121.49,118.15 121.49,117.59 121.06,117.17 v2(121.06,117.11) 120.5,116.55 RZ536.2
CNV_COEX1: length 128.2
  TOP w0.109: v1(162.21,116.5) 161.97,116.75 v2(161.71,116.75) ; v2(127.18,44.41) 127.48,44.41 127.63,44.57 127.72,44.57 UH1.AU9
  IN1 w0.102: v2(127.18,44.41) 127.18,44.58 126.11,45.66 126.11,47.7 125.09,48.71 125.09,53.97 124.77,54.29 124.77,55.21 123.59,56.39 123.59,61.59 123.04,62.15 123.04,68.53 122.5,69.07 122.5,71.41 120.76,73.15 120.76,78.81 121.97,80.02 121.97,87.39 121.36,88 121.36,92.74 v2(120.54,93.56)
  IN3 w0.081: v2(161.71,116.75) 162.16,117.2 166.78,117.2 167.98,116 167.98,110.02 164.21,106.25 164.21,102.95 163.3,102.03 159.1,102.03 158.53,102.59 156.24,102.59 152.09,98.44 152.09,97.58 150.8,96.28 149.68,96.28 148.91,97.05 131.08,97.05 128.66,94.63 125.6,94.63 124.82,93.84 121.59,93.84 121.51,93.92 121.51,93.93 121.31,94.14 120.76,94.14 120.54,93.91 v2(120.54,93.56)
  BOTTOM w0.109: RZ373.2 v2(161.71,116.75) ; RH608.1 127.07,44.41 v2(127.18,44.41) 127.3,44.29 127.3,43.98 127.61,43.68 RH607.2
CNV_COEX2: length 127
  TOP w0.109: UH1.AW2 127,47.92 127,48.36 v2(126.9,48.46) ; v2(162.57,118.63) 163.02,118.63 v1(163.13,118.52)
  IN1 w0.102: v2(121.21,108.68) 121.21,106.56 120.43,105.78 119.45,105.78 117.96,104.28 117.96,102.65 119.05,101.55 119.05,99.85 122.27,96.63 122.27,96.01 124.55,93.74 124.55,86.68 124.1,86.23 124.1,83.28 124.45,82.93 124.45,79.52 123.49,78.56 123.49,75.18 123.86,74.81 123.86,73.03 125.18,71.71 125.18,71.28 126.52,69.95 126.52,67.72 127.16,67.07 127.16,65.58 127.31,65.43 127.31,63.54 127.63,63.22 128.48,63.22 128.94,62.76 128.94,61.98 130.65,60.27 130.65,53.6 129.51,52.46 129.51,50.94 127.03,48.46 v2(126.9,48.46)
  IN2 w0.081: v2(121.21,108.68) 121.54,109 121.54,109.64 124.36,112.47 124.36,113.34 127.37,116.35 127.37,116.94 131.12,120.69 131.66,120.69 134.01,123.04 137.53,123.04 140.1,125.62 141.7,125.62 145.49,121.83 145.49,121.59 146.05,121.03 147.33,121.03 148.92,119.45 150.38,119.45 151.93,121 160.88,121 161.95,119.92 161.95,119.15 162.47,118.63 v2(162.57,118.63)
  BOTTOM w0.109: RZ372.2 162.42,118.78 v2(162.57,118.63)
CNV_COEX3: length 133.4
  TOP w0.109: UH1.AV6 126.75,46.39 126.6,46.39 v2(126.58,46.37)
  IN1 w0.102: v2(121.1,93.72) 121.59,93.23 121.59,88.09 122.2,87.48 122.2,79.93 120.99,78.72 120.99,73.24 122.73,71.5 122.73,69.16 123.26,68.63 123.26,62.25 123.82,61.69 123.82,56.48 125,55.3 125,54.38 125.32,54.06 125.32,48.92 126.99,47.25 126.99,46.49 126.87,46.37 v2(126.58,46.37)
  IN3 w0.081: v2(121.1,93.72) 121.23,93.59 124.89,93.59 125.7,94.4 128.73,94.4 131.17,96.84 148.79,96.84 149.64,96 151.13,96 152.37,97.25 152.37,98.4 156.34,102.36 158.44,102.36 159.01,101.8 163.39,101.8 164.42,102.83 164.42,106.17 168.39,110.13 168.39,117.96 166.14,120.2 160.56,120.2 159.71,121.05 v2(159.71,121.93)
  BOTTOM w0.109: RZ374.2 v1(159.97,118.21) 159.49,118.69 159.49,121.72 v2(159.71,121.93)
CNV_PRX_DTX_N0: length 83.2
  TOP w0.076: UH1.BB3 125.05,48.05 125.11,48.11 125.11,48.95 124.43,49.62 124.1,49.62 124.03,49.54 v2(124.03,49.26)
  IN4 w0.102: v2(116.75,99.63) 116.6,99.78 116.6,100.03 116.66,100.09 117.03,100.09 117.34,99.78 119.13,99.78 119.8,100.45 120.05,100.45 120.23,100.27 120.23,100.01 119.42,99.2 119.42,98.79 119.71,98.5 120.12,98.5 121.02,99.41 121.28,99.41 121.46,99.23 121.46,98.98 120.64,98.17 120.64,97.76 122.73,95.67 122.73,91.35 116.15,84.76 116.15,84.35 111.15,79.35 111.15,77.95 107.6,74.4 107.6,69.85 108.13,69.32 108.13,62.63 110.39,60.36 111.12,60.36 112.6,58.88 115.07,58.88 115.33,59.13 116.52,59.13 117.79,57.86 119.75,57.86 120.69,56.92 120.69,52.26 123.47,49.48 123.81,49.48 v2(124.03,49.26)
  BOTTOM w0.109: RZ527.1 116.17,101.69 116.17,101.66 116.18,101.65 116.18,101.18 116,101.01 116,100.18 116.31,99.87 116.51,99.87 v2(116.75,99.63)
CNV_PRX_DTX_N1: length 82.7
  TOP w0.076: 122.69,50.43 122.71,50.43 122.74,50.47 124.14,50.47 125.43,49.18 125.43,47.85 UH1.BA3
  TOP w0.109: 122.69,50.43 121.51,50.43 120.75,51.19 120.75,51.61 120.64,51.73 120.46,51.73 v2(120.21,51.48)
  IN4 w0.102: v2(120.21,51.48) 120.04,51.65 119.82,51.65 118.98,52.5 118.98,54.8 117.94,55.84 117.94,55.86 117.87,55.93 114.31,55.93 111.8,58.44 110.78,58.44 107.65,61.57 107.65,62.26 107.53,62.38 107.53,69.07 106.93,69.67 106.93,74.69 109.38,77.14 109.38,78.42 115.56,84.59 115.56,85.09 121.93,91.47 121.93,93.87 120.85,94.94 119.72,94.94 118.7,95.97 118.7,96.38 119.48,97.16 119.48,97.41 119.3,97.59 119.05,97.59 118.15,96.69 117.74,96.69 117.45,96.98 117.45,97.39 118.33,98.27 118.33,98.52 118.16,98.7 117.9,98.7 117.14,97.94 116.73,97.94 114.97,99.7 114.97,101.1 v2(114.71,101.35)
  BOTTOM w0.109: RZ529.1 114.97,101.75 114.97,101.6 v2(114.71,101.35)
CNV_PRX_DTX_P0: length 83.2
  TOP w0.076: v2(124.03,49.98) 124.23,49.77 124.5,49.77 125.26,49.01 125.26,48.04 125.08,47.87 UH1.BB4
  IN4 w0.102: v2(124.03,49.98) 124.03,49.86 123.83,49.67 123.55,49.67 120.88,52.34 120.88,57 119.82,58.05 117.87,58.05 116.6,59.32 115.25,59.32 114.99,59.07 112.68,59.07 111.19,60.55 110.47,60.55 108.31,62.7 108.31,69.4 107.78,69.93 107.78,74.32 111.34,77.87 111.34,79.27 116.34,84.27 116.34,84.68 122.92,91.27 122.92,95.75 120.83,97.84 120.83,98.09 121.64,98.9 121.64,99.31 121.35,99.6 120.95,99.6 120.04,98.69 119.79,98.69 119.61,98.87 119.61,99.12 120.42,99.94 120.42,100.34 120.13,100.63 119.72,100.63 119.05,99.96 117.42,99.96 117.1,100.28 116.96,100.28 v2(116.73,100.51)
  BOTTOM w0.109: RZ528.1 116.39,101.56 116.39,101.09 116.22,100.92 116.22,100.27 116.39,100.09 116.67,100.09 116.78,100.2 116.78,100.46 v2(116.73,100.51)
CNV_PRX_DTX_P1: length 82.9
  TOP w0.076: UH1.BA2 125.77,47.96 125.85,47.96 125.94,48.05 125.94,48.16 125.79,48.31 125.64,48.31 125.58,48.37 125.58,49.24 124.2,50.62 122.74,50.62 122.71,50.65 122.69,50.65
  TOP w0.109: 122.69,50.65 121.6,50.65 120.97,51.28 120.97,51.7 120.73,51.95 120.46,51.95 v2(120.21,52.2)
  IN4 w0.102: v2(115.43,101.35) 115.15,101.07 115.15,99.78 116.81,98.12 117.06,98.12 117.83,98.89 118.23,98.89 118.52,98.6 118.52,98.19 117.64,97.31 117.64,97.06 117.82,96.88 118.07,96.88 118.97,97.78 119.38,97.78 119.67,97.49 119.67,97.08 118.88,96.3 118.88,96.05 119.8,95.13 120.93,95.13 122.12,93.94 122.12,91.39 115.74,85.01 115.74,84.52 109.57,78.34 109.57,77.06 107.12,74.62 107.12,69.75 107.72,69.15 107.72,62.46 107.84,62.34 107.84,61.64 110.85,58.63 111.88,58.63 114.39,56.12 117.94,56.12 118.13,55.93 118.13,55.92 119.17,54.88 119.17,52.57 119.9,51.84 120.14,51.84 120.21,51.91 v2(120.21,52.2)
  BOTTOM w0.109: v2(115.43,101.35) 115.18,101.59 115.18,101.75 RZ530.1
CNV_PTX_C_DRX_N0: length 3.5
  BOTTOM w0.109: JNGFF1.57 126.75,104.11 126.92,103.94 126.92,103.6 126.85,103.53 126.25,103.53 126,103.28 126,102.57 CZ537.2
CNV_PTX_C_DRX_N1: length 3.5
  BOTTOM w0.109: CZ539.2 124.22,102.58 124.22,103.11 124.57,103.45 125,103.45 125.39,103.85 125.39,103.95 125.26,104.09 JNGFF1.51
CNV_PTX_C_DRX_P0: length 3.5
  BOTTOM w0.109: CZ536.2 126.21,102.6 126.21,103.19 126.33,103.31 126.94,103.31 127.14,103.51 127.14,103.95 127.26,104.07 JNGFF1.59
CNV_PTX_C_DRX_P1: length 3.5
  BOTTOM w0.109: CZ538.2 124.44,102.6 124.44,103.02 124.66,103.24 125.09,103.24 125.61,103.76 125.61,103.92 125.75,104.07 JNGFF1.53
CNV_PTX_DRX_N0: length 92.6
  TOP w0.076: 122.99,45.71 123.01,45.71 123.04,45.67 123.55,45.67 123.59,45.72 123.59,45.96 123.67,46.04 123.75,46.04 123.85,45.94 UH1.BE6
  TOP w0.109: 122.99,45.71 122.62,45.71 122.27,46.06 122.27,46.29 120.35,48.21 117.22,48.21 116.95,48.48 116.47,48.48 116.42,48.48 116.32,48.48 v2(116.06,48.73)
  IN4 w0.102: v2(116.06,48.73) 115.84,48.51 115.66,48.51 115.62,48.55 115.62,51.41 115.14,51.89 115.14,52.52 110.81,56.84 109.69,56.84 105.1,61.43 105.1,64.38 105.94,65.21 105.94,68.41 104.06,70.28 104.06,70.53 103.77,70.81 102.69,70.81 102.51,70.99 102.51,71.25 102.69,71.42 103.77,71.42 104.06,71.71 104.06,72.12 103.77,72.41 102.69,72.41 102.51,72.59 102.51,72.84 102.69,73.02 103.77,73.02 104.06,73.31 104.06,73.72 103.77,74 102.73,74 102.55,74.18 102.55,74.44 102.73,74.61 103.77,74.61 104.06,74.9 104.06,75.63 105.31,76.88 105.31,78.34 108.92,81.95 108.92,85.1 109.67,85.85 109.67,86.42 110.86,87.61 110.86,87.73 113,89.87 114.96,89.87 116.37,91.28 116.37,93.91 v2(115.41,94.86)
  BOTTOM w0.109: v2(115.41,94.86) 115.33,94.78 115.33,94.57 115.44,94.46 115.69,94.46 115.92,94.69 115.92,95.39 117.46,96.93 117.46,98.45 118.77,99.76 122.63,99.76 122.77,99.9 123.96,99.9 125.14,101.08 125.89,101.08 125.99,101.18 125.99,101.35 CZ537.1
CNV_PTX_DRX_N1: length 92.8
  TOP w0.109: v2(117.18,48.83) 117.42,49.06 117.47,49.06 118.01,48.53 120.31,48.53 122.56,46.29 122.56,46.07 122.71,45.92 122.91,45.92 122.96,45.97 122.96,46.06 UH1.BG6
  IN4 w0.102: v2(123.16,101.24) 122.94,101.02 122.4,101.02 121.96,100.57 121.55,100.57 118.93,103.19 113.54,103.19 112.53,102.19 112.53,99.67 113.78,98.43 113.78,96.15 114.56,95.37 116.59,95.37 117.06,94.9 117.06,90.77 115.41,89.12 115.41,87.15 108.46,80.2 107.94,80.2 105.75,78.02 105.75,76.64 104.77,75.66 104.77,70.15 106.34,68.58 106.34,65.02 105.51,64.19 105.51,62.72 106.46,61.77 106.46,60.96 110.17,57.25 110.98,57.25 113.67,54.56 116.17,54.56 117.35,53.38 117.35,51.1 116.36,50.11 116.36,49.35 116.68,49.03 116.98,49.03 v2(117.18,48.83)
  BOTTOM w0.109: CZ539.1 124.21,101.36 124.21,101.08 123.96,100.83 123.19,100.83 123.09,100.94 123.09,101.17 v2(123.16,101.24)
CNV_PTX_DRX_P0: length 92.6
  TOP w0.076: UH1.BD7 123.81,45.52 123.04,45.52 123.01,45.49 122.99,45.49
  TOP w0.109: 122.99,45.49 122.53,45.49 122.06,45.97 122.06,46.2 120.26,48 117.13,48 116.86,48.26 116.47,48.26 116.42,48.26 116.31,48.26 v2(116.07,48.01)
  IN4 w0.102: v2(116.07,48.01) 116.07,48.06 115.81,48.32 115.59,48.32 115.43,48.48 115.43,51.33 114.95,51.82 114.95,52.44 110.73,56.66 109.61,56.66 104.91,61.35 104.91,64.46 105.75,65.29 105.75,68.33 103.87,70.21 103.87,70.45 103.7,70.63 102.61,70.63 102.32,70.91 102.32,71.32 102.61,71.61 103.7,71.61 103.87,71.79 103.87,72.04 103.7,72.22 102.61,72.22 102.32,72.51 102.32,72.92 102.61,73.21 103.7,73.21 103.87,73.39 103.87,73.64 103.7,73.82 102.65,73.82 102.36,74.11 102.36,74.51 102.65,74.8 103.7,74.8 103.87,74.98 103.87,75.71 105.12,76.95 105.12,78.42 108.73,82.03 108.73,85.18 109.48,85.93 109.48,86.5 110.67,87.69 110.67,87.8 112.92,90.06 114.88,90.06 116.18,91.35 116.18,93.83 115.83,94.17 115.62,94.17 v2(115.41,93.97)
  BOTTOM w0.109: v2(115.41,93.97) 115.71,94.27 115.81,94.27 116.14,94.6 116.14,95.3 117.68,96.84 117.68,98.36 118.86,99.54 122.72,99.54 122.86,99.68 124.05,99.68 125.23,100.87 125.98,100.87 126.2,101.09 126.2,101.3 CZ536.1
CNV_PTX_DRX_P1: length 92.7
  TOP w0.109: UH1.BF6 123.32,46.13 123.05,46.4 122.77,46.4 122.71,46.45 120.4,48.74 118.1,48.74 117.56,49.28 117.37,49.28 v2(117.22,49.42)
  IN4 w0.102: v2(123.16,100.42) 123.33,100.59 123.33,100.72 123.21,100.83 122.48,100.83 122.03,100.38 121.47,100.38 118.85,103 113.61,103 112.72,102.11 112.72,99.75 113.96,98.51 113.96,96.23 114.64,95.55 116.67,95.55 117.24,94.98 117.24,90.69 115.59,89.04 115.59,87.07 108.54,80.01 108.01,80.01 105.94,77.94 105.94,76.56 104.96,75.58 104.96,70.23 106.53,68.66 106.53,64.94 105.7,64.11 105.7,62.8 106.65,61.85 106.65,61.04 110.25,57.44 111.05,57.44 113.75,54.75 116.25,54.75 117.54,53.45 117.54,51.02 116.55,50.03 116.55,49.43 116.75,49.22 117.02,49.22 v2(117.22,49.42)
  BOTTOM w0.109: CZ538.1 124.42,101.3 124.42,100.99 124.05,100.61 123.36,100.61 v2(123.16,100.42)
CNV_RF_RESET#: length 105.8
  TOP w0.102: 119.94,40.3 119.97,40.34 120.36,40.34 121.5,41.47 123.1,41.47 123.34,41.24 123.82,41.24 123.88,41.29 UH1.BE16
  TOP w0.109: v2(137.1,98.82) 137.1,97.62 137.17,97.55 QZ17.2 v1(139.14,97.55) 139.65,97.55 139.96,97.23 139.96,96.09 139.37,95.49 RZ3.1 ; v2(114.51,38.23) 114.51,39.52 114.81,39.82 116.19,39.82 116.37,40 118.12,40 118.16,39.96 118.3,39.91 119.49,39.91 119.89,40.3 119.94,40.3 RH617.1
  IN1 w0.102: v2(114.83,94.96) 115.15,95.27 115.64,95.27 116.11,94.79 116.11,83.96 114.44,82.29 114.44,76.4 112.86,74.81 112.86,71.08 112.13,70.35 112.13,68.28 112.17,68.23 112.17,67.86 111.03,66.72 111.03,63.37 112.06,62.34 112.06,60.99 112.42,60.64 112.42,52.34 113.85,50.91 113.85,44.95 114.1,44.7 114.1,40.91 114.38,40.63 114.38,38.36 v2(114.51,38.23)
  IN2 w0.081: v2(137.1,98.82) 136.44,98.15 120.41,98.15 117.57,95.31 115.19,95.31 v2(114.83,94.96)
CNV_RF_RESET#_R: length 55.8
  TOP w0.109: QZ17.3 139.15,98.2 v2(139.65,98.69) 140.28,98.06 v1(140.28,95.94) 140.28,95.89 139.3,94.91 RZ3.2 137.3,94.5 136.98,94.19 135.33,94.19 135.09,94.43 RZ378.2
  IN1 w0.102: v2(127.26,120.54) 127.26,118.17 127.39,118.04 127.39,109.56 128.17,108.78 130.54,108.78 130.84,109.07 132.35,109.07 133.11,108.31 133.11,104.04 135.2,101.95 135.2,100.73 136.41,99.52 138.82,99.52 v2(139.65,98.69)
  BOTTOM w0.109: RZ531.2 116.66,117.43 117.74,118.51 120.11,118.51 120.49,118.89 122.26,118.89 122.93,119.56 126.28,119.56 v2(127.26,120.54)
CNV_RGI_PRX_DTX: length 84.1
  TOP w0.109: UH1.AV3 127.53,47.43 127.53,48.2 127.47,48.25 127.47,49.57 126.54,50.5 126.54,51.48 126.44,51.58 RH613.2 126.5,51.81 127.11,51.19 v2(127.25,51.19)
  IN1 w0.102: v2(121.06,117.79) 120.44,117.17 120.44,108.03 116.86,104.44 116.86,103.1 118.6,101.36 118.6,99.66 118.89,99.36 118.89,99.15 121.82,96.23 121.82,95.82 123.12,94.52 123.12,89.43 123.64,88.9 123.64,83.09 123.99,82.74 123.99,79.71 123.04,78.75 123.04,74.99 123.4,74.62 123.4,72.84 124.58,71.67 124.58,71.09 125.97,69.7 125.97,66.1 126.85,65.21 126.85,63.35 128.98,61.22 128.98,57.62 129.18,57.42 129.18,54.47 128.9,54.19 128.9,52.06 128.28,51.44 127.49,51.44 v2(127.25,51.19)
  BOTTOM w0.109: v2(121.06,117.79) 121.04,117.81 120.3,117.81 v1(120.22,117.73) 120.22,117.59 119.73,117.11 119.64,117.11 119.09,116.55 RZ535.2
CNV_RGI_PTX_DRX: length 87.6
  TOP w0.102: v2(125.83,49.77) 126.13,49.47 126.13,47.42 UH1.BA4
  TOP w0.109: v2(125.83,49.77) 124.98,50.62 124.73,50.62 124.36,51 123.27,51 122.97,51.3 122.51,51.3 122.18,51.62 RH605.1 RH606.1
  IN1 w0.102: v2(119.7,117.73) 119.17,117.21 119.17,112.39 117.63,110.85 117.63,107.53 114.83,104.72 114.83,102.9 114.03,102.1 114.03,100.45 115.76,98.72 116.75,98.72 119.28,96.19 119.28,95.15 120.18,94.25 121.45,94.25 121.82,93.88 121.82,88.47 122.43,87.86 122.43,79.83 121.84,79.25 121.84,72.71 123.06,71.5 123.06,69.51 123.49,69.08 123.49,62.34 124.05,61.78 124.05,56.58 125.23,55.4 125.23,54.48 125.55,54.16 125.55,50.05 v2(125.83,49.77)
  BOTTOM w0.109: v2(119.7,117.73) 118.9,117.73 v1(118.77,117.6) 118.77,117.07 RZ534.2
CNV_WT_RCOMP: length 8.4
  TOP w0.109: 122.87,51.02 123.09,50.8 124.28,50.8 125.89,49.19 UH1.BA1 ; RH612.2 121.45,51.75 120.9,52.3 v1(120.9,53.62)
  TOP w0.152: 122.87,51.02 122.01,51.02 121.49,51.54 RH612.2
COMP_1PH: length 6.5
  TOP w0.109: v1(310.7,45.53) 310.7,45.68 309.9,46.48 PC1108.2
  TOP w0.203: PU1100.50 306.77,44.15 307.92,45.3 307.92,45.98 308.41,46.47 PC1107.2 309.79,46.47 PC1108.2
COMP_2PH: length 4.6
  TOP w0.203: 303.38,37.7 303.15,37.94 v1(303.15,38.17) PU1100.33
  TOP w0.254: PC1119.2 303.34,35.89 PC1117.2 303.38,37.7
COMP_4PH: length 3.4
  TOP w0.203: PU1100.6 v1(303.55,46.74) 303.55,46.83 304.14,47.42 PR1133.1 PC1113.1
CONTACTLESS_DET#: length 305.9
  TOP w0.102: 122.16,45.24 122.37,45.03 UH1.BG8
  TOP w0.109: v2(121.14,46.3) 121.14,46.26 122.16,45.24 ; v1(341.15,45.03) RH90.2 340.83,46.33 v2(340.52,46.33) 340.14,46.33 DZ8.2
  IN3 w0.081: v2(310.8,4.57) 310.47,4.24 308.76,4.24 308.21,3.7 306.48,3.7 305.87,3.09 303.18,3.09 301.61,1.52 276.97,1.52 273.98,4.51 268.47,4.51 265.31,7.67 256.13,7.67 254.61,9.19 246.55,9.19 241.88,4.52 168.16,4.52 167.13,5.56 158.52,5.56 154.78,9.3 149.59,9.3 148.08,10.81 141.54,10.81 140.69,11.66 133.87,11.66 133.27,12.26 130.82,12.26 129.92,13.16 129.07,13.16 128.56,13.67 124.24,13.67 119.44,18.46 119.44,21.2 119.54,21.3 119.54,24.54 120.25,25.25 120.25,28.11 120.7,28.56 120.7,31.14 119.92,31.92 119.92,34.86 120.13,35.06 120.13,36.73 120.41,37.01 120.41,44.35 121.01,44.96 121.01,45.99 v2(121.14,46.3)
  BOTTOM w0.109: v2(310.8,4.57) 318.82,4.57 321,6.75 321,7.12 324.83,10.95 336.88,10.95 343.65,17.72 343.65,42.21 340.89,44.97 340.89,45.96 v2(340.52,46.33)
CONTACTLESS_DET#_R: length 4
  TOP w0.109: DZ8.1 337.61,46.01 v1(337,46.62) 336.85,46.78 336.85,47.56 336.37,48.05 JUSH1.4
CORE_SW1: length 2
  TOP w0.109: 286.25,54.43 v1(286.25,53.37)
  BOTTOM w0.508: v2(285.06,54.46) 284.4,54.46 PC1216.1
CORE_SW2: length 1.5
  BOTTOM w0.109: v2(283.28,43.96) v1(282.66,43.96)
  BOTTOM w0.508: v2(283.28,43.96) 283.41,43.83 PC1226.1
CORE_SW3: length 1.6
  BOTTOM w0.109: v2(282.9,34.94) v1(282.23,34.94)
  BOTTOM w0.508: PC1236.1 v2(282.9,34.94)
CORE_SW4: length 1.8
  BOTTOM w0.109: v2(283.08,23.19) v1(282.37,23.19)
  BOTTOM w0.508: PC1246.1 v2(283.08,23.19)
CPU_2_PCH_TRIGGER: length 185.5
  TOP w0.109: UH1.AK2 131.57,47.92 131.57,51.35 131.67,51.45 v2(131.67,51.65)
  IN2 w0.081: v2(265.11,66.18) 265.11,66.45 264.36,67.19 264.36,70.39 263.83,70.93 262.86,70.93 257.6,76.18 257.6,77.55 v2(258.05,78)
  VCC w0.086: v2(258.05,78) 256.18,78 254.2,76.02 239.55,76.02 238.17,77.4 232.85,77.4 229.84,80.41 221.91,80.41 215.59,86.73 197.52,86.73 196.75,87.5 180.98,87.5 179.5,88.98 178.77,88.98 178.22,89.53 175.21,89.53 174.28,88.6 168.48,88.6 164.5,84.62 164.5,76.65 163.93,76.07 163.93,73.73 164.56,73.09 164.56,71.01 162.7,69.14 162.7,67.19 161.94,66.43 161.94,65.74 161.46,65.27 v2(160.91,65.27)
  IN3 w0.081: v2(131.67,51.65) 131.86,51.65 132.42,52.21 133.14,52.21 133.55,51.81 133.98,51.81 136.13,53.95 139.24,53.95 139.65,53.54 141.43,53.54 143.38,55.49 144.26,55.49 146.16,57.38 147.71,57.38 148.66,58.33 150.38,58.33 154.14,62.09 156.91,62.09 159.45,64.63 160.28,64.63 v2(160.91,65.27)
  BOTTOM w0.109: v2(265.11,66.18) 265.5,66.18 266.77,67.45 v1(266.77,67.45) 266.86,67.55 269.31,67.55 269.35,67.58 270.37,67.58 RC177.1
CPU_2_PCH_TRIGGER_R: length 29.3
  TOP w0.109: UC1.J23 247.47,61.99 247.91,61.55 249.37,61.55 v2(249.5,61.67)
  BOTTOM w0.109: v2(249.5,61.67) 249.82,61.99 249.82,62.6 250.23,63.01 252.42,63.01 252.59,63.17 253.45,63.17 253.63,62.99 256.48,62.99 257.58,64.09 260.36,64.09 260.98,64.71 261.47,64.71 262,65.24 262,65.53 262.29,65.83 262.58,65.83 262.71,65.7 264.02,65.7 264.63,65.09 265.28,65.09 267.32,67.13 269.74,67.13 v1(269.77,67.17) 270.87,67.17 RC177.2
CPU_24MHZ_R_D: length 157.6
  TOP w0.102: v2(253.38,65.68) 253.71,65.35 UC1.E31 ; v2(153.44,53.66) 153.2,53.9 152.86,53.9 149.72,57.04 146.87,57.04 146.04,56.2 146.04,54.33 146.21,54.16 146.21,53.97 RH169.1
  IN4 w0.102: v2(153.44,53.66) 153.73,53.95 154.45,53.95 155,53.39 157.45,53.39 160.22,56.16 160.22,58.14 161.52,59.43 161.52,61.39 163.65,63.51 163.65,69.47 167.36,73.18 167.36,84.56 169.38,86.57 171.61,86.57 174.95,89.92 184.93,89.92 185.22,89.62 192.3,89.62 192.7,90.02 195.74,90.02 196.04,90.33 218.44,90.33 222.5,86.27 225.5,86.27 226.79,84.98 231.03,84.98 241.96,74.05 253.13,74.05 254.29,72.88 254.29,69.72 253.68,69.11 252.95,69.11 252.59,68.76 252.59,66.29 252.95,65.93 253.13,65.93 v2(253.38,65.68)
CPU_24MHZ_R_D#: length 157.9
  TOP w0.102: v2(153.44,54.38) 153.16,54.09 152.94,54.09 149.8,57.23 146.79,57.23 145.84,56.28 145.84,54.25 146.02,54.08 146.02,53.99 RH170.1 ; v2(253.38,66.33) 253.71,66 UC1.D31
  IN4 w0.102: v2(153.44,54.38) 153.69,54.13 154.52,54.13 155.08,53.58 157.37,53.58 160.03,56.24 160.03,58.21 161.33,59.51 161.33,61.46 163.46,63.59 163.46,69.54 167.17,73.26 167.17,84.64 169.3,86.76 171.53,86.76 174.88,90.11 185,90.11 185.3,89.81 192.23,89.81 192.62,90.21 195.66,90.21 195.96,90.51 218.52,90.51 222.58,86.46 225.58,86.46 226.87,85.17 231.11,85.17 242.04,74.23 253.2,74.23 254.48,72.96 254.48,69.64 253.76,68.93 253.03,68.93 252.78,68.68 252.78,66.37 253.03,66.12 253.17,66.12 v2(253.38,66.33)
CPU_C10_GATE#: length 248.7
  TOP w0.109: RH616.1 125.07,53.56 v1(126.32,54.82) 126.76,55.26 128.18,55.26 128.35,55.09 129.38,55.09 v2(129.6,54.87) ; UZ61.2 278.84,73.76 RC562.1 279.27,73.76 RZ543.1 279.5,74 v2(278.04,75.47) ; RH446.2 124.97,61.2 v2(125.04,61.13)
  TOP w0.254: PR309.1 308.06,62.91 308.28,63.12 308.95,63.12 v2(311.05,65.22)
  VCC w0.086: v2(278.04,75.47) 278.04,75.68 277.75,75.97 271.08,75.97 266.72,71.61 261.54,71.61 257.54,75.61 256.58,75.61 255.02,74.05 238.66,74.05 237.95,74.75 233.77,74.75 231.74,72.72 223.17,72.72 212.07,83.82 196.41,83.82 195.34,84.89 183.47,84.89 182.77,84.18 180.5,84.18 178.88,85.8 171.84,85.8 168.39,82.36 168.39,78.58 167.22,77.41 167.22,67.72 165.66,66.16 v2(165.38,66.16)
  IN3 w0.081: v2(159.67,65.03) 159.53,65.03 156.82,62.32 153.97,62.32 150.71,59.05 148.88,59.05 148.5,59.44 147.15,59.44 145,57.29 143.92,57.29 141.44,54.81 138.76,54.81 138.55,55.02 136.1,55.02 135.4,54.32 131.9,54.32 131.36,54.87 v2(129.6,54.87) ; v2(311.05,65.22) 311.22,65.39 311.22,68.25 310.44,69.03 308.82,69.03 306.25,71.6 306.25,72.89 305.85,73.29 305.05,73.29 303.9,74.44 302.37,74.44 301.83,74.97 286.91,74.97 286.07,74.13 279.37,74.13 v2(278.04,75.47)
  IN4 w0.102: v2(129.6,54.87) 128.72,55.74 128.72,60.01 127.19,61.55 125.46,61.55 v2(125.04,61.13)
  BOTTOM w0.109: v2(159.67,65.03) 160.23,64.47 160.6,64.47 160.79,64.66 162.95,64.66 164.45,66.16 v2(165.38,66.16)
