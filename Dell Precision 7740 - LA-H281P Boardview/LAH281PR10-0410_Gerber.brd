# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
ME_FWP_PCH: length 98.2
  TOP w0.109: RH328.1 116.39,42.95 115.92,42.95 v2(115.41,42.45)
  IN3 w0.081: v2(159.97,81.1) 157.93,81.1 157.55,80.72 155.38,80.72 152.02,77.36 152.02,72.51 150.95,71.43 150.95,69.45 149.85,68.35 149.85,68.07 148.98,67.21 147.62,67.21 147.47,67.05 147.47,65.22 146.96,64.72 146.16,64.72 144.73,63.29 144.73,62.49 143.28,61.04 142.37,61.04 141.56,60.23 137.91,60.23 137.32,59.64 137.32,58.48 136.35,57.51 133.46,57.51 132.95,57 125.31,57 124.82,56.51 122.59,56.51 119.12,53.05 119.01,52.93 119.01,49.92 116.6,47.51 114.34,47.51 113.92,47.1 113.92,44.7 114.79,43.82 114.79,43.06 v2(115.41,42.45)
  IN4 w0.102: v2(169.87,94.91) 169.87,92.6 167.56,90.29 167.56,87.91 160.75,81.1 v2(159.97,81.1)
  BOTTOM w0.109: RH100.2 v2(169.87,94.91) 170,95.04 SW1.3 ; v2(115.41,42.45) v1(115.41,42.97)
ME_RESET#: length 2.8
  TOP w0.109: v1(123.47,58.92) RH70.1 121.99,58.38 121.97,58.38 121.46,57.87 UC3.2
ME_SUS_PWR_ACK_R: length 12.7
  TOP w0.089: UH1.BC37 124.76,30.83 123.97,30.83 123.84,30.7 123.27,30.7 123.16,30.58 123.16,30.57 122.97,30.38 122.69,30.38 122.69,30.39 121.69,30.39 121.42,30.11
  TOP w0.102: T319.1 113.26,29.44 117.94,29.44 118.12,29.62 120.34,29.62 120.83,30.11 121.42,30.11
MEC_XTAL1: length 5.9
  TOP w0.109: UE1.A1 133.28,79.69 133.37,79.79 133.37,80.86 132.84,81.4 132.84,82.25 CE28.1 132.53,82.97 131.72,83.79 YE1.1
MEC_XTAL2: length 2.9
  TOP w0.109: RE290.2 CE29.1 133.4,82.94 134.22,83.76 YE1.2
MEC_XTAL2_R: length 2.6
  TOP w0.109: UE1.A3 134.44,79.87 134.62,80.05 134.62,81.36 RE290.1
MEDIACARD_IRQ#: length 130.9
  TOP w0.109: v2(125.74,36.6) 125.34,36.19 UH1.BB26
  IN2 w0.081: v2(125.74,36.6) 125.72,36.57 125.72,36.54 125.5,36.31 124.65,36.31 123.99,36.97 121.09,36.97 120.79,37.28 117.39,37.28 117.04,37.63 114.77,37.63 114.13,36.99 114.13,35.82 113.6,35.29 111.77,35.29 111.1,34.63 111.1,33.48 110.7,33.08 109.77,33.08 107.43,30.74 105.7,30.74 105.2,31.25 103.64,31.25 102.7,30.31 101.11,30.31 99.92,29.12 98.52,29.12 97.05,27.65 97.05,26.75 96.04,25.75 94.3,25.75 93.43,24.88 89.98,24.88 88.29,23.19 87.58,23.19 86.06,21.67 84.88,21.67 83.03,19.83 80.13,19.83 76.59,16.28 69.12,16.28 66.82,13.99 60.76,13.99 58.76,15.99 58.06,15.99 57.58,16.48 56.73,16.48 55.85,17.35 52.92,17.35 52.46,16.89 48.82,16.89 47.62,18.09 45.75,18.09 44.95,17.29 42.77,17.29 42.29,17.77 v2(40.78,17.77)
  IN3 w0.081: v2(23.29,23.13) 23.34,23.08 24.41,23.08 24.76,22.72 29.58,22.72 30.55,21.75 30.55,20.15 31.44,19.26 31.44,18.41 32.09,17.77 v2(40.78,17.77)
  BOTTOM w0.109: v1(40.26,18.81) 40.26,18.11 40.6,17.77 v2(40.78,17.77) ; RR211.2 23.69,23.53 v2(23.29,23.13) 23.09,22.93 23.09,21.18 22.03,20.12 22.03,20.02 21.69,19.67 19.86,19.67 19.7,19.51 UR1.48
MEM_INTERLEAVED: length 9.2
  TOP w0.109: v2(125.85,39.92) 126.05,39.72 UH1.BA20
  BOTTOM w0.109: RH371.1 RH372.1 120.17,38.13 120.35,38.31 122.78,38.31 123.98,39.51 123.98,40.23 124.2,40.45 125.09,40.45 125.48,40.29 v2(125.85,39.92)
MEM_SMBCLK: length 31.8
  TOP w0.089: 120.93,35.76 121.11,35.94 122.11,35.94 122.31,36.14 123.28,36.14 123.45,35.97 123.73,35.97 123.8,36.04 UH1.BE26
  TOP w0.109: QH4.6 107.17,22.67 106.75,23.09 106.59,23.09 CC320.1 106.58,24.02 v2(107.25,24.02) ; 120.93,35.76 120.72,35.55 120.72,35.17 120.26,34.71 117.66,34.71 117.55,34.6 116.22,34.6 115.87,34.96 114.92,34.96 RH56.2 114.94,35.31 114.94,35.46 114.53,35.88 113.59,35.88 v2(113.42,35.71)
  IN3 w0.081: v2(107.25,24.02) 107.26,24.02 108.07,24.82 108.07,25.27 109.95,27.15 109.95,27.84 111.2,29.09 111.2,29.09 111.47,29.36 112.32,29.36 112.73,29.76 112.73,30.62 113.83,31.72 113.83,35.85 113.8,35.87 113.58,35.87 v2(113.42,35.71)
MEM_SMBDATA: length 30.4
  TOP w0.089: UH1.BF26 123.6,36.2 123.48,36.2 123.36,36.32 122.24,36.32 122.04,36.12 121.03,36.12 120.86,35.95 120.85,35.95 120.84,35.94 120.77,35.94 120.76,35.93
  TOP w0.109: 120.76,35.93 120.48,35.65 120.48,35.27 120.17,34.95 117.56,34.95 117.45,34.84 116.32,34.84 115.97,35.19 115.55,35.19 114.63,36.11 113.61,36.11 v2(113.42,36.31) ; v2(109.41,25.21) 110.07,25.21 RH57.2 110.12,23.97 QH4.3
  IN3 w0.081: v2(109.41,25.21) 109.41,25.2 109.03,24.82 108.44,24.82 108.3,24.96 108.3,25.18 110.18,27.06 110.18,27.75 111.3,28.87 111.3,28.87 111.56,29.13 112.42,29.13 112.95,29.67 112.95,30.52 114.06,31.63 114.06,35.94 113.9,36.1 113.63,36.1 v2(113.42,36.31)
MID1_CA_DET: length 4
  TOP w0.109: v1(53.83,50.95) 53.83,51.11 52.6,52.34 RV895.1 52.07,52.34 51.94,52.47 v2(51.92,52.47)
  BOTTOM w0.109: UV66.52 51.97,52.52 v2(51.92,52.47)
MID2_CA_DET: length 3.5
  TOP w0.109: v2(73.43,54.4) 73.47,54.35 UV67.52
  BOTTOM w0.109: RV896.2 73.43,54.75 v2(73.43,54.4)
MISO: length 12.9
  IN2 w0.081: v2(20.5,11.88) 20.5,11.84 20,11.34 20,5.79 19.45,5.25 v2(19.45,4.22)
  BOTTOM w0.109: UR1.14 19.3,12.49 19.44,12.35 20.24,12.35 20.5,12.09 v2(20.5,11.88) ; v2(19.45,4.22) 19.95,4.71 UR3.2
MOD_ID1: length 6.6
  BOTTOM w0.109: v1(25.73,40.02) RT534.2 25.73,38.47 RT536.1 25.52,38.14 25.09,37.71 24.53,37.71 24.23,37.4 23.55,37.4 23.38,37.23 23.38,37.04 22.04,35.7 UT5.L10
MOD_ID2: length 3.6
  BOTTOM w0.102: RT537.1 18.51,38.17 19,37.68 19,35.71 UT5.L4
  BOTTOM w0.109: RT537.1 RT535.2
MODE_IO: length 0.6
  BOTTOM w0.109: v2(307.1,60) v1(307.1,59.37)
MOSI: length 18.8
  IN2 w0.081: v2(19.87,11.94) 18.97,11.94 16.96,9.93 16.96,8.79 15.34,7.17 15.34,4.49 16.03,3.8 16.41,3.8 v2(16.76,4.16)
  BOTTOM w0.109: v2(16.76,4.16) 16.76,2.73 16.2,2.17 UR3.5 13.74,2.17 v1(13.23,2.68) ; v2(19.87,11.94) 19.46,11.94 18.9,12.5 UR1.15
MSCLK: length 55.9
  TOP w0.109: UE1.H10 v2(140.41,73.28)
  IN3 w0.081: v2(140.41,73.28) 140,72.86 140,72.3 139.77,72.07 139.39,72.07 139.22,71.9 139.22,69.97 139.46,69.73 139.46,68.21 139.24,68 139.24,67.41 138.5,66.67 138.5,65.57 137.94,65.01 134.6,65.01 133.31,63.72 130.14,63.72 129.91,63.49 127.04,63.49 126.53,64.01 122.25,64.01 121.68,63.43 120.94,63.43 120.9,63.4 120.9,62.93 120.98,62.85 v2(121.09,62.85) 120.9,62.66 120.9,61.86 118.6,59.56 116.63,59.56 115.87,58.8 115.87,58.38 115.95,58.31 116.16,58.31 v2(116.42,58.56)
  BOTTOM w0.109: RE30.2 118.21,53.8 119.11,54.7 119.11,55.08 122.44,58.41 122.44,59.94 120.88,61.5 120.88,62.64 v2(121.09,62.85) ; JDEG1.6 113.07,55.81 113.2,55.68 113.49,55.68 113.57,55.75 113.57,56.59 115.14,58.17 115.74,58.17 115.89,58.32 116.18,58.32 v2(116.42,58.56) 116.65,58.33 116.79,58.33 RE72.2
MSDATA: length 46.1
  TOP w0.109: UE1.G9 v2(139.61,74.08)
  IN3 w0.081: v2(116.42,57.85) 116.19,58.08 115.85,58.08 115.64,58.29 115.64,58.87 116.55,59.77 118.52,59.77 120.69,61.94 120.69,63.48 120.85,63.64 121.59,63.64 122.19,64.24 126.62,64.24 127.14,63.72 129.81,63.72 130.04,63.95 133.22,63.95 134.51,65.24 137.84,65.24 138.27,65.67 138.27,66.76 139.03,67.53 139.03,68.08 139.25,68.3 139.25,69.64 139.06,69.82 138.44,70.44 138.44,71.91 138.61,72.07 139.06,72.07 139.24,72.25 139.24,73.71 v2(139.61,74.08)
  BOTTOM w0.109: RE86.1 RE75.2 116.87,58.1 116.67,58.1 v2(116.42,57.85) 116.18,58.08 115.99,58.08 115.84,57.93 115.24,57.93 113.8,56.5 113.8,55.65 113.59,55.44 113.2,55.44 113.07,55.31 JDEG1.7
MUX1_CFG0: length 5.3
  BOTTOM w0.109: UV66.28 56,44.08 v1(55.45,43.53) 54.96,43.04 54.96,42.68 RV876.1 54.31,42.04 54.31,40.85 54.43,40.73 RV879.1
MUX1_CFG1: length 5.3
  BOTTOM w0.109: UV66.27 56.4,43.64 55.57,42.81 RV856.1 56.06,42.03 56.06,40.58 RV878.1
MUX1_CFG2: length 5
  BOTTOM w0.109: RV877.1 56.31,40.5 56.31,41.98 RV857.1 v1(56.84,43.48) 56.8,43.53 UV66.26
MUX1_CFG3: length 5.5
  BOTTOM w0.109: RV848.1 58.6,40.83 v1(58.6,40.97) 58.6,41.65 RV858.1 57.2,43.04 UV66.25
MUX1_CFG4: length 4.4
  TOP w0.109: RV891.1 v1(52.54,50.85) 52.73,50.66 52.73,49.83 RV892.1 52.36,49.8 v2(52.04,50.12)
  BOTTOM w0.109: UV66.46 v2(52.04,50.12)
MUX1_IN1_EQ0: length 6.3
  BOTTOM w0.109: RV852.1 49.49,44.71 49.87,45.08 50.93,45.08 RV881.1 51.64,45.61 51.89,45.87 51.89,46.74 52.87,47.72 UV66.40
MUX1_IN1_EQ1: length 6.4
  BOTTOM w0.109: RV850.1 48.89,45.79 49.4,45.79 50.04,46.42 50.04,46.67 50.24,46.88 50.95,46.88 RV882.1 51.64,46.55 51.64,46.99 v1(52.05,47.4) 52.76,48.12 UV66.41
MUX1_IN2_EQ0: length 7.7
  BOTTOM w0.109: UV66.38 52.77,46.92 52.37,46.52 52.37,44.18 51.76,43.58 RV883.1 50.88,43 v1(49.62,43) 49.02,43 RV853.1
MUX1_IN2_EQ1: length 7.6
  BOTTOM w0.109: RV851.1 48.94,43.69 v1(49.63,44.39) 50.04,44.8 51,44.8 RV880.1 51.78,44.34 52.13,44.68 52.13,46.64 52.81,47.32 UV66.39
MUX2_CFG0: length 4.4
  TOP w0.109: RV871.1 84.78,51.07 84.29,51.56 83.25,51.56 82.8,51.12 RV887.1 82.22,50.49 UV67.28
MUX2_CFG1: length 4.1
  TOP w0.109: RV872.1 84.73,49.7 83.28,49.7 RV888.1 82.24,50.18 82.15,50.09 UV67.27
MUX2_CFG2: length 4.6
  TOP w0.109: RV873.1 84.58,48.66 83,48.66 82.8,48.86 RV886.1 82.28,49.69 UV67.26
MUX2_CFG3: length 6.2
  TOP w0.109: UV67.25 82.13,49.29 82.24,49.18 82.24,48.71 RV885.1 82.8,47.75 82.94,47.61 84.55,47.61 RV874.1 85.23,48.01 v1(85.23,47.18)
MUX2_CFG4: length 10.1
  TOP w0.109: UV67.46 75.87,54.4 v2(75.89,54.42)
  BOTTOM w0.109: RV893.1 70.12,58.15 v1(69.73,58.54)
  BOTTOM w0.508: RV893.1 RV894.1 70.85,57.15 71.16,56.84 74.32,56.84 75.89,55.26 v2(75.89,54.42)
MUX2_IN1_EQ0: length 7.7
  TOP w0.109: UV67.40 78.27,54.08 v1(78.59,54.4) 79.78,55.59 80.62,55.59 RV875.1 81.99,56.96 81.99,58.23 RV864.1
MUX2_IN1_EQ1: length 8.3
  TOP w0.109: UV67.41 77.87,54.24 80.08,56.45 RV868.1 80.97,56.96 80.97,58.23 RV865.1 v1(79.41,58.74)
MUX2_IN2_EQ0: length 8.8
  TOP w0.109: RV866.1 84.02,58.23 84.02,56.96 RV863.1 82.95,55.89 82.5,55.89 v1(81.8,55.2) 81.1,54.5 79.7,54.5 79.07,53.87 UV67.38
MUX2_IN2_EQ1: length 8.3
  TOP w0.109: UV67.39 78.67,53.98 79.58,54.88 v1(80.1,54.88) 80.92,54.88 RV884.1 83,56.96 83,58.23 RV867.1
NB_MUTE#: length 322.1
  TOP w0.109: RA48.1 374.14,27.58 DA8.1 373.75,27.75 373.25,27.26 373.25,26.76 v1(373.16,26.66) 372.89,26.4 372.89,24.4 v2(373.21,24.08) ; UE1.A4 v2(134.85,79.64)
  IN2 w0.081: v2(134.85,79.64) 135.34,79.64 135.8,79.18 137.09,79.18 137.11,79.2 140.66,79.2 141.01,79.54 141.53,79.54 142.03,79.03 142.03,78.63 142.87,77.79 144.14,77.79 145.13,76.8 145.13,70.63 146.23,69.53 147.96,69.53 148.29,69.86 151.08,69.86 152.14,70.93 152.96,70.93 154.2,69.69 154.2,68.86 157.08,65.98 157.08,61.04 158.39,59.73 159.25,59.73 163.68,55.3 163.68,54.35 164.32,53.71 165.91,53.71 167.64,51.98 167.64,51.13 v2(167.45,50.95)
  IN3 w0.081: v2(167.45,50.95) 167.45,49.9 166.97,49.42 166.97,48.89 166.42,48.34 166.42,47.49 166.84,47.07 166.84,41.95 167.35,41.45 167.35,39.85 168.09,39.1 168.09,26.52 167.55,25.97 167.55,23.65 168.54,22.66 168.54,17.06 171.85,13.75 174.1,13.75 175.49,12.36 199.79,12.36 200.95,13.51 228.77,13.51 233.07,17.81 237.82,17.81 238.69,18.68 239.9,18.68 240.92,19.7 241.4,19.7 242.51,20.8 259.17,20.8 262.42,17.55 266.75,17.55 271.66,12.64 278.22,12.64 279.26,11.6 297.3,11.6 298.4,12.69 308.71,12.69 309.34,13.32 314.64,13.32 321.89,20.58 327.39,20.58 327.92,20.05 330.45,20.05 330.95,20.55 333.02,20.55 334.31,19.26 334.31,18.96 334.8,18.48 338.21,18.48 338.69,18.96 340.1,18.96 340.71,18.35 340.95,18.35 342.48,16.83 343.62,16.83 344.79,18 346.16,18 346.77,18.61 350.7,18.61 351.59,17.73 355.75,17.73 356.31,18.29 361.43,18.29 362.16,19.03 370.15,19.03 371.68,20.55 371.68,20.94 371.95,21.21 371.95,22.13 372.13,22.31 372.58,22.31 372.8,22.52 372.8,23.67 v2(373.21,24.08)
NB_PSID: length 44.2
  BOTTOM w0.254: PL4.2 87.88,27.61 87.42,28.07 PD3.3 PD3.2 83.86,30.24 82.21,30.24 82,30.03 77.1,30.03 77.03,30.1 76.34,30.1 74.27,32.17 v1(74.27,38.84) 74.27,40.43 74.77,40.93 78.03,40.93 79.16,42.07 81.92,42.07 83.1,43.25 84.54,43.25 86.55,45.26 PJPDC1.2
Net_817: length 1
  TOP w0.109: v2(129.33,30.24) 129.33,30.29 129.86,30.82 129.86,31.05
Net_2912: length 0.5
  TOP w0.109: v2(140.42,46.03) 139.87,46.03
NGFF_CONFIG_0: length 52.2
  TOP w0.109: UE1.N9 139.55,69.34 139.55,68.57 140.12,68 140.12,66.15 v2(140.28,65.99) 140.35,65.93 RE734.1
  IN1 w0.102: v2(150.01,100.95) 150.31,100.64 150.31,96.9 148.73,95.32 148.73,81.62 145.83,78.72 145.83,73.42 145.06,72.65 145.06,68.12 142.93,65.99 140.28,65.99 140.28,65.99 v2(140.28,65.99)
  BOTTOM w0.109: v2(150.01,100.95) 150.7,101.64 v1(150.7,101.83) 150.77,101.91 150.77,105.22 150.24,105.75 JNGFF2.13
NGFF_CONFIG_1: length 65.1
  TOP w0.109: UE1.M10 v2(140.41,70.08) 140.46,70.03 140.46,69.47 141.21,68.72 141.21,67.92 141.58,67.55 141.58,65.6 RE732.1 ; v2(161.57,109.64) v1(161.57,110.28)
  IN1 w0.102: v2(140.41,70.08) 140.83,70.49 140.83,78.23 140.79,78.27 140.79,81.08 141.93,82.22 141.93,89.11 145.64,92.81 145.64,94.04 145.53,94.15 145.53,95.53 145.53,95.53 145.53,96.06 145.53,96.06 145.53,97.66 145.77,97.9 145.77,100.01 146.68,100.92 146.68,102.76 146.34,103.1 v2(146.3,103.1)
  IN2 w0.081: v2(161.57,109.64) 159.97,108.05 153.93,108.05 152.52,106.64 147.47,106.64 146.3,105.48 146.3,104.36 145.9,103.95 145.9,103.55 146.3,103.14 v2(146.3,103.1)
  BOTTOM w0.109: v2(161.57,109.64) 161.57,108.4 162.24,107.72 JNGFF2.61
NGFF_CONFIG_2: length 67.5
  TOP w0.109: UE1.N10 140.04,68.87 v2(140.6,68.31) 140.6,68.2 141.3,67.5 141.3,66.94 141.11,66.75 RE733.1 ; v2(163.42,109.67) v1(163.42,110.21)
  IN1 w0.102: v2(146.3,103.77) 146.91,103.16 146.91,100.83 146,99.91 146,97.81 145.76,97.57 145.76,96.16 145.76,96.16 145.76,95.44 145.76,95.44 145.76,94.25 145.87,94.13 145.87,92.17 142.82,89.12 142.82,86.58 143.53,85.87 143.53,82.7 141.61,80.78 141.61,69.95 140.6,68.94 v2(140.6,68.31)
  IN2 w0.081: v2(163.42,109.67) 161.3,107.54 154.03,107.54 152.68,106.19 147.6,106.19 146.73,105.32 146.73,104.46 146.3,104.03 v2(146.3,103.77)
  BOTTOM w0.109: v2(163.42,109.67) 163.74,109.35 JNGFF2.67
NGFF_CONFIG_3: length 53.5
  TOP w0.109: RE735.1 139.58,66.44 139.65,66.5 v2(139.65,67.71) ; UE1.F4 v2(134.87,75.62)
  IN1 w0.102: v2(139.65,67.71) 139.28,67.34 138.25,67.34 138,67.59 138,69.03 137.13,69.89 137.13,70.44 136.88,70.69 136.88,72.64 136.63,72.88 135.44,72.88 135.28,73.04 135.28,73.09 135.27,73.1 135.27,73.46 135.28,73.46 135.28,74.38 134.87,74.79 v2(134.87,75.62) 134.47,76.02 134.47,76.54 134.22,76.79 133.96,76.79 133.67,77.09 133.67,79.35 134.86,80.54 134.86,81.23 134.47,81.63 134.47,87.84 138.28,91.65 138.28,93.28 143.94,98.95 143.94,105.29 v2(143.79,105.45)
  BOTTOM w0.109: JNGFF2.1 145.24,105.98 144.71,105.45 v2(143.79,105.45) ; v2(139.65,67.71) v1(140.16,67.19)
NRB_BIT: length 4.8
  TOP w0.102: UH1.BE30 123.54,34.36 123.4,34.22 123.23,34.22 122.86,33.85 122.14,33.85 121.11,32.82 v1(120.85,32.82)
  TOP w0.109: v1(120.85,32.82) 120.81,32.78 RH331.2
OUT1_CA_DET: length 8.5
  TOP w0.109: RV130.2 300.41,88.23 299.31,88.23 298.36,87.28 298.36,86.44 297.8,85.88 v1(297.8,85.64) 297.8,84.05 298.17,83.69 UV8.43
PANEL_BKEN_EC: length 91.3
  TOP w0.109: UE1.J9 v2(139.61,72.48) ; v2(165.17,130.82) 165.46,131.11 DV37.2
  IN1 w0.102: v2(145.52,130.32) 145.46,130.26 145.46,122.06 145.87,121.66 145.87,119.13 144.09,117.35 144.01,117.35 142.9,116.24 142.9,111.91 144,110.81 144,107.25 146.28,104.97 146.28,104.45 145.87,104.04 145.87,102.15 145.57,101.84 145.57,101.57 146.02,101.12 146.02,100.65 145.54,100.16 145.54,98 145.3,97.76 145.3,95.97 145.3,95.97 145.3,95.63 145.3,95.63 145.3,95.56 143.52,93.78 143.52,91.22 141.7,89.4 141.7,83.82 140.77,82.89 140.77,81.76 138.43,79.42 138.43,75.36 138.84,74.94 139.71,74.94 139.98,74.68 139.98,72.85 v2(139.61,72.48)
  IN2 w0.081: v2(165.17,130.82) 160.17,125.82 156.38,125.82 152.14,130.06 145.77,130.06 v2(145.52,130.32)
  BOTTOM w0.109: v2(165.17,130.82) v1(165.17,131.35)
PANEL_BKEN_PCH: length 193.7
  TOP w0.102: v2(127.86,27.42) 127.86,27.24 127.54,26.92
  TOP w0.109: v2(167.08,130.19) 167.08,130.46 DV35.2 ; UH1.AV46 127.54,26.92
  IN1 w0.102: v2(127.86,27.42) 127.9,27.46 127.9,29.5 127.31,30.09 123.56,30.09 121.89,31.76 121.89,36.18 122.18,36.47 122.18,37.54 120.89,38.83 120.89,45.62 121.08,45.81 121.28,45.81 121.51,46.04 121.51,46.99 121.24,47.27 121.24,51.91 120.83,52.32 120.83,54.93 120.44,55.31 120.44,57.27 119.61,58.11 119.61,62.14 119.52,62.22 119.52,63.96 118.3,65.18 118.3,68.28 119.18,69.16 119.18,70.97 118.8,71.36 118.8,72.43 118.23,72.99 118.23,73.37 117.8,73.8 117.8,75.4 117.53,75.67 117.53,78.28 118.34,79.09 118.34,81.64 118.69,81.99 118.69,84.07 117.26,85.5 117.26,96.92 116.37,97.8 115.38,97.8 112.07,101.11 112.07,105.83 112.61,106.36 113.67,106.36 114.41,107.1 114.41,114.49 116.51,116.59 116.51,118.16 117.31,118.96 117.31,120.64 120.5,123.83 120.5,133.77 123.42,136.69 123.42,144.9 123.9,145.38 125.22,145.38 130.29,140.31 133.59,140.31 137.36,136.54 v2(137.36,132.73)
  IN2 w0.081: v2(167.08,130.19) 164.97,130.19 160.32,125.54 156.21,125.54 151.94,129.81 140.28,129.81 v2(137.36,132.73)
  BOTTOM w0.109: v2(167.08,130.19) v1(167.08,130.8)
PANEL_MONITOR: length 89
  TOP w0.109: UE1.M8 138.44,70.49 v2(138.82,70.87)
  IN1 w0.102: v2(143.83,135.46) 144.33,134.96 144.33,122.87 145.16,122.04 145.16,120.48 144.82,120.14 144.82,118.48 142.56,116.23 142.56,111.67 143.77,110.46 143.77,106.76 144.42,106.1 144.42,101.8 144.76,101.46 145.24,101.46 145.62,101.09 145.62,100.56 145.31,100.26 145.31,98.09 143.06,95.84 143.06,91.41 141.25,89.59 141.25,84.01 140.53,83.3 139.37,83.3 138.83,82.76 138.83,80.55 137.98,79.7 137.98,75.19 138.37,74.8 138.37,71.32 v2(138.82,70.87)
  BOTTOM w0.109: QV23.3 136.33,136.33 136.22,136.22 135.39,136.22 135.28,136.34 RV910.2 135.28,138.41 RV911.1 135.39,140.1 139.19,140.1 v1(141.23,138.06) v2(143.83,135.46)
PBAT_CHARGER_SMBCLK: length 108.2
  TOP w0.109: v2(124.47,62.89) 124.87,63.3 125.39,63.3 126.46,62.23 128.66,62.23 128.9,62.47 128.9,63.09 v1(130.23,64.41) 131.17,65.35 132.08,65.35 132.28,65.55 132.28,66.89 RE43.1 131.81,67.41 132.26,67.86 132.81,67.86 133.04,68.09 133.04,68.5 133.64,69.11 UE1.N2 ; PR65.2 66.52,14.72 65.99,15.25 65.99,16.91 65.47,17.42 PD9.2 64.97,18.49 64.97,19.25 63.99,20.23 63.99,23.03 64.04,23.08 v2(64.09,23.08) 64.15,23.08 64.92,22.31 PR711.1
  IN2 w0.081: v2(64.09,23.08) 64.09,23.32 65.33,24.55 66.08,24.55 68.79,27.27 76.28,27.27 80.44,31.43 84.08,31.43 88.79,36.14 90.17,36.14 94.04,40.01 94.04,41.83 97.42,45.2 97.42,50.59 100.55,53.72 102.59,53.72 102.97,54.1 104.06,54.1 107.27,57.31 113.97,57.31 116.52,59.86 119.35,59.86 122.17,62.68 124.26,62.68 v2(124.47,62.89)
PBAT_CHARGER_SMBDAT: length 110.3
  TOP w0.089: UE1.M3 134.1,70.11 134.1,69.16 133.67,68.73
  TOP w0.109: PR66.2 66.36,13.93 65.48,14.81 65.48,16.98 PD9.3 64.44,18.02 64.44,19.17 63.59,20.02 63.59,23.39 63.72,23.53 64.45,23.53 v2(64.8,23.18) 64.91,23.07 PR710.1 ; 133.67,68.73 133.27,68.34 133.27,67.84 RE37.1 133.28,66.9 133.28,65.39 133.01,65.11 131.55,65.11 v1(131.39,64.96) 131.25,64.96 129.14,62.85 129.14,62.37 128.76,61.99 126.06,61.99 125.18,62.87 v2(125.05,62.87)
  IN2 w0.081: v2(64.8,23.18) 65.13,23.18 68.98,27.04 76.37,27.04 79.83,30.49 83.88,30.49 89.31,35.93 90.26,35.93 94.25,39.92 94.25,41.71 98.22,45.68 98.22,51.1 100.64,53.51 102.68,53.51 103.06,53.89 104.15,53.89 107.36,57.1 114.21,57.1 116.1,58.99 119.28,58.99 122.35,62.07 124.26,62.07 v2(125.05,62.87)
PBAT_PRES#: length 127.7
  TOP w0.109: UE1.F9 v2(139.61,75.63) ; PR724.1 66.06,19.45 PR62.2 65.61,18.61 66.81,17.4 v2(66.81,17.27) 66.5,16.96 PD10.2 66.5,15.67 PR67.2
  IN1 w0.102: v2(101.86,30.96) 101.67,30.77 100.37,30.77 98.53,28.94 95.31,28.94 93.87,27.5 87.99,27.5 87.1,26.61 86.69,26.61 84.9,24.82 82.28,24.82 77.74,20.28 76.07,20.28 74.92,19.14 68.58,19.14 68.19,19.53 68.19,20.25 67.88,20.56 66.81,20.56 66.27,20.02 66.27,17.98 66.81,17.44 v2(66.81,17.27)
  IN3 w0.081: v2(139.61,75.63) 139.61,75.52 139.01,74.92 138.2,74.92 137.64,74.36 137.64,70.43 137.61,70.41 137.61,68.07 137.51,67.97 137.51,67.95 137.25,67.69 136.23,67.69 136.21,67.68 136.16,67.68 135.54,67.06 133.42,67.06 132.32,65.96 132.32,65.65 131.9,65.23 129.2,65.23 128.75,65.68 127.06,65.68 126.67,66.07 122.76,66.07 122.53,65.84 121.4,65.84 118.87,63.31 118.57,63.31 114.75,59.49 114.75,58.64 107.78,51.67 100.82,51.67 99.82,50.67 99.82,44.88 98.77,43.83 98.77,40.17 100.06,38.88 100.06,31.73 100.82,30.96 v2(101.86,30.96)
PCH_2_CPU_TRIGGER: length 166
  TOP w0.109: v2(129.96,53.91) 130.4,53.47 130.4,53.43 RH42.2 ; v2(247.85,63.77) 247.47,63.39 UC1.H23
  IN2 w0.081: v2(129.96,53.91) 131.63,53.91 131.96,53.58 132.27,53.58 133.24,52.61 133.24,50.1 133.42,49.92 133.93,49.92 135.31,51.3 135.31,53.08 137.54,55.31 138.35,55.31 138.94,54.73 141.77,54.73 142.8,55.76 145.39,55.76 146.04,55.11 148.94,55.11 150.12,53.93 v2(150.34,53.93)
  VCC w0.086: v2(229.39,71.39) 228.98,71.8 221.82,71.8 212.22,81.41 205.4,81.41 204.89,81.91 195.22,81.91 194.7,82.44 189.36,82.44 188.7,83.1 180.29,83.1 178.5,84.89 172.29,84.89 169.31,81.9 169.31,78.2 169.11,77.99 169.11,75.55 169.57,75.08 169.57,73.25 169.26,72.93 168.5,72.93 167.66,72.09 167.66,65.57 163.07,60.97 163.07,58.61 158.19,53.74 154.68,53.74 154.15,54.27 154.15,55.31 153.92,55.54 151.95,55.54 v2(150.34,53.93)
  IN3 w0.081: v2(229.39,71.39) 229.81,70.97 230.36,70.97 230.88,70.45 230.88,68.25 231.53,67.6 234.01,67.6 235.01,66.6 235.8,66.6 236.78,67.58 239.61,67.58 241.15,66.04 241.15,63.44 241.23,63.36 247.45,63.36 247.85,63.76 v2(247.85,63.77)
PCH_2_CPU_TRIGGER_R: length 5.2
  TOP w0.089: UH1.AK3 131.16,47.29 131.05,47.4 131.05,48.01 131.18,48.14 131.18,48.4
  TOP w0.102: 131.01,51.15 131.18,50.97 131.18,48.4
  TOP w0.109: RH42.1 130.81,51.35 v1(130.96,51.2) 131.01,51.15
PCH_BATLOW#: length 5
  TOP w0.109: UH1.BF44 123.31,27.33 123.04,27.06 122.78,27.06 122.57,26.85 122.57,26.53 121.28,25.24 119.71,25.24 RH94.1
PCH_CL_CLK1: length 92.9
  TOP w0.109: UH1.AR2 128.6,47.94 128.6,51.15 128.29,51.45 128.29,51.99 127.62,52.67 127.3,52.67 v2(127.15,52.82)
  IN4 w0.102: v2(121.56,113.84) 121.34,114.06 121.08,114.06 120.86,113.84 120.86,113.11 123.95,110.02 123.95,106.28 125.51,104.73 125.51,99.5 126.01,99 126.01,96.04 126.52,95.53 126.52,90.6 117.4,81.49 116.72,81.49 113.66,78.42 113.66,76.47 111.3,74.11 111.3,73.64 110.56,72.91 110.56,66.59 110.98,66.18 110.98,64.95 111.76,64.18 112.38,64.18 113.8,62.75 118.71,62.75 118.75,62.79 119.27,62.79 119.31,62.75 119.97,62.75 120.47,62.26 123.52,62.26 124.23,61.55 124.23,59.22 126.44,57 126.44,54.36 126.04,53.95 126.04,53.15 126.53,52.66 126.99,52.66 v2(127.15,52.82)
  BOTTOM w0.109: JNGFF1.34 121,113.11 120.88,113.23 120.88,113.76 121.19,114.06 121.34,114.06 v2(121.56,113.84)
PCH_CL_DATA1: length 95.1
  TOP w0.109: v2(127.15,52.19) 127.39,52.43 127.52,52.43 128.06,51.89 128.06,51.35 128.36,51.05 128.36,47.02 128.21,46.88 UH1.AT5
  IN4 w0.102: v2(121.56,114.56) 121.29,114.29 120.99,114.29 120.63,113.93 120.63,113.01 123.72,109.92 123.72,106.19 125.28,104.63 125.28,99.41 125.78,98.91 125.78,95.94 126.29,95.43 126.29,90.7 117.3,81.71 116.63,81.71 113.43,78.52 113.43,76.56 111.07,74.2 111.07,73.74 110.34,73 110.34,66.5 110.75,66.08 110.75,64.86 111.67,63.95 112.29,63.95 113.71,62.52 118.8,62.52 118.84,62.56 119.18,62.56 119.22,62.52 119.87,62.52 120.37,62.03 123.42,62.03 124,61.45 124,59.12 126.21,56.91 126.21,54.45 125.81,54.05 125.81,53.06 126.44,52.43 126.91,52.43 v2(127.15,52.19)
  BOTTOM w0.109: JNGFF1.32 120.5,113.09 120.64,113.23 120.64,113.85 121.09,114.3 121.3,114.3 v2(121.56,114.56)
PCH_CL_RST1#: length 78
  TOP w0.109: v2(127.74,46.38) 127.74,46.5 128,46.76 UH1.AU4
  IN1 w0.102: v2(118.12,108.17) 118.12,107.33 115.31,104.52 115.31,102.96 116,102.28 116,99.54 116.34,99.2 116.95,99.2 119.76,96.39 119.76,95.35 120.34,94.77 121.62,94.77 122.33,94.06 122.33,89.18 122.91,88.6 122.91,79.63 122.32,79.05 122.32,74.69 122.69,74.32 122.69,72.55 123.54,71.7 123.54,71.69 123.62,71.62 123.62,69.74 123.98,69.38 123.98,62.63 124.53,62.07 124.53,58.45 126.13,56.85 126.13,54.53 126.03,54.42 126.03,50.88 126.2,50.71 126.2,48.39 127.74,46.84 v2(127.74,46.38)
  BOTTOM w0.109: v2(118.12,108.17) 120.2,110.26 120.2,111.36 120,111.55 JNGFF1.30 120,114.26 v1(119.67,114.59)
PCH_CPU_BCLK_D: length 12.4
  TOP w0.076: UH1.B8 144.93,45.19 144.88,45.25 144.88,45.32 144.96,45.4 146.11,45.4 147.04,46.32 147.04,46.74 147.97,47.67 147.99,47.67 148.01,47.68
  TOP w0.102: 148.01,47.68 148.41,48.08 148.41,51.45 v3(147.45,52.41) 147.14,52.72 147.14,54.47 RH161.2
PCH_CPU_BCLK_D#: length 12.4
  TOP w0.076: UH1.C8 144.57,45.22 144.89,45.55 146.05,45.55 146.88,46.38 146.88,46.8 147.86,47.78 147.86,47.8 147.87,47.82
  TOP w0.102: RH166.2 146.95,54.35 146.95,52.64 147.08,52.51 147.08,52.45 147.53,52 147.59,52 148.22,51.37 148.22,48.16 147.87,47.82
PCH_CPU_BCLK_R_D: length 151.4
  TOP w0.076: UC1.B31 253.77,67.59 253.58,67.78 253.58,68.34 253.56,68.36 253.56,68.37
  TOP w0.102: RH161.1 147.07,55.9 147.07,56.04 147.23,56.2 149.36,56.2 153.63,51.93 155.04,51.93 155.18,51.78 155.18,51.62 v2(155.12,51.55) ; 253.56,68.37 253.56,69.71 254.25,70.4 254.25,70.88 254.14,71 253.72,71 253.61,70.89 253.61,70.75 v2(253.69,70.66)
  IN4 w0.102: v2(155.12,51.55) 155.4,51.84 158.87,51.84 159.36,52.33 161.08,54.05 161.08,56.83 163.22,58.97 163.22,61.47 164.69,62.94 164.69,68.08 165.28,68.67 165.28,69.72 168.31,72.75 168.31,82.02 175.36,89.07 184.51,89.07 184.91,88.67 192.58,88.67 193.23,89.32 196.89,89.32 197.31,89.73 217.85,89.73 222.18,85.41 225.05,85.41 226.27,84.18 230.7,84.18 241.8,73.08 252.52,73.08 252.99,72.62 252.99,71.18 253.19,70.97 253.38,70.97 v2(253.69,70.66)
PCH_CPU_BCLK_R_D#: length 151.4
  TOP w0.076: UC1.A32 254.01,67.75 253.83,67.75 253.74,67.84 253.74,68.34 253.75,68.36 253.75,68.37
  TOP w0.102: 253.75,68.37 253.75,69.63 254.44,70.32 254.44,70.96 254.22,71.19 253.88,71.19 v2(253.69,71.38) ; v2(155.11,52.41) 154.83,52.12 153.71,52.12 149.44,56.39 147.15,56.39 146.88,56.12 146.88,55.89 RH166.1
  IN4 w0.102: v2(253.69,71.38) 253.47,71.16 253.27,71.16 253.18,71.25 253.18,72.69 252.6,73.27 241.88,73.27 230.78,84.37 226.35,84.37 225.13,85.59 222.25,85.59 217.93,89.92 197.23,89.92 196.82,89.51 193.15,89.51 192.5,88.86 184.99,88.86 184.59,89.26 175.28,89.26 168.12,82.09 168.12,72.83 165.09,69.8 165.09,68.75 164.5,68.16 164.5,63.02 163.03,61.55 163.03,59.05 161.98,58 160.89,56.91 160.89,54.13 158.79,52.02 155.5,52.02 v2(155.11,52.41)
PCH_CPU_NSSC_CLK_D: length 10.4
  TOP w0.076: 147.56,48.21 147.54,48.2 147.51,48.2 146.65,47.33 146.65,46.44 145.92,45.72 144.82,45.72 144.67,45.56 144.16,45.56 UH1.D7
  TOP w0.102: 147.56,48.21 147.61,48.27 147.61,50.68 146.21,52.08 146.21,52.5 RH169.2
PCH_CPU_NSSC_CLK_D#: length 10.4
  TOP w0.076: UH1.C6 144.53,45.78 144.34,45.78 144.29,45.84 144.29,45.93 144.44,46.08 144.68,46.08 144.9,45.87 145.86,45.87 146.5,46.51 146.5,47.4 147.41,48.31 147.41,48.33 147.42,48.35
  TOP w0.102: 147.42,48.35 147.42,50.6 146.02,52 146.02,52.48 RH170.2
PCH_CPU_PCIBCLK_D: length 10.3
  TOP w0.076: 146.8,49.57 146.8,49.55 146.79,49.53 146.79,48.3 146.17,47.68 146.17,46.74 145.77,46.33 145.77,46.23 145.81,46.18 145.81,46.1 145.75,46.04 145.62,46.04 UH1.A6
  TOP w0.102: RH167.1 144.93,54.4 144.93,54.04 144.97,54 144.97,53.32 144.93,53.28 144.93,53.14 145.17,52.9 145.17,52.04 146.8,50.4 146.8,49.57
PCH_CPU_PCIBCLK_D#: length 10.3
  TOP w0.076: 146.61,49.57 146.61,49.55 146.63,49.53 146.63,48.36 146.02,47.75 146.02,46.8 145.64,46.42 145.53,46.42 UH1.B6
  TOP w0.102: RH168.1 144.74,54.39 v3(144.74,53.66) 144.74,53.06 144.98,52.82 144.98,51.96 146.61,50.32 146.61,49.57
PCH_CPU_PCIBCLK_R_D: length 161.6
  TOP w0.076: v2(256.47,66) 256.37,66.09 UC1.D35
  TOP w0.102: RH167.2 144.87,55.94 144.87,56.28 147.26,58.67 148.81,58.67 149.35,58.14 149.93,58.14 151.03,57.04 156.42,57.04 157.35,56.1 158.28,56.1 158.38,56 v2(158.38,55.69)
  IN4 w0.102: v2(158.38,55.69) 158.72,56.03 158.95,56.03 159.41,56.49 159.41,58.65 160.72,59.97 160.72,61.76 161.76,62.79 161.76,66.45 162.78,67.47 162.78,70.76 163.1,71.08 164.05,71.08 166.14,73.17 166.14,77.63 164.73,79.05 164.73,83.05 170.37,88.7 171.57,88.7 174.24,91.36 177.28,91.36 177.69,91.77 180.65,91.77 181.29,91.13 184.98,91.13 185.65,90.45 191.59,90.45 191.76,90.63 194.94,90.63 195.24,90.92 222.07,90.92 223.93,89.06 226.7,89.06 226.97,89.34 228.03,89.34 228.17,89.19 228.17,87.32 229.71,85.78 231.42,85.78 232.48,84.71 234.26,84.71 234.74,84.23 234.74,82.4 242.27,74.87 253.49,74.87 255.01,73.35 255.01,67.08 255.77,66.33 256.14,66.33 v2(256.47,66)
PCH_CPU_PCIBCLK_R_D#: length 161.6
  TOP w0.076: UC1.C36 256.49,66.61 v2(256.15,66.96)
  TOP w0.102: v2(158.37,56.57) 158.09,56.29 157.43,56.29 156.49,57.23 151.11,57.23 150.01,58.33 149.43,58.33 148.89,58.86 147.19,58.86 144.68,56.36 144.68,55.83 RH168.2
  IN4 w0.102: v2(256.15,66.96) 256.15,66.63 256.03,66.51 255.85,66.51 255.2,67.16 255.2,73.43 253.57,75.06 242.35,75.06 234.93,82.47 234.93,84.31 234.34,84.9 232.56,84.9 231.5,85.97 229.79,85.97 228.36,87.4 228.36,89.27 228.11,89.53 226.89,89.53 226.62,89.25 224.01,89.25 222.15,91.11 195.16,91.11 194.87,90.82 191.68,90.82 191.51,90.64 185.73,90.64 185.06,91.31 181.37,91.31 180.73,91.96 177.61,91.96 177.21,91.55 174.16,91.55 171.49,88.89 170.29,88.89 164.54,83.13 164.54,78.97 165.95,77.56 165.95,73.25 163.97,71.27 163.02,71.27 162.59,70.84 162.59,67.55 161.57,66.53 161.57,62.87 160.53,61.83 160.53,60.05 159.22,58.73 159.22,56.57 158.87,56.22 158.73,56.22 v2(158.37,56.57)
PCH_DPB_CTRL_CLK: length 17.8
  TOP w0.102: v2(130.39,42.6) 130.61,42.39 UH1.AL13
  BOTTOM w0.109: v2(130.39,42.6) 129.81,42.03 129.11,42.03 128.67,42.46 128.67,43.22 128.32,43.58 128.32,44.64 128.65,44.97 128.65,46.87 128.27,47.25 128.27,50.03 128.44,50.2 128.44,53.33 127.13,54.63 127.13,56 RH628.1
PCH_DPB_CTRL_DATA: length 13
  TOP w0.102: UH1.AR8 128.24,45.24 128.23,45.25 v2(128,45.25)
  BOTTOM w0.109: RH221.1 126.89,56 126.89,54.54 128.2,53.23 128.2,50.3 128.03,50.13 128.03,47.16 128.41,46.77 128.41,45.45 128.22,45.25 v2(128,45.25)
PCH_DPB_HPD: length 117.7
  TOP w0.109: RV902.1 59.13,46.85 v2(59.2,46.91) ; v2(128.03,45.84) 128.03,45.89 128.17,46.03 UH1.AT6 ; v2(89.52,41.85) 90.22,42.55 90.22,51.65 90.84,52.28 v1(98.54,52.28) 98.54,49.55 97.55,48.56 97.55,36.55 97.96,36.15 98.91,36.15 99.13,35.93 99.13,35.31 100.17,34.26 101.02,34.26 101.51,33.77 v2(101.52,33.77)
  IN1 w0.102: v2(61.69,40.1) 74.83,40.1 77.24,42.51 88.23,42.51 88.89,41.85 v2(89.52,41.85)
  IN2 w0.081: v2(59.2,46.91) 58.87,46.59 58.87,43.5 61.31,41.06 61.31,40.48 v2(61.69,40.1) ; v2(128.03,45.84) 127.69,45.84 127.12,46.41 127.12,47.27 126.88,47.51 125.32,47.51 124.65,48.17 124.01,48.17 123.51,47.68 118.37,47.68 118.06,47.37 117.44,47.37 116.89,46.81 115.3,46.81 114.61,47.5 114.05,47.5 113.46,46.92 113.46,41.32 112.77,40.63 112.77,40.27 107.62,35.12 103.68,35.12 102.33,33.77 v2(101.52,33.77)
  BOTTOM w0.109: v2(59.2,46.91) 59.2,46.92 UV66.19
PCH_DPC_CTRL_CLK: length 229.9
  TOP w0.102: UH1.AN13 129.33,42.41 v2(129.32,42.4)
  TOP w0.109: v2(306.09,75.38) 306.31,75.6 306.31,75.71 306.07,75.95 305.36,75.95 304.59,76.73 304.59,78.48 304.45,78.61 304.2,78.61 304.13,78.54 UV8.22
  VCC w0.086: v2(259.25,78.02) 258.6,78.67 255.93,78.67 253.9,76.64 240.82,76.64 239.38,78.09 234.41,78.09 230.9,81.6 221.89,81.6 215.98,87.51 197.78,87.51 197.13,88.15 181.45,88.15 179.43,90.17 174.81,90.17 174.03,89.39 168.22,89.39 163.88,85.05 163.88,76.94 163.14,76.21 163.14,71.64 162.08,70.58 162.08,67.45 160.9,66.27 160.79,66.27 v2(160.63,66.43)
  IN3 w0.081: v2(132.13,55.54) 132.41,55.54 132.46,55.59 132.97,55.59 132.99,55.56 140.57,55.56 142.84,57.84 144.78,57.84 147.01,60.07 149.18,60.07 149.22,60.11 150.85,60.11 153.87,63.13 156.28,63.13 159.35,66.21 160.41,66.21 v2(160.63,66.43) ; v2(259.25,78.02) 259.56,77.71 260.26,77.71 261.77,79.22 268.67,79.22 269.82,78.07 281.34,78.07 281.98,77.43 286.52,77.43 286.84,77.75 300.89,77.75 302.98,75.66 305.19,75.66 306,74.84 306.24,74.84 306.32,74.92 306.32,75.15 v2(306.09,75.38)
  BOTTOM w0.109: v2(129.32,42.4) 129.32,42.44 129.99,43.12 129.99,44.08 130.15,44.24 130.5,44.24 130.72,44.46 130.72,45.59 130.24,46.08 130.24,47.9 130.48,48.14 130.48,51.74 130.55,51.82 130.55,52.78 131.75,53.98 131.75,55.16 v2(132.13,55.54) 132.13,56.48 RH222.1
PCH_DPC_CTRL_DATA: length 229
  TOP w0.102: UH1.AL10 130.58,43.91 v2(130.4,43.73)
  TOP w0.109: v2(306.8,75.38) 306.55,75.63 306.55,75.81 306.17,76.19 305.46,76.19 304.82,76.82 304.82,78.58 304.55,78.85 304.26,78.85 304.17,78.94 UV8.23
  VCC w0.086: v2(160.65,65.79) 160.88,66.02 161,66.02 162.32,67.35 162.32,70.48 163.39,71.54 163.39,76.11 164.12,76.84 164.12,84.94 168.32,89.14 174.13,89.14 174.92,89.93 179.33,89.93 181.34,87.91 197.03,87.91 197.68,87.26 215.88,87.26 221.79,81.35 230.8,81.35 234.31,77.84 239.27,77.84 240.72,76.39 254,76.39 256.03,78.42 258.24,78.42 v2(258.64,78.02)
  IN3 w0.081: v2(306.8,75.38) 306.55,75.12 306.55,74.82 306.34,74.61 305.91,74.61 305.09,75.43 302.88,75.43 300.79,77.52 286.93,77.52 286.61,77.2 281.89,77.2 281.25,77.84 269.73,77.84 268.57,78.99 261.86,78.99 260.35,77.48 259.18,77.48 v2(258.64,78.02) ; v2(132.48,54.98) 132.48,55.29 132.55,55.36 132.87,55.36 132.88,55.35 132.9,55.35 132.91,55.35 140.66,55.35 142.93,57.63 144.86,57.63 147.1,59.86 149.27,59.86 149.29,59.88 150.94,59.88 153.97,62.91 156.37,62.91 159.45,65.98 160.46,65.98 v2(160.65,65.79)
  BOTTOM w0.109: RH223.1 132.56,56.23 132.56,55.06 v2(132.48,54.98) 131.98,54.48 131.98,53.88 130.79,52.69 130.79,51.72 130.71,51.64 130.71,48.04 130.47,47.8 130.47,46.18 130.96,45.69 130.96,44.29 v2(130.4,43.73)
PCH_DPC_HPD: length 213.3
  TOP w0.109: UH1.AN10 v2(129.01,43.91) ; v2(295.83,76.49) 295.87,76.54 295.87,76.57 296.17,76.86 UV8.3
  VCC w0.086: v2(162.38,63.23) 162.36,63.25 162.36,63.87 162.6,64.1 162.86,64.1 164.05,65.3 164.05,66.62 166.19,68.76 166.19,77.84 167.33,78.98 167.33,81.12 166.9,81.55 166.9,84.86 168.83,86.79 179.29,86.79 180.91,85.17 182.36,85.17 183.15,85.97 196.13,85.97 197.18,84.91 212.72,84.91 219.56,78.07 225.05,78.07 226.4,79.42 229.43,79.42 233.12,75.74 238.39,75.74 239.09,75.03 254.61,75.03 256.28,76.7 257.85,76.7 258.6,75.95 v2(258.96,75.95)
  IN3 w0.081: v2(162.38,63.23) 162.22,63.38 160.15,63.38 156.49,59.73 156.49,58.82 155.45,57.77 152.47,57.77 149.45,54.75 146.32,54.75 145.29,53.72 143.91,53.72 142.43,52.25 141.16,52.25 140.37,51.45 139.65,51.45 139.04,52.06 138.38,52.06 138.25,51.93 137.08,51.93 136.98,52.03 136.21,52.03 135.05,50.87 135.05,48.59 134.74,48.28 134.06,48.28 133.14,47.36 130.86,47.36 129.23,45.73 129.23,44.14 v2(129.01,43.91) ; v2(295.83,76.49) 287.25,76.49 286.46,75.71 280.16,75.71 279.2,76.66 270.96,76.66 265.82,71.51 263.2,71.51 258.96,75.75 v2(258.96,75.95)
  BOTTOM w0.109: v2(295.83,76.49) v1(295.27,76.49)
PCH_DPD_CTRL_CLK: length 13.8
  TOP w0.102: UH1.AL9 v2(130.17,44.64)
  BOTTOM w0.109: v2(130.17,44.64) 129.89,44.92 v1(129.89,47.28) 129.89,48.84 129.65,49.08 129.65,50.29 129.11,50.83 129.11,52.11 130.85,53.86 130.85,56.3 RH224.1
PCH_DPD_CTRL_DATA: length 12.3
  TOP w0.102: v2(129.01,48.53) 128.84,48.36 128.84,47.63 UH1.AR3
  BOTTOM w0.109: RH225.1 130.62,56.21 130.62,53.96 128.87,52.21 128.87,50.73 129.41,50.19 129.41,48.99 129.65,48.74 129.65,48.01 129.56,47.92 129.11,47.92 129.01,48.02 v2(129.01,48.53)
PCH_DPD_HPD: length 223.6
  TOP w0.109: UH1.AP9 128.93,44.64 v2(128.72,44.44) ; JDGFF4.A10 284.81,92.92 284.89,93 287.04,93 289.35,90.69 v1(289.98,90.69) 290.5,90.69 291.21,89.98 291.21,88.91 290.58,88.29 289.01,88.29 287.45,86.73 287.45,83.63 282.05,78.23 v2(282.05,77.97)
  VCC w0.086: v2(162.76,63.71) 163.04,63.71 164.3,64.96 164.3,66.46 166.44,68.61 166.44,77.75 167.57,78.88 167.57,81.22 167.15,81.65 167.15,84.76 168.93,86.54 179.19,86.54 180.81,84.92 182.46,84.92 183.26,85.72 196.03,85.72 197.08,84.67 212.62,84.67 219.46,77.82 225.15,77.82 226.5,79.18 229.33,79.18 233.02,75.49 238.26,75.49 238.96,74.79 254.71,74.79 256.34,76.42 257.78,76.42 258.93,75.28 259,75.28 261.92,72.35 266.42,72.35 270.77,76.71 274.58,76.71 276.37,78.5 281.52,78.5 v2(282.05,77.97)
  IN3 w0.081: v2(128.72,44.44) 128.72,44.62 128.6,44.74 128.6,45.37 130.84,47.61 133.04,47.61 133.95,48.53 134.68,48.53 134.85,48.7 134.85,51 136.61,52.76 138.62,52.76 139.7,51.68 140.33,51.68 141.08,52.44 142.3,52.44 143.79,53.93 145.2,53.93 146.23,54.96 149.34,54.96 152.36,57.98 155.14,57.98 155.43,58.27 155.43,58.99 160.03,63.59 161.01,63.59 161.13,63.71 v2(162.76,63.71)
  BOTTOM w0.109: v2(128.72,44.44) 128.85,44.57 128.85,45.38 129.03,45.56 RH630.2
PCH_DPWROK: length 112.1
  TOP w0.109: CH266.1 RH215.1 121.73,19.4 121.49,19.64 v2(121.49,19.66) ; UH1.AW41 126.34,28.91 v2(126.19,28.76)
  IN1 w0.102: v2(112.84,35.7) 113.69,34.85 113.69,31.63 114,31.32 114,29.63 113.23,28.87 113.23,28.19 113.64,27.79 113.64,25.71 v2(113.46,25.53) 113.46,25.12 114.5,24.08 115.33,24.08 115.69,23.73 115.8,23.68 116.39,23.68 116.58,23.88 118.62,23.88 119.52,22.98 119.52,21 119.9,20.61 121.92,20.61 122.07,20.46 122.07,19.98 121.69,19.6 121.55,19.6 v2(121.49,19.66)
  IN3 w0.081: v2(147.5,75.12) 147.5,73.97 148.77,72.7 148.77,71.03 148.08,70.35 148.08,69.33 145.34,66.59 145.34,65.28 143.59,63.53 143.59,63.07 141.19,60.67 137.73,60.67 136.88,59.82 136.88,58.66 136.17,57.95 133.28,57.95 132.75,57.42 125.11,57.42 124.63,56.95 121.96,56.95 119.88,54.86 118.97,54.86 117.63,53.52 117.63,51.47 113.5,47.35 113.5,44.52 114.25,43.78 114.25,39.72 112.24,37.71 112.24,36.3 v2(112.84,35.7)
  BOTTOM w0.109: RE536.1 146.7,76.09 147.02,75.76 147.02,75.6 v2(147.5,75.12) ; v2(126.19,28.76) 125.86,28.76 125.35,28.25 125.35,27.51 125.1,27.26 124.88,27.26 124.17,26.56 123.7,26.56 123.47,26.33 123.35,26.33 122.45,25.43 120.66,25.43 120.31,25.78 118.13,25.78 RH308.1 117.83,26.08 117.83,26.72 117.39,27.16 v4(117.08,27.16) 116.87,27.16 116.53,26.82 114.5,26.82 113.46,25.78 v2(113.46,25.53)
PCH_DPWROK_EC: length 8.6
  TOP w0.109: UE1.F8 v2(138.81,75.62)
  BOTTOM w0.102: v2(138.81,75.62) 139.22,76.03 143.28,76.03 143.71,76.47 144.47,76.47 RE536.2
  BOTTOM w0.109: RE536.2 v1(145.9,75.05)
PCH_INTRUDER_HDR#: length 4.3
  TOP w0.102: UH1.BB44 125.53,27.62 v2(125.53,27.12)
  BOTTOM w0.109: RH198.2 v1(126.57,25.8) 126.57,26.11 126.9,26.44 126.9,26.86 126.64,27.12 v2(125.53,27.12)
PCH_JTAG_TCK: length 254.9
  TOP w0.102: 132.1,52.06 132.1,51.53 131.76,51.19 131.76,47.43 UH1.AJ3
  TOP w0.109: v2(241.01,14.85) 240.82,14.66 240.82,14.08 242.1,12.8 256.21,12.8 259.65,9.35 259.65,6.35 260.13,5.87 262.81,5.87 v2(263.21,5.48) ; RH313.1 127.29,56.26 127.82,55.73 128.38,55.73 128.54,55.56 129.84,55.56 130.18,55.23 130.86,55.23 131.34,54.74 131.34,53.73 131.98,53.1 v2(131.98,52.95) 131.98,52.19 132.1,52.06
  IN3 w0.081: v2(263.21,5.48) 262.83,5.48 261.96,4.61 256.04,4.61 253.52,7.13 247.44,7.13 242.77,2.47 167.31,2.47 166.27,3.5 157.46,3.5 153.78,7.19 148.79,7.19 147.23,8.74 138.22,8.74 137.36,9.6 135.35,9.6 133.79,8.04 132.47,8.04 131.72,8.79 131.72,10.16 131.69,10.2 129.93,10.2 128.84,11.28 128.29,11.28 127.78,11.79 124.53,11.79 122.94,10.2 120.86,10.2 119.28,11.78 119.28,13.11 117.73,14.66 117.73,16.87 117.39,17.21 117.39,19.78 115.33,21.83 115.33,25.96 114.11,27.18 114.11,28.32 115.85,30.06 116.09,30.06 116.48,30.45 116.48,31.01 117.04,31.56 117.04,35.94 117.62,36.52 117.62,37.13 118.76,38.27 118.76,44.87 119.41,45.52 119.41,48.02 123.26,51.86 123.72,51.86 126.39,54.52 127.16,54.52 128.46,53.22 131.7,53.22 v2(131.98,52.95)
  BOTTOM w0.109: JXDP1.55 240.08,15.34 240.58,14.85 v2(241.01,14.85) ; v4(132.41,53.91) 132.41,53.55 131.98,53.11 v2(131.98,52.95)
PCH_JTAG_TDI: length 248.4
  TOP w0.076: 132.33,49.72 132.31,49.7 132.31,48.08 UH1.AH2
  TOP w0.109: v2(262.32,6.58) 261.85,6.11 260.22,6.11 259.89,6.45 259.89,9.45 256.31,13.03 243.93,13.03 241.7,15.26 240.74,15.26 239.99,16 239.99,20.11 v2(239.75,20.35) ; 132.33,49.72 132.33,49.89 132.34,49.9 132.34,50.23 v2(132.53,50.43) 133.17,51.07 133.17,51.85 132.55,52.47 132.55,53.39 131.82,54.12 131.82,54.94 131.04,55.72 130.65,55.72 RH314.1
  IN3 w0.081: v2(262.32,6.58) 261.27,5.53 256.62,5.53 254.1,8.05 247.06,8.05 242.4,3.38 167.69,3.38 166.65,4.42 157.89,4.42 154.21,8.1 149.17,8.1 147.61,9.66 138.64,9.66 137.78,10.52 133.39,10.52 132.8,11.11 130.35,11.11 129.35,12.12 128.64,12.12 128.13,12.63 123.68,12.63 122.49,13.81 119.95,13.81 119.38,14.39 119.38,16.87 118.3,17.94 118.3,20.19 116.99,21.5 116.99,23.36 118.16,24.53 118.16,26.02 117.66,26.52 117.66,30.43 118.03,30.79 118.46,30.79 118.92,31.26 118.92,35.23 119.17,35.49 119.17,37.12 119.5,37.45 119.5,44.65 120.09,45.24 120.09,47.62 122.35,49.88 122.93,49.88 124.62,51.56 130.36,51.56 131.49,50.43 v2(132.53,50.43)
  BOTTOM w0.109: v4(131.98,49.3) 131.98,49.88 v2(132.53,50.43) ; v2(239.75,20.35) 239.36,20.74 239.05,20.74 238.58,21.21 RC229.2 237.99,21.49 CC304.1
PCH_JTAG_TDO: length 253.9
  TOP w0.076: UH1.AH3 132.26,47.59 132.26,47.71 132.12,47.85 132.12,49.96 132.14,49.98
  TOP w0.102: 132.14,49.98 132.14,50.68 132.51,51.04
  TOP w0.109: v2(241.81,23.39) 241.81,23.34 241.97,23.19 241.97,22.83 241.3,22.16 241.3,20.5 242.89,18.91 242.89,16.77 244.3,15.36 244.3,14.41 245.21,13.5 256.5,13.5 261.19,8.82 261.19,8.04 262.02,7.2 262.74,7.2 262.96,6.98 v2(262.96,6.57) ; RH315.1 128.55,56.26 129.01,55.8 129.94,55.8 130.26,55.48 130.94,55.48 131.58,54.84 131.58,53.98 132.35,53.21 132.35,52.39 132.92,51.82 132.92,51.37 v2(132.59,51.04) 132.51,51.04
  IN3 w0.081: v2(132.59,51.04) 131.39,51.04 130.68,51.75 124.57,51.75 124.11,51.29 123.49,51.29 119.92,47.72 119.92,45.31 119.31,44.7 119.31,37.53 118.98,37.2 118.98,35.57 118.69,35.28 118.69,32.49 117.73,31.52 117.73,31.28 117.43,30.99 117.43,26.43 117.97,25.89 117.97,24.84 115.98,22.85 115.98,22.16 118.07,20.06 118.07,17.75 118.41,17.41 118.41,14.94 120.1,13.25 120.1,12.12 121.34,10.89 122.65,10.89 124.19,12.42 128.04,12.42 128.55,11.91 129.23,11.91 130.26,10.89 132.7,10.89 133.3,10.29 137.69,10.29 138.55,9.43 147.52,9.43 149.07,7.87 154.06,7.87 157.75,4.19 166.56,4.19 167.6,3.15 242.49,3.15 247.16,7.82 254.01,7.82 256.53,5.3 261.62,5.3 262.89,6.57 v2(262.96,6.57)
  BOTTOM w0.109: v4(240.7,24.09) 241.07,24.09 241.77,23.39 v2(241.81,23.39) 241.76,23.34 CC303.1 242.33,22.18 RC230.2
PCH_JTAG_TMS: length 264.5
  TOP w0.089: 131.26,52.06 131.26,51.35 131.37,51.24 131.37,48.07 131.23,47.94 131.23,47.65 131.32,47.56 131.42,47.56 131.57,47.41 131.57,47.08 131.81,46.83 UH1.AJ4
  TOP w0.109: 131.26,52.06 131.26,52.47 v2(131.42,52.62) 131.42,53.28 131.06,53.63 131.06,54.62 130.71,54.97 130.1,54.97 129.74,55.33 128.45,55.33 128.28,55.49 126.28,55.49 RH312.1 ; v2(239.1,20.32) 239.15,20.37 CC336.1 ; v2(263.85,5.48) 263.44,5.07 262.97,5.07 262.4,5.64 260.03,5.64 259.41,6.25 259.41,9.26 256.11,12.56 241.98,12.56 240.51,14.03 240.51,14.61 239.58,15.54 v2(239.58,17.24)
  IN1 w0.102: v2(239.1,20.32) 239.19,20.32 239.68,19.83 239.68,17.35 v2(239.58,17.24)
  IN3 w0.081: v2(131.42,52.62) 130.99,53.05 128.34,53.05 127.09,54.29 126.46,54.29 123.84,51.67 123.33,51.67 119.58,47.92 119.58,45.45 118.93,44.8 118.93,38.1 117.85,37.02 117.85,36.42 117.27,35.85 117.27,31.47 116.83,31.03 116.83,30.47 116.16,29.81 115.92,29.81 114.34,28.23 114.34,27.39 116.28,25.45 116.28,23.78 115.54,23.04 115.54,21.98 117.62,19.9 117.62,17.3 117.96,16.96 117.96,14.75 119.5,13.2 119.5,11.88 120.95,10.43 122.84,10.43 124.42,12 127.87,12 128.38,11.49 128.96,11.49 130.02,10.43 131.78,10.43 131.95,10.26 131.95,8.89 132.57,8.27 133.7,8.27 135.26,9.83 137.46,9.83 138.32,8.97 147.33,8.97 148.88,7.42 153.87,7.42 157.56,3.73 166.37,3.73 167.41,2.69 242.68,2.69 247.35,7.36 253.64,7.36 256.17,4.84 261.86,4.84 262.96,5.93 263.48,5.93 263.85,5.56 v2(263.85,5.48)
  BOTTOM w0.109: RC228.2 238.53,20.71 238.92,20.32 v2(239.1,20.32) ; v4(131.88,52.23) 131.49,52.62 v2(131.42,52.62)
PCH_JTAGX: length 289.2
  TOP w0.089: v2(132.51,51.7) 132.51,51.58 131.95,51.02 131.95,47.78 132.06,47.66 132.06,47.41 132.39,47.09 UH1.AH4
  IN2 w0.081: v2(259,23.8) 259,23.28 259.32,22.96 259.32,21.39 256.18,18.25 248.92,18.25 247.92,19.25 242.76,19.25 241.99,18.48 240.43,18.48 240.12,18.17 238.95,18.17 238.14,17.35 236.38,17.35 232.67,13.63 232.67,13.06 v2(232.55,12.95)
  VCC w0.086: v2(274.34,77.41) 273.96,77.79 272.44,77.79 271.08,79.15 261.42,79.15 259.85,77.58 256.11,77.58 254.31,75.77 239.45,75.77 238.07,77.16 232.74,77.16 229.74,80.16 221.81,80.16 215.72,86.26 197.65,86.26 196.65,87.26 180.87,87.26 179.39,88.74 178.65,88.74 178.11,89.27 175.31,89.27 174.4,88.35 168.58,88.35 164.74,84.52 164.74,76.54 164.17,75.97 164.17,73.83 164.81,73.19 164.81,69.92 164.2,69.3 v2(164.2,69.01)
  IN3 w0.081: v2(164.2,69.01) 161.54,66.35 161.54,65.33 160.63,64.43 159.57,64.43 157.01,61.86 154.23,61.86 150.35,57.98 148.87,57.98 148.06,57.17 146.55,57.17 144.57,55.19 143.41,55.19 141.55,53.33 139.54,53.33 139.15,53.72 136.17,53.72 134.04,51.59 133.23,51.59 133.12,51.7 v2(132.51,51.7)
  IN4 w0.102: v2(274.34,77.41) 272.26,75.33 272.26,70.87 v2(271.35,69.95) 271.34,69.95 270.69,69.95 270.44,69.7 270.44,69.29 264.84,63.69 264.84,61.84 264.2,61.2 264.2,56.7 263.36,55.86 263.36,38.87 261.47,36.98 261.47,26.27 v2(259,23.8)
  BOTTOM w0.109: RC143.2 CC305.1 234.9,17.19 232.37,14.66 232.37,13.12 232.54,12.95 v2(232.55,12.95) ; v4(131.13,50.74) 131.54,50.74 v2(132.51,51.7) ; v2(271.35,69.95) 271.45,69.85 272.69,69.85 272.81,69.97 275.88,69.97 276.11,69.73 RC166.2
PCH_PCIE_WAKE#: length 194.9
  TOP w0.109: RE274.2 128.6,66.65 128.92,66.97 129.93,66.97 130.78,67.82 v2(130.78,67.98) ; UH1.BB47 124.9,25.23 125.06,25.07 125.06,24.71 124.83,24.48 124.83,24.11 122.96,22.24 RH92.1 123.47,21.17 123.47,20.18 v2(123.54,20.11) ; v2(131.97,70.94) 132.28,71.25 UE1.L1 ; v2(111.96,64.66) 112.18,64.66 112.75,65.23 RT445.1
  IN1 w0.102: v2(179.6,13.77) 179.39,13.77 178.58,12.96 176.21,12.96 175.71,13.46 175.71,14.85 175.29,15.28 175.03,15.28 172.47,17.84 172.47,26.14 172.08,26.53 v2(169.98,26.53)
  IN2 w0.081: v2(169.98,26.53) 169.98,26.92 169.06,27.84 169.06,41.07 167.26,42.87 167.26,47.11 164.28,50.09 164.13,50.09 163.42,50.81 163.42,51.01 161.63,52.8 161.63,54.36 158.44,57.55 153.21,57.55 151.13,59.63 151.13,60.71 150.16,61.69 149.45,61.69 147.41,63.73 142.81,63.73 141.28,65.26 140.06,65.26 138.75,66.57 132.42,66.57 131.02,67.97 130.79,67.97 v2(130.78,67.98) 130.76,67.99 130.76,68.23 131.37,68.83 131.37,70.33 v2(131.97,70.94) ; v2(146.33,12.86) 145.61,12.14 134.75,12.14 133.49,13.41 133.49,15.73 132.81,16.41 130.41,16.41 129.63,17.19 129.63,19.46 129.29,19.8 126.85,19.8 125.06,21.58 124.11,21.58 123.54,21.02 v2(123.54,20.11)
  IN4 w0.102: v2(111.96,64.66) 113.48,64.66 114.95,66.12 114.95,68.49 115.87,69.42 118.95,69.42 119.91,68.45 122.49,68.45 123.74,67.2 127.36,67.2 127.65,66.92 128.63,66.92 128.92,67.2 130.16,67.2 130.78,67.83 v2(130.78,67.98)
  BOTTOM w0.109: v2(179.6,13.77) 179.39,13.77 177.91,12.29 171.94,12.29 171.11,11.46 163.72,11.46 163.01,12.17 155.79,12.17 155.54,12.42 150.9,12.42 150.23,11.74 147.46,11.74 v1(146.74,12.46) v2(146.33,12.86)
PCH_PECI: length 10.4
  TOP w0.109: UH1.AF2 133.02,48.1 133.34,48.42 133.34,48.9 133.49,49.05 133.49,49.48 134,49.99 134,51.3 132.93,52.37 v1(132.93,52.75) 132.93,53.05 132.83,53.15 132.83,53.63 132.05,54.41 132.05,55.04 131.71,55.38 RH73.1 RH74.1
PCH_PLTRST#: length 354.2
  TOP w0.084: 124.28,34.6 124.57,34.72 124.93,34.77
  TOP w0.089: UH1.AV29 127.07,34.72 126.59,35.19 125.35,35.19 124.93,34.77 ; 124.28,34.6 124.17,34.6
  TOP w0.102: 124.17,34.6 123.52,34.6 123.5,34.61
  TOP w0.109: 123.5,34.61 123.42,34.61 123.23,34.42 123.15,34.42 122.78,34.04 122.06,34.04 121.34,33.33 v2(120.92,33.33) ; v2(115.53,32.75) 115.1,32.32 RH641.1 CH349.1 114.27,31.56 114.07,31.36 112.93,31.36 112.58,31.71 112.25,31.71 v2(112.19,31.77) ; RH624.2 143.97,140.04 134.05,140.04 132.34,141.75 130.12,141.75 126.6,145.26 126.6,151.79 124.91,153.48 v2(124.91,155.18) ; v2(97.27,35.02) 97.27,35.36 v1(97.5,35.59)
  IN1 w0.102: v2(97.27,35.02) 97.27,35.36 95.32,37.3 95.32,43.63 93.62,45.33 93.62,51.38 101.35,59.11 102.28,59.11 103.01,59.83 103.01,67.27 104.33,68.59 106.3,68.59 107.69,69.99 107.69,76.54 108.58,77.43 108.58,83.94 107.24,85.28 107.24,87.51 108,88.28 108.13,88.28 109,89.15 110.85,89.15 112.51,90.81 112.51,94.69 111.58,95.62 110.11,95.62 107.27,98.46 107.27,112.46 109.6,114.79 109.6,133.01 110.63,134.04 110.63,153.49 112.32,155.18 v2(124.91,155.18)
  IN2 w0.081: v2(97.27,35.02) 96.75,34.5 96.75,33.78 95.24,32.27 90.19,32.27 88.81,30.89 88.81,30.47 85.62,27.29 84.14,27.29 82.75,25.9 80.09,25.9 75.13,20.93 69.16,20.93 67.77,19.54 66.66,19.54 65.47,18.35 63.04,18.35 61.67,19.72 60.08,19.72 59.87,19.93 59.87,20.83 58.75,21.95 58.75,23.28 58.47,23.56 57.22,23.56 55.73,22.06 50.29,22.06 49.58,22.77 49.35,22.77 48.85,23.27 46.32,23.27 45.92,22.87 45.51,22.87 43.36,25.03 39.44,25.03 37.49,23.08 24.13,23.08 23.62,22.57 v2(23.52,22.57) ; v2(115.53,32.75) 115.69,32.59 115.69,31.69 116.53,30.85 118.69,30.85 120.92,33.08 v2(120.92,33.33)
  IN3 w0.081: v2(120.92,33.33) 120.91,33.32 120.91,32.61 121.33,32.19 121.33,29.74 122.46,28.61 122.46,28.16 121.37,27.07 121.26,27.07 120.64,26.45 120.64,25 119.94,24.29 119.94,22.6 119.99,22.54 119.99,21.08 119.86,20.95 119.86,18.64 123.55,14.95 129.03,14.95 v2(130.71,13.27)
  IN4 w0.102: v2(97.27,35.02) 98.49,33.8 99.43,33.8 101.34,31.88 v2(104.77,31.88)
  BOTTOM w0.109: UH7.1 105.82,30.84 v2(104.77,31.88) 104.84,31.96 105.42,31.96 105.89,31.49 UH7.2 111.91,31.49 v2(112.19,31.77) ; v2(130.71,13.27) 132.13,11.85 RH623.2 ; RH625.2 114.75,33.1 115.1,32.75 v2(115.53,32.75) ; RH626.1 24.62,22.95 23.92,22.95 23.54,22.57 v2(23.52,22.57)
PCH_PLTRST#_AND: length 5.7
  BOTTOM w0.109: RH622.1 v1(113.56,34.24)
  BOTTOM w0.356: UH7.4 110.77,32.14 110.96,32.32 110.96,33 CH350.1 111.12,33.16 111.66,33.16 RH65.1
  BOTTOM w0.381: RH65.1 113.51,33.24 RH622.1
  BOTTOM w0.508: RH619.1 111.73,32.45 RH65.1
PCH_PLTRST#_R: length 632.5
  TOP w0.109: v2(106.18,58.83) v1(106.18,54.41) 106.18,53.28 103.55,50.65 100.32,50.65 98.03,48.37 98.03,36.84 98.25,36.62 99.1,36.62 99.6,36.13 99.6,35.5 100.37,34.73 101.7,34.73 102.44,33.98 102.44,31.9 103.28,31.07 103.82,31.07 104.33,30.55 v2(104.33,30.55) ; v2(112.81,61.53) 112.98,61.36 113.5,61.36 113.75,61.61 RT499.1 114.02,61.99 114.61,62.58 119.33,62.58 119.64,62.26 RT612.1 ; v2(324.6,30.55) 324.24,30.19 324.24,19.76 v2(324.05,19.57)
  IN1 w0.102: v2(134.44,93.55) 134.82,93.93 134.82,97.3 132.09,100.03 132.09,101.81 132.81,102.53 132.81,103.16 132.42,103.55 132.42,108.03 132.06,108.38 131.12,108.38 130.83,108.09 126.57,108.09 v2(124.41,110.25) ; v2(109.05,81.38) 109.05,77.48 107.92,76.35 107.92,69.86 106.43,68.37 104.42,68.37 104.14,68.08 104.14,61.2 105.36,59.98 105.36,59.66 v2(106.18,58.83)
  IN2 w0.081: v2(324.05,19.57) v2(325.8,19.57) 326.39,18.99 326.39,16.71 321.84,12.16 321.84,3.44 322.43,2.86 325.93,2.86 326.21,2.58 334.03,2.58 334.74,3.29 339.57,3.29 339.94,2.92 342.91,2.92 343.36,3.37 345.37,3.37 346.28,4.28 350.19,4.28 351.57,5.65 356.06,5.65 358.9,8.5 358.9,11.8 359.23,12.13 363.21,12.13 364.28,13.2 365.18,13.2 366.4,14.42 371.5,14.42 373.71,12.21 373.71,10.82 372,9.11 JNGFF4.50 ; v2(124.41,110.25) 124.41,110.71 126.6,112.89 126.6,113.9 128.61,115.92 129.37,115.92 131.33,117.87 131.33,118.46 132.13,119.27 138.81,119.27 139.82,118.25 140.71,118.25 141.77,117.2 145.95,117.2 147.89,115.25 149.9,115.25 150.44,114.71 160.97,114.71 162.13,113.55 162.13,112.54 163,111.66 v2(163.17,111.66) ; v2(112.81,61.53) 111.64,60.35 110.51,60.35 109.45,59.29 106.97,59.29 106.51,58.83 v2(106.18,58.83)
  VCC w0.086: v2(145.96,60.74) 145.97,60.74 145.97,52.21 149.83,48.34 150.6,48.34 157.68,41.26 157.68,32.34 157.78,32.24 157.78,29.39 157.17,28.78 157.17,28.11 157.57,27.72 157.57,27.66 158.44,26.79 158.44,23.67 155.72,20.96 155.72,17.83 164.62,8.93 216.41,8.93 217.09,8.25 221.55,8.25 222.19,8.89 232.72,8.89 235.75,11.92 236.88,11.92 237.97,13.01 241.3,13.01 241.6,12.7 248.7,12.7 249.23,12.17 264.01,12.17 266.73,9.45 292.71,9.45 297.88,14.63 301.92,14.63 304.7,17.4 318.61,17.4 320.81,19.6 324.03,19.6 v2(324.05,19.57)
  IN3 w0.081: v2(324.6,30.55) 319.23,30.55 318.75,31.02 316.31,31.02 315.11,32.23 309.8,32.23 309.36,32.66 309.36,35.16 309.98,35.78 312.58,35.78 315.54,38.74 315.54,40.44 320.2,45.1 v2(327.61,45.1) ; v2(109.05,81.38) 109.05,81.88 109.85,82.68 111.07,82.68 118.19,89.8 120.88,89.8 122.43,91.35 125.31,91.35 125.36,91.39 v2(127.9,91.39)
  BOTTOM w0.109: JNGFF3.50 326.03,19.79 v2(325.8,19.57) ; v2(134.44,93.55) 134.44,93.17 133.49,92.22 128.72,92.22 v2(127.9,91.39) 127.33,91.39 127.04,91.1 JNGFF6.50 127.04,88.69 125.24,86.9 125.24,84.68 124.58,84.02 124.58,83.06 125.36,82.29 125.36,80.9 126.01,80.25 126.01,79.75 125.19,78.93 125.19,76.47 126.29,75.37 126.29,73.47 125.87,73.04 125.87,71.13 126.52,70.48 126.52,68.66 128.06,67.13 129.49,67.13 130.02,66.6 137.98,66.6 138.4,66.18 138.4,65.29 138.87,64.82 141.88,64.82 v2(145.96,60.74) ; JNGFF5.50 327.61,45.11 v2(327.61,45.1) ; v2(163.17,111.66) 162.3,110.8 159.65,110.8 157.49,112.96 JNGFF2.42 ; v2(104.33,30.55) 104.98,29.91 106.45,29.91 106.76,30.22 107.34,30.22 108,29.56 110.47,29.56 110.89,29.97 111.21,29.97 111.83,29.36 113.66,29.36 114.12,29.81 114.12,31 113.91,31.21 113.04,31.21 112.6,31.65 112.6,32.4 RH619.2 ; JNGFF1.44 123.5,111.66 124.41,110.76 v2(124.41,110.25)
