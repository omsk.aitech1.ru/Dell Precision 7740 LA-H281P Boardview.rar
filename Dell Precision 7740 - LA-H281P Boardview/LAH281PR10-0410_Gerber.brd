# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N17883375: length 4.6
  TOP w0.305: PR38.1 54.91,24.32 54.51,24.73 v1(54.51,25.3) 54.35,25.45 54,25.45 53.64,25.81 53.64,26.69 53.26,27.07 PQ6.5
N20816750:
  vias: v2(291.2,16.11)
N20816752: length 0.9
  BOTTOM w0.109: v2(291.07,16.99) 291.5,16.99 v1(291.82,17.31)
N20816771: length 2.6
  TOP w0.109: v1(294.46,15.86) 293.93,16.4 PR1701.2
  TOP w0.508: PR1701.2 PC1706.1
N20816775: length 4.9
  TOP w0.109: PC1707.2 294.03,14.58 v1(294.46,14.58)
  TOP w0.305: PU1700.3 291.58,14.91 291.98,15.32 PR1700.2 PC1707.2
N20816793: length 2.8
  TOP w0.254: v2(278.31,17.44) 278.04,17.17 PL1700.3
  BOTTOM w0.109: v2(278.31,17.44) v1(278.31,18.07)
  BOTTOM w0.254: PR1703.1 278.28,17.41 v2(278.31,17.44)
N20816800: length 3.1
  BOTTOM w0.109: v1(282.8,15.91) PR1702.1
  BOTTOM w0.508: PC1709.2 285,15.36 PR1702.1
N20816821: length 1.4
  TOP w0.109: PC1806.2 289.79,70.39 v1(290.13,70.73)
N20816822: length 2.9
  TOP w0.109: v1(292.24,68.07) 291.77,67.6 290.51,67.6 289.88,68.23 PR1800.1
N20816832: length 4.8
  TOP w0.109: PC1807.2 291.9,67.08 v1(292.33,66.65)
  TOP w0.254: PC1807.2 291.06,67.07 PR1801.2 288.93,66.14 PU1800.3
N20816859: length 2.3
  TOP w0.109: v1(292.28,69.44) PC1806.1
  TOP w0.508: PC1806.1 291.18,68.24 PR1800.2
N20816888: length 3.3
  BOTTOM w0.109: v1(283.07,65.23) PR1802.1
  BOTTOM w0.508: PC1809.2 281.02,63.86 281.02,64.75 PR1802.1
N20820556: length 5.4
  TOP w0.305: PL1202.3 278.05,57.33 278.36,57.02 278.36,55.27 277.75,54.66 v2(277.75,53.89) PR1203.1
N20820665: length 6.3
  TOP w0.109: v1(277.45,52.17) 277.61,52.17 PR1207.1
  TOP w0.305: PL1203.3 278.05,47.19 278.35,47.49 PR1207.1
N23832668: length 46.6
  TOP w0.508: PQ23.4 v2(86.88,34.8)
  IN1 w0.381: v2(60.79,28.16) 61.71,29.07 62.47,29.07 62.74,29.34 62.74,29.39 65.58,32.23 65.58,36.34 66.58,37.34 71.8,37.34 72.63,36.5 75.33,36.5 76.39,37.56 85.14,37.56 86.88,35.83 v2(86.88,34.8)
  BOTTOM w0.109: v2(60.79,28.16) v1(60.79,27.61)
  BOTTOM w0.305: v2(60.79,28.16) 61.03,28.4 PR47.2 PC19.2 59.18,28.18 PQ25.1 56.79,28.18 55.95,29.02 55.95,30.72 55.55,31.13 PR52.1
N23832751: length 5.5
  BOTTOM w0.381: PR50.1 58.67,33.38 58.42,33.63 57.14,33.63 56.89,33.38 PR44.2 56.89,32.6 57.04,32.46 v1(57.04,32.03) 57.04,31.77 56.77,31.5 56.77,30.4 PQ25.2
N23832775: length 7.2
  BOTTOM w0.109: PQ8.3 62.42,27.59 61.62,28.39 v1(61.62,31.35) 61.62,31.46 60.04,33.03 PR50.2
N23832788: length 33
  TOP w0.254: v2(66.62,31) 67.37,30.24 71.14,30.24 71.89,30.99 PQ22.4
  BOTTOM w0.254: PR46.2 47.69,32.32 PC18.2 ; PR46.2 48.46,30.28 PQ24.1 48.9,30.09 PR51.1 ; PR46.2 48.99,32.86 48.99,33.56 49.26,33.82 50.66,33.82 51.4,34.56 53.78,34.56 54.24,34.1 59.5,34.1 62.6,31 v1(64.64,31) v2(66.62,31)
N23832850: length 3.6
  BOTTOM w0.109: v1(48.33,25.15) PR43.2
  BOTTOM w0.508: PQ24.2 49.24,27.87 49.24,26.35 PR48.1 PR43.2
N23833318: length 3.6
  BOTTOM w0.109: v1(55.67,32.11) 55.27,31.7 54.65,31.7 54.07,31.13 PR52.2
  BOTTOM w0.254: PR52.2 53.55,31.13 53.04,30.62 PQ9.3
N23833326: length 7.2
  BOTTOM w0.109: PR53.1 53.71,33.39 54.11,33.79 55.7,33.79 v1(55.87,33.63)
  BOTTOM w0.254: PR53.1 53.46,33.07 51.48,33.07 51.25,32.84 51.25,32.27 51.38,32.15 51.38,31.5 51.15,31.27 PQ9.5
N23900457: length 3.8
  TOP w0.109: PR707.2 72.27,26.58 71.18,26.58 70.48,25.88 PU700.3
N24451540: length 1.9
  TOP w0.109: v1(58.02,26.22) 58.02,26.49 57.31,27.21 PC13.1
N24455122: length 1.2
  TOP w0.109: PR39.2 55.99,30.74 v1(56.6,31.35)
N24455126: length 4.7
  TOP w0.109: PR40.1 54.32,32.99 54.32,34.19 v1(53.86,34.66)
  TOP w0.254: PR40.1 53.93,32.44 54.79,32.44 PR36.2 54.85,31.61 PQ4.4
N24455128: length 1.5
  TOP w0.254: PQ4.5 53.92,31.47 53.07,32.33 PR41.2
N24468445: length 4.9
  BOTTOM w0.254: PR55.2 52.98,29.59 52.12,30.46 52.12,30.78 52.61,31.27 PQ9.2
  BOTTOM w0.305: PR55.2 53.81,29.59 54.4,30.19 PC20.1 PR58.2
N24468529: length 3.1
  BOTTOM w0.109: v1(54.48,27.89) PR57.2 53.52,27.92 PR55.1 53.27,28.92 52.85,28.92 PQ7.3
N24468533: length 3
  BOTTOM w0.109: v1(53.5,26.02) 53.02,26.49 PR54.2 ; PR54.2 52.47,26.94 52.4,27.01 PQ7.4 ; PR54.2 PR59.1
N24468535: length 1.7
  BOTTOM w0.109: PR60.2 50.87,26.83 50.98,26.94 51.64,26.94 51.75,27.05 PQ7.5
N24480969: length 6
  BOTTOM w0.109: v1(74.01,23.17) 74.01,23.31 PC2016.1
  BOTTOM w0.381: PR2041.2 75.99,26.61 76.26,26.35 PU2004.6
  BOTTOM w0.508: PR2041.2 PR2056.1 75.72,25.67 75.72,24.73 75.28,24.3 PC2016.1
N24481025: length 6.2
  BOTTOM w0.109: PC2017.1 76.27,24.01 75.56,23.29 v1(75.31,23.29)
  BOTTOM w0.381: PR2042.1 78.66,24.09 PR2040.2 PR2053.1 PC2017.1 76.29,24.11 76.29,25.55 76.43,25.7 PU2004.5
N24481044: length 1.9
  BOTTOM w0.109: PR2036.2 v1(78.74,22.19)
  BOTTOM w0.254: PR2036.2 78,23.26 PR2040.1
N24481164: length 0.7
  BOTTOM w0.109: v1(69.9,28.88) 69.87,28.86 69.87,28.22
N24481285: length 3.7
  BOTTOM w0.109: PU2001.2 52.12,22.95 PC2009.1 52.51,23.4 PR2033.1 PR2023.2
N24481291: length 6.9
  BOTTOM w0.109: PR2022.2 PR2032.1 55.02,23.35 PC2010.1 v1(55.05,22.29) 55.05,21.81 PR2030.1 53.7,20.46 53.03,20.46 52.77,20.72 PU2001.3
N24481333: length 3
  BOTTOM w0.109: PR2019.1 53.36,25.11 53.65,25.4 53.92,25.51 v1(55.34,25.51)
  BOTTOM w0.508: PR2022.1 53.41,25 PR2019.1
N24501581: length 55.4
  TOP w0.109: v2(81.1,24.91) 81.1,25.06 81.41,25.38 PR9.1 81.76,25.35 PR4.2 81.72,24.55 PC3.2 81.39,23.74 79.79,22.14 PQ13.1 78.79,21.2 v1(77.95,22.04)
  IN1 w0.508: v2(81.1,24.91) 82.24,26.05 84.3,26.05 85.69,27.44 85.92,27.44 87.17,28.69 87.67,28.69 88.59,29.61 88.59,30.34 90.31,32.06 94.77,32.06 95.45,31.37 101.33,31.37 101.6,31.64 102.12,31.64 102.4,31.92 102.4,32.78 102.64,33.02 102.64,34 101.77,34.88 98.38,34.88 95.96,37.3 v2(95.96,44.97)
  BOTTOM w0.508: PQ11.4 98.99,44.86 98.76,45.1 96.08,45.1 v2(95.96,44.97)
N24501583: length 1.3
  TOP w0.109: v1(78.08,17.1) 78.61,17.63 PR70.2
N24501661: length 3.2
  TOP w0.109: v1(78.9,19.6) 79.54,20.23 81.87,20.23
N24501681:
  vias: v1(83.37,18.16)
N24501694: length 48.7
  TOP w0.508: v2(103.53,53.33) 102.26,54.6 86.99,54.6 86.36,53.96 86.36,53.05 88.42,50.99 88.42,43.66 86.94,42.19 86.94,35.89 87.96,34.88 87.96,33.67 87.45,33.16 87.45,31.1 88.35,30.2 v1(88.35,29.05) 88.35,28.13 88.4,28.08 88.4,26.88
  BOTTOM w0.381: PQ10.4 104.08,53.13 103.88,53.33 v2(103.53,53.33)
N24501736: length 1.2
  TOP w0.109: PR1.2 91.9,22.46 v1(92.23,22.79)
N24501799: length 5.7
  TOP w0.109: v1(83.28,26.3) 83.06,26.3 82.65,25.9 PR9.2 83.04,25.38 83.39,25.03 83.39,24.35 84.56,23.17 85.12,23.17 85.31,22.98 PQ3.3
N24501803: length 1.9
  TOP w0.109: v1(84.76,26.38) 84.62,26.25 PR17.1
  TOP w0.381: PR17.1 84.62,24.99 84.66,24.96 PQ3.5
N24501987: length 3
  TOP w0.109: PQ1.4 90.27,19.18 PR22.1 ; v1(90.45,17.15) 90.27,17.33 PR22.1 ; PR15.2 89.53,18.17 PR22.1
N24502002: length 3.9
  TOP w0.109: v1(89.62,16.11) 89.12,16.11 88.67,16.56 PR20.2
  TOP w0.381: PQ1.3 88.33,18.82 88.67,18.48 PR16.1
  TOP w0.508: PR20.2 PR16.1
N24502008: length 1
  TOP w0.381: PQ1.5 90.84,19.87 90.87,19.84 PR23.2
N24502134: length 3
  TOP w0.109: PR16.2 87.65,18.19 v1(86.74,17.27)
  TOP w0.381: PU1.2 86.87,19.11 87.75,18.22 PR16.2
N24561932: length 4.8
  TOP w0.109: v1(96.67,33.59) 97.1,33.16 PR11.2
  TOP w0.254: PQ14.3 98.57,32.46 97.24,32.46 PR11.2 97.91,33.42 PR12.1
N24561949: length 32.7
  TOP w0.109: v2(98.75,27.39) 98.75,27.43 99.94,28.62 PQ14.1 ; v2(98.09,31.98) 97.8,31.69 PR11.1
  IN2 w0.081: v2(95.16,23.84) 95.81,23.84 98.75,26.77 v2(98.75,27.39)
  IN4 w0.102: v2(98.75,27.39) 99.81,28.45 99.81,30.95 98.77,31.98 v2(98.09,31.98)
  BOTTOM w0.109: PR2162.2 98.5,25.2 98.33,25.03 97.98,25.03 97.58,24.64 96.72,24.64 95.93,23.84 v2(95.16,23.84) ; PR14.2 87.15,19.88 v1(87.69,19.88) 88.83,19.88 92.19,23.24 94.56,23.24 v2(95.16,23.84) ; v2(95.16,23.84) 93.55,25.45 PQ2108.1
N24561967: length 7
  BOTTOM w0.109: PR21.2 PR14.1 88.25,20.41 88.72,20.88 88.72,22.53 v1(89.46,23.27) 89.62,23.44 PQ16.2
N24561971: length 24.3
  TOP w0.109: PQ14.2 100.25,32.06 99.29,31.09 98.32,31.09 98.18,31.23 96.75,31.23 96.29,31.69 PR24.1 PR19.2 95.32,31.54 95.96,30.9 PQ2109.2 PQ2109.5 95.96,28.6 96,28.56 96,27.07 v2(96.23,26.84)
  BOTTOM w0.109: v2(96.23,26.84) 96.4,26.84 v1(96.8,26.44) 96.8,25.3 96.48,24.99 94.95,24.99 94.65,25.28 94.65,25.79 93.97,26.47 92.68,26.47 92.59,26.39 92.59,25.16 92.11,24.68 PQ2108.2 89.81,26.33 PQ16.1
N24565509: length 1.3
  BOTTOM w0.109: v1(46.8,19.85) 46.43,19.48 PR2051.2
N24565519: length 8.1
  BOTTOM w0.109: v1(48.31,17.57) 48.02,17.86 PR2062.1
  BOTTOM w0.254: PU2003.6 43.39,16.69 43.94,16.14 45.46,16.14 PC2024.1 46.41,16.44 46.44,16.41 PR2050.2 47.65,16.64 47.65,17.38 47.34,17.68 PR2062.1
N24565597:
  vias: v1(41.45,22.68)
N24620312: length 4.3
  TOP w0.109: v1(55.2,23.19) 55.38,23.02 PR2016.1
  TOP w0.254: PQ2004.1 55.95,20.65 55.57,21.03 55.57,21.6 55.92,21.95 PQ2004.3 56.19,23 PR2016.1
N24620374: length 5.3
  TOP w0.109: v1(60.37,13.97) 59.84,14.51 PR2014.2
  TOP w0.254: PQ2002.1 61.96,15.85 61.63,15.52 PR2007.1 60.7,15.13 60.45,14.87 PR2014.2 59.65,15.06 PQ2001.3
N24620554: length 3.9
  TOP w0.109: v1(58.28,18.86) 58.35,18.79 PQ2001.6
  TOP w0.254: PQ2001.6 PQ2001.5 59,18.05 59.38,18.43 60.02,18.43 60.36,18.09 PR2008.1
N24621898: length 4.1
  TOP w0.109: v1(56.68,16.36) 56.12,16.92 PQ2005.1
  TOP w0.254: PR2021.1 55.88,19.27 PQ2005.3 55.74,18.22 55.26,17.74 55.26,17.45 55.78,16.92 PQ2005.1
N24623814: length 1.3
  BOTTOM w0.109: PR2054.1 34.45,17.49 33.94,16.98 v1(33.69,16.98)
N24623824: length 6.1
  BOTTOM w0.109: PR2048.2 32.69,15.73 32.56,15.59 v1(32.28,15.59)
  BOTTOM w0.254: PR2048.2 PR2061.1 34.4,15.73 34.48,15.65 PC2020.1 35.66,15.65 35.9,15.88 37.14,15.88 37.3,16.04 PU2003.2
N24623894:
  vias: v1(37.48,23.03)
N24632022: length 3.4
  BOTTOM w0.254: PU2001.6 52.77,15.91 52.87,15.82 PC2012.1 52.86,15.39 PR2035.1 PR2027.2
N24632028: length 6
  BOTTOM w0.109: PC2013.1 54.52,15.4 PR2034.1 PR2026.2 53.42,15.71 PU2001.5 54.1,17.15 PR2031.1 v1(55.73,17.66)
N24632068: length 4.7
  BOTTOM w0.109: PR2026.1 53.72,13.4 53.41,13.1 PR2020.1 52.73,12.97 52.39,12.63 51.17,12.63 v1(50.7,13.1)
N24695047: length 4
  BOTTOM w0.109: PR72.2 64.84,29.59 63.9,29.59 63.72,29.4 PQ8.6 63.72,28.83 63.61,28.72 63.19,28.72 63.07,28.84 PQ8.5 v1(63.07,30.15)
N24831965: length 2
  TOP w0.203: PR207.2 110.12,11.79 111.12,12.8 PU200.9
N25195948: length 7.5
  TOP w0.109: v1(357.21,36.29) 357.91,36.98 357.91,38.52 PC505.1
  TOP w0.254: PC505.1 357.26,39.71 356.55,40.43 PU500.16 357.09,41.27 357.25,41.43 357.25,41.57 357.1,41.72 PU500.17
N25195958: length 5.3
  TOP w0.109: v1(355.89,36.18) 356.3,36.18 356.63,36.51 356.63,38.56 356.39,38.8 356.37,38.8 PC513.1
  TOP w0.254: PC513.1 355.98,40.13 355.9,40.22 PU500.15
N25196046: length 2
  TOP w0.109: PR506.1 354.99,37.24 v1(354.78,37.04)
  TOP w0.508: PR506.1 354.97,38.11 PC514.2
N25196480: length 1.4
  TOP w0.109: PC501.1 v1(356.82,48)
N26820574: length 1.8
  TOP w0.109: PR705.1 79.51,23.99 v1(78.97,23.45)
N26821586: length 3.8
  TOP w0.109: PU700.7 68.88,25.95 68.34,26.49 v1(68.34,26.84) 68.34,27.23 68.55,27.45 PR717.2 PC711.2
N26821595: length 2.8
  TOP w0.109: PU700.8 67.71,24.43 66.78,25.35 PR719.2 PC712.2
N26822390: length 2.3
  TOP w0.203: PU700.25 72.66,23.23 72.81,23.08 v1(73.26,23.08) 74.22,23.08 PR708.1
N26822393: length 1.2
  TOP w0.109: PR708.2 v1(76.87,22.98)
N26927630: length 3
  TOP w0.254: UC1.BT25 248.93,27.22 248.93,25.87 248.84,25.78 v1(248.84,25.35) RC114.1
N26949736: length 1.6
  TOP w0.109: PU700.11 67.31,23.23 v2(67.14,23.07) PR710.2
N26949739: length 1.8
  TOP w0.109: PR711.2 67,22.31 67.53,22.83 PU700.12
N27025928: length 3
  TOP w0.109: T18.1 253.31,69.86 253.31,69.56 252.82,69.07 252.82,67.81 252.99,67.65 UC1.B30
N27025929: length 5.4
  TOP w0.109: UC1.C30 252.62,67.02 252.62,69.22 253.06,69.66 253.06,71.6 T19.1
N27025930: length 11.1
  TOP w0.109: T21.1 229.17,72.2 v2(230,71.38) ; UC1.G3 v2(232.97,63.61)
  IN1 w0.102: v2(230,71.38) 230,71.27 232.27,69 232.27,68.33 233.21,67.39 233.21,66.42 232.97,66.18 v2(232.97,63.61)
N27025931: length 9.2
  TOP w0.109: v2(229.36,64.78) 229.28,64.78 229.18,64.68 225.84,64.68 225.16,65.37 T20.1 ; UC1.J3 v2(232.32,63.61)
  IN3 w0.081: v2(232.32,63.61) 231.15,64.78 v2(229.36,64.78)
N27025932: length 7.6
  TOP w0.089: 254.2,25.08 254.2,25.31 253.74,25.77 253.74,25.94 253.72,25.97 253.72,26.81 253.74,26.83 253.74,27.15 253.81,27.21 253.81,27.44 253.77,27.48 253.77,27.75 UC1.BR31
  TOP w0.109: T24.1 255.56,23.07 254.93,23.69 254.68,23.69 254.2,24.17 254.2,25.08
N27025933: length 1.2
  TOP w0.109: v2(253.1,32.67) 253.1,32.66 UC1.BH30
  BOTTOM w0.109: v2(253.1,32.67) 252.61,32.67 T22.1
N27025934: length 8
  TOP w0.109: T23.1 257.16,22.93 256.06,24.04 256.06,26.2 255.85,26.41 255.85,26.74 255.47,27.12 255.47,27.47 255.88,27.88 UC1.BR35
N27025935: length 6.4
  TOP w0.109: UC1.D1 231.09,65.96 230.53,66.52 230.53,71.58 T1.1
N27025936: length 6.4
  TOP w0.109: T2.1 228.65,68.94 230.29,67.3 230.29,66.27 230.43,66.13 230.43,65.88 231.14,65.18 UC1.E1
N27025938: length 8.6
  TOP w0.109: UC1.E2 232,65.86 231.54,66.31 231.14,66.31 230.89,66.56 230.89,72.32 T4.1
N27025939: length 13.6
  TOP w0.109: UC1.BR1 230.86,27.4 v2(230.86,26.31)
  BOTTOM w0.109: v2(230.86,26.31) 229.57,26.31 228.34,25.08 220.43,25.08 T5.1
N27025940: length 11.8
  TOP w0.109: v2(231.52,26.91) 231.92,27.31 UC1.BT2
  BOTTOM w0.109: T6.1 221.47,25.31 228.24,25.31 229.84,26.91 v2(231.52,26.91)
N27025941: length 11.6
  TOP w0.109: UC1.BN35 256.92,28.27 256.92,27.86 256.99,27.78 256.99,27.05 257.27,26.76 257.27,24.6 257.73,24.15 257.73,19.5 T7.1
N27025942: length 12.8
  TOP w0.109: T8.1 257.97,20.63 257.97,24.46 v2(258.06,24.55) ; UC1.BL34 v2(255.69,31.1)
  IN1 w0.102: v2(258.06,24.55) 258.06,26.94 256.74,28.26 256.74,29.07 255.69,30.12 v2(255.69,31.1)
N27025943: length 19.6
  TOP w0.109: v2(254.73,28.92) 254.69,28.92 UC1.BN33
  BOTTOM w0.109: T11.1 263.81,14.47 258.58,19.7 258.58,21.6 257.65,22.53 257.65,26.74 256.12,28.27 255.38,28.27 v2(254.73,28.92)
N27025944: length 9.5
  TOP w0.109: UC1.J24 248.26,62.15 v2(248.23,62.12)
  BOTTOM w0.109: T9.1 250.71,69.45 250.99,68.81 250.99,67.17 250.59,66.77 250.59,66.11 250.62,66.08 250.62,64.44 250.5,64.33 250.2,64.33 249.81,63.94 249.81,63.5 249.6,63.28 249.39,63.28 v2(248.23,62.12)
N27025945: length 11
  TOP w0.109: UC1.H24 248.72,62.9 248.72,62.14 v2(248.87,61.99)
  BOTTOM w0.109: v2(248.87,61.99) 248.87,62.36 249.44,62.94 249.88,62.94 250.2,63.26 251.18,63.26 251.43,63.51 251.43,67.27 252.1,67.94 252.1,69.09 T10.1
N27025946: length 1.6
  TOP w0.109: v2(240.43,54.02) 240.23,53.81 240.23,53.69 239.94,53.41 UC1.AA14
  BOTTOM w0.109: T12.1 239.98,53.56 v2(240.43,54.02)
N27025947: length 1.2
  TOP w0.109: UC1.AE29 251.6,50.39 v2(251.48,50.27)
  BOTTOM w0.109: v2(251.48,50.27) 251.3,50.08 T15.1
N27025948: length 5.2
  TOP w0.109: v2(251.53,60.09) 251.82,60.09 UC1.N29
  BOTTOM w0.109: T14.1 250.7,62.81 251.61,62.81 252.17,62.24 252.17,60.72 v2(251.53,60.09)
N27025949: length 29.1
  TOP w0.109: UC1.R14 240.41,57.98 240.76,58.33 240.76,60.7 240.76,60.7 240.76,61.25 240.99,61.48 v2(241.12,61.48)
  BOTTOM w0.076: 233.96,66.71 234.71,66.71 235.15,66.27 235.27,66.27 236.29,65.25 236.29,64.76 236.66,64.39 237.68,64.39 238.21,63.85 238.84,63.85 239.1,64.11 239.34,64.11 239.62,63.83 239.62,63.28 239.43,63.09 239.43,62.73 239.85,62.31 239.85,61.99 240.36,61.48 v2(241.12,61.48)
  BOTTOM w0.109: T13.1 221.75,69.44 222.38,68.82 230.59,68.82 231.85,67.55 233.11,67.55 233.96,66.71
N27025953: length 1.2
  TOP w0.109: v2(251.53,43.07) 251.76,43.3 UC1.AP29
  BOTTOM w0.109: v2(251.53,43.07) 251.91,43.45 T28.1
N27025954: length 1.1
  TOP w0.109: v2(240.21,42.98) 239.84,43.35 UC1.AP14
  BOTTOM w0.109: T27.1 240.21,43.21 v2(240.21,42.98)
N27025955: length 24
  TOP w0.109: UC1.BK28 250.87,31.54 v2(250.8,31.54)
  BOTTOM w0.109: T29.1 262.89,14.73 257.99,19.62 257.99,21.52 257.18,22.33 257.18,26.49 255.91,27.76 253.45,27.76 252.44,28.77 252.44,29.39 251.48,30.35 251.48,30.87 250.82,31.54 v2(250.8,31.54)
N27025956: length 26.7
  TOP w0.109: UC1.BJ28 250.85,32.21 v2(250.85,32.3)
  BOTTOM w0.109: v2(250.85,32.3) 251.41,31.74 251.41,31.28 252.05,30.63 252.05,30.11 252.68,29.49 252.68,28.87 253.54,28.01 256.04,28.01 257.42,26.63 257.42,22.43 258.23,21.62 258.23,19.72 264.28,13.66 T30.1
N27028301: length 24.3
  TOP w0.109: v2(162.38,30.14) v1(162.38,30.71)
  IN3 w0.081: v2(152.65,24.37) 153.16,24.88 159.18,24.88 162.38,28.08 v2(162.38,30.14)
  BOTTOM w0.109: UZ26.4 161.87,31.75 162.3,31.32 RZ120.2 162.38,30.78 v2(162.38,30.14) ; UZ34.4 150.01,19.99 150.29,20.27 152.6,20.27 153.2,20.87 153.2,24.06 152.88,24.37 v2(152.65,24.37)
N27099309: length 1.2
  TOP w0.109: v2(239.49,42) 239.49,41.85 UC1.AT13
  BOTTOM w0.109: T26.1 239.09,42 v2(239.49,42)
N27099311: length 1.7
  TOP w0.109: UC1.AW13 239.44,39.4 239.44,39.33 v2(239.49,39.28)
  BOTTOM w0.109: v2(239.49,39.28) 238.99,38.78 T25.1
N27099349: length 1.1
  TOP w0.109: UC1.AU13 239.44,40.32 239.44,40.25 v2(239.49,40.2)
  BOTTOM w0.109: v2(239.49,40.2) 239.49,40.62 T31.1
N27099351: length 1.1
  TOP w0.109: v2(239.49,38.37) 239.16,38.71 UC1.AY13
  BOTTOM w0.109: v2(239.49,38.37) 239.82,38.7 T32.1
N27121902: length 4.5
  TOP w0.109: v1(150.92,125.07) 151.1,124.9 RV832.1 151.89,123.01 152.42,122.48 UV64.48
N27182711: length 1.9
  TOP w0.109: v1(303.36,32.37) 303.25,32.49 PR1137.2
  TOP w0.254: PC1119.1 303.34,33.44 PR1137.2
N27232717: length 1.2
  TOP w0.102: UH1.R15 138.31,41.9 v2(138.05,41.9)
  BOTTOM w0.109: T60.1 138.4,42.26 v2(138.05,41.9)
N27232718: length 3.1
  TOP w0.102: v2(137.97,42.59) 138.14,42.41 UH1.R13
  BOTTOM w0.109: v2(137.97,42.59) 138.57,43.18 139.43,43.18 139.76,42.85 T61.1
N27232720: length 1.1
  TOP w0.102: v2(129.31,31.82) 129.31,31.81 UH1.AN35
  BOTTOM w0.109: T62.1 128.94,31.82 v2(129.31,31.82)
N27232721: length 1.5
  TOP w0.102: UH1.AL37 v2(130.4,31.07)
  BOTTOM w0.109: v2(130.4,31.07) 130.63,31.07 T63.1
N27232838: length 2.1
  BOTTOM w0.109: v1(99.5,25.99) 99.98,25.51 RH28.2 100.5,26.39 CH321.1
N27232839: length 0.8
  BOTTOM w0.109: CH322.1 121.18,24.2 RH29.2
N27234698: length 2.5
  BOTTOM w0.109: RH101.2 168,96.06 SW1.2
N27267303: length 1.3
  TOP w0.102: UH1.Y35 136.31,31.94 v2(136.73,31.52)
  BOTTOM w0.109: v2(136.73,31.52) 137.1,31.52 T34.1
N27267305: length 1.8
  TOP w0.102: UH1.Y36 136.52,31.17 v2(136.75,30.94)
  BOTTOM w0.109: T33.1 137.36,30.11 137.36,30.5 v2(136.75,30.94)
N27267307: length 8.1
  TOP w0.109: UH1.BC1 124.45,48.85 123.87,48.85 122.72,50 121.16,50 119.83,51.33 119.83,52.51 119.45,52.89 T36.1
N27267309: length 1.3
  TOP w0.102: v2(130.4,31.92) 130.53,31.92 130.61,31.84 UH1.AL35
  BOTTOM w0.109: T35.1 130.4,31.79 v2(130.4,31.92)
N27271302: length 1.2
  TOP w0.152: UH1.U13 137.09,42.76 v2(136.98,42.76)
  BOTTOM w0.109: T40.1 137.07,42.76 v2(136.98,42.76)
N28152235: length 4.4
  TOP w0.127: v1(306.78,32.64) 306.46,32.96 306.46,33.25 305.99,33.72 PR1128.1
  TOP w0.203: PR1128.1 PC1111.2 306.07,35.07 PC1112.2 PR1127.2
N28152401: length 6
  TOP w0.109: PC1128.2 297.08,48.3 v1(297.24,48.47)
  TOP w0.203: 297.84,46.12 297.46,46.12 PR1150.2 PC1128.2 ; 298.7,45.53 299.68,44.55 PU1100.15
  TOP w0.254: 297.84,46.12 298.42,45.53 298.7,45.53
N28152437: length 3
  TOP w0.203: v2(304.81,46.39) 304.81,46.32 304.75,46.25 PU1100.3
  BOTTOM w0.109: v2(304.81,46.39) v1(305.34,46.39)
  BOTTOM w0.203: v2(304.81,46.39) 304.7,46.28 PC1118.2 304.1,46.31 PR1132.2
N28152465: length 3.7
  TOP w0.203: PU1100.36 v2(304.35,38.5)
  BOTTOM w0.109: v2(304.35,38.5) v1(303.82,38.5)
  BOTTOM w0.203: PC1120.1 PR1135.1 304.8,38.95 v2(304.35,38.5)
N28152580: length 4.9
  TOP w0.203: PC1140.1 PR1107.1 310.38,50.1 310.87,50.59 v1(310.87,51.32) 310.39,51.81 PC1103.2 309.9,51.8 PR1106.2
N28152729: length 4.4
  TOP w0.152: PC1105.1 308.46,49.48 307.97,49.96 v1(307.71,49.96)
  TOP w0.203: PR1108.2 309.89,50.91 PC1103.1 309.9,50.25 309.5,49.84 PR1109.1 PC1105.1
N28152784: length 4.6
  TOP w0.203: PC1130.1 PR1151.2 297.79,45.35 298.32,44.82 v1(298.65,44.82) 298.94,44.82 299.62,44.15 PU1100.16
N28152844: length 38.4
  TOP w0.109: v1(294.93,40.29) 295.26,40.61 v2(295.34,40.61)
  TOP w0.203: PH1104.1 290.71,12.14 v2(291.21,12.65) ; PR1166.2 PR1168.1 295.34,40.82 v2(295.34,40.61)
  IN1 w0.203: v2(291.21,12.65) 292.31,12.65 295.93,16.27 297.25,16.27 299.54,18.56 v2(299.54,25.92)
  IN4 w0.203: v2(299.54,25.92) 299.54,32.65 294.84,37.35 294.84,39.51 295.34,40.01 v2(295.34,40.61)
N28152958: length 50.5
  TOP w0.254: v2(280.21,13.71) 280.23,13.68 PH1102.2 ; PR1141.2 302.71,34.94 302.71,33.36 PR1144.1 302.21,33.47 302.21,33.54 302.08,33.67 v2(302.08,34.3)
  BOTTOM w0.254: v2(302.08,34.3) 303.79,34.3 305.64,32.45 305.64,28.98 299.82,23.15 v1(299.82,20.63) 299.82,18.14 298.58,16.9 298.58,15.6 293.81,10.84 287.65,10.84 287.49,11 283.12,11 281.58,12.54 281.58,13.38 281.15,13.81 280.31,13.81 v2(280.21,13.71)
N28153073: length 54.8
  TOP w0.109: PR1101.1 v2(311.86,42.98)
  TOP w0.152: v2(276.63,62.68) 276.63,62.68 PH1100.2
  IN1 w0.152: v2(276.63,62.68) 276.63,62.91 277.16,63.44 278.41,63.44 278.89,62.96 285.17,62.96 285.42,62.7 296.01,62.7 297,61.71 297.1,61.61 308.33,61.61 311.25,58.7 311.25,51.49 312.34,50.4 312.34,43.46 v2(311.86,42.98)
N28153459: length 10.4
  TOP w0.305: v2(295.98,48.66) 295.98,49.8 292.75,53.04 v1(292.05,53.04) PH1103.1
  BOTTOM w0.254: PR1167.1 295.73,47.44 295.81,47.51 PR1165.2
  BOTTOM w0.305: v2(295.98,48.66) 295.15,47.82 PR1167.1
N28153589: length 2.5
  TOP w0.109: PU1100.43 306.72,41.35 307.08,40.99 v1(307.38,40.99) 307.69,40.99 307.83,41.13 PR1198.1
N28153954: length 2.6
  TOP w0.109: v1(304.15,51.21) PC1115.1
  TOP w0.203: PC1115.1 304.14,49.52 PR1133.2
N28154016: length 3.9
  BOTTOM w0.152: PR1122.2 304.88,52.34 v1(304.99,52.45)
  BOTTOM w0.203: PC1109.1 305.68,49.82 PC1110.1 305.7,50.54 305.7,51.4 PR1123.1 304.9,51.4 PR1122.2
N28154283: length 25.9
  TOP w0.152: PH1101.2 279.85,52.44 v2(279.83,52.42)
  TOP w0.203: v2(301.72,50.24) 302.02,50.54 302.28,50.54 302.37,50.45 PR1140.2 302.4,50.4 PR1142.1
  IN4 w0.152: v2(279.83,52.42) 280.67,53.25 292.96,53.25 295.78,50.43 301.53,50.43 v2(301.72,50.24)
N28180064: length 3.4
  TOP w0.109: v1(311.97,47.65) 311.74,47.89 310.42,47.89 309.9,47.37 PR1118.2
  TOP w0.203: PR1118.2 308.94,47.37 PC1107.1
N28185893: length 2.1
  TOP w0.109: PC1116.1 305.13,33.74 v1(305.62,33.25)
  TOP w0.203: PC1116.1 305.11,34.31 PR1134.2
N28185971: length 2
  TOP w0.109: v1(306.52,50.57) 306.78,50.32 PC1114.1
  TOP w0.203: PC1114.1 306.75,49.55 PR1130.2
N31547518: length 15.2
  TOP w0.109: UV64.54 150.21,119.75 v2(149.88,120.08) ; v2(144.88,126) v1(144.88,128.35) RV900.2 144.14,129.34 144.02,129.22 QV43.1
  IN2 w0.081: v2(144.88,126) 146.33,126 148.79,123.54 148.79,122.16 149.88,121.07 v2(149.88,120.08)
N42077965: length 1.4
  TOP w0.109: v1(291.96,60.91) 291.79,60.75 PC1214.2
N42077969: length 2.9
  TOP w0.109: PR1201.1 292.03,58.35 292.67,57.71 293.98,57.71 v1(294.32,58.05)
N42077993: length 5.1
  TOP w0.109: PC1213.2 293.92,57.2 v1(294.36,56.76)
  TOP w0.254: PR1200.2 291.78,57.2 290.8,56.23 290.5,56.23 290.41,56.14 PU1200.3
  TOP w0.508: PC1213.2 PR1200.2
N42078041: length 1.2
  TOP w0.109: PC1224.2 v1(292.02,49.76)
N42078055: length 3.3
  TOP w0.109: v1(294.6,47.49) 294.6,47.39 293.89,46.67 292.68,46.67 PR1204.1
N42078421: length 2.3
  TOP w0.109: v1(294.27,59.58) PC1214.1
  TOP w0.508: PR1201.2 293.19,58.37 PC1214.1
N42078543: length 2.9
  BOTTOM w0.109: PC1216.2 v1(281.66,54.62)
  BOTTOM w0.508: PR1202.1 282.84,55.51 PC1216.2
N42078657: length 2.4
  TOP w0.109: v1(293.42,49.77) PC1224.1
  TOP w0.508: PC1224.1 293.42,47.34 PR1204.2
N42078671: length 5
  TOP w0.109: v1(294.68,46.17) PC1223.2
  TOP w0.254: PU1201.3 291.36,45.39 PR1205.2 292.13,46.17 PC1223.2
N42078715: length 3.4
  BOTTOM w0.109: v1(283.04,45.29) PR1206.1
  BOTTOM w0.508: PR1206.1 284.68,44.66 PC1226.2
N43928883: length 2.2
  TOP w0.109: PQ704.6 77.82,18.18 v1(78.05,18.42)
  TOP w0.381: PQ704.6 77.05,18.65 77.19,18.79 PR721.2
N50023717: length 3.9
  TOP w0.109: UC1.BP13 239.37,28.62 238.96,28.21 238.96,27.32 239.09,27.19 239.09,26.51 238.58,26 T199.1
N50024616: length 3.5
  TOP w0.109: T194.1 255.35,70.76 255.35,69.61 254.8,69.06 254.8,68.4 255.01,68.19 UC1.A33
N50626069: length 4.4
  BOTTOM w0.109: v1(36.29,30.22) 35.91,29.83 35.91,28.13 36.23,27.81 PQ2102.6
  BOTTOM w0.254: PR2134.2 37.09,27.81 PQ2102.6
N50626073: length 6.6
  BOTTOM w0.109: PQ2101.2 35.62,33.23 v1(35.46,33.06)
  BOTTOM w0.508: PQ2101.2 37.1,29.85 37.65,29.3 PR2134.1 PR2100.2
N50626131: length 11.2
  TOP w0.254: PR2101.2 37.13,34.7 PC2100.2 37.03,34.68 36.79,34.93 v2(36.45,34.93) 36.45,33.01 36.63,32.83 PQ2100.4
  BOTTOM w0.254: PQ2101.1 38.05,33.67 37.79,33.92 37.79,35.61 PR2108.1 36.91,35.69 v1(36.73,35.5) 36.45,35.22 v2(36.45,34.93)
N50626325: length 3.5
  BOTTOM w0.305: PR2142.2 43.2,29.81 42.77,29.38 42.52,29.38 42.16,29.02 42.16,27.86 42.47,27.56 PQ2106.6
N50626329: length 1.8
  BOTTOM w0.109: 42.95,31.74 43,31.74 43.77,30.96 v1(44.45,30.96)
N50626379: length 7.6
  TOP w0.254: v2(39.99,34.91) 40.54,34.36 PR2105.2 PC2102.2 40.54,33.06 40.8,32.79 41.41,32.79 41.61,32.59 PQ2104.4
  BOTTOM w0.254: v2(39.99,34.91) v1(40.38,35.3) 40.66,35.57 PR2109.1 41.98,34.99 PQ2105.1
N50640713: length 18.6
  TOP w0.109: v2(95.79,24.42) v1(96.48,25.12) 96.7,25.33 96.7,27.84 PR2161.2 96.61,27.93 PQ2109.6
  IN4 w0.102: v2(85.85,18.89) 87.27,18.89 88,19.62 88,20.26 89.53,21.78 89.85,21.78 91.72,23.65 94.27,23.65 94.49,23.43 95.33,23.43 95.79,23.9 v2(95.79,24.42)
  BOTTOM w0.109: v2(85.85,18.89) 85.88,18.91 PR21.1
N50640786: length 18.6
  BOTTOM w0.109: PR2145.1 84.11,26.16 v1(84.93,25.35) 85.04,25.24 86.97,25.24 88.73,27 89.25,27 89.61,27.36 PL4.1 89.85,27.61 90.85,26.61 PQ2108.3 92.24,26.61 92.47,26.84 93.94,26.84 PR2143.1 95.31,25.67 95.31,26.58 95.98,27.26 96.85,27.26 97.58,26.52 PR2162.1
N50645864: length 26.1
  TOP w0.109: PQ2109.3 94.8,30.25 94.8,28.42 95.35,27.87 95.35,24.57 v2(95.21,24.42)
  IN4 w0.102: v2(84.53,23.79) 85.01,23.79 85.99,22.81 90.49,22.81 91.96,24.29 95.08,24.29 v2(95.21,24.42)
  BOTTOM w0.109: PU2004.3 83.12,26.35 PR2145.2 83.41,26.05 83.41,25.35 82.83,24.77 PC2104.1 PR2144.1 83.13,23.64 83.64,24.14 v1(83.93,24.14) 84.17,24.14 v2(84.53,23.79) 84.4,23.66 PR2148.1
N50646290: length 3.5
  BOTTOM w0.109: PR2147.2 PC2105.1 PR2146.1 83.11,27 PU2004.2
N50692210: length 1.8
  TOP w0.109: PR714.2 66.94,24.59 v2(67.09,24.45) 67.5,24.03 PU700.9
N50714647: length 4.8
  BOTTOM w0.109: PR2150.2 34.87,26.53 35.35,27.02 35.35,28.26 ; v1(34.97,30.23) 35.35,29.85 35.35,28.26 ; 35.35,28.26 35.15,28.46 34.81,28.46
N50715082: length 2.2
  BOTTOM w0.305: PR2106.2 39.72,26.71 40.32,27.31 40.32,27.77 40.76,28.21 PQ2106.2
N51087553: length 6.4
  TOP w0.109: v1(326.32,1.6) 326.32,1.98 325,3.31 PC533.1
  TOP w0.254: PC533.1 324.86,3.98 324.27,4.57 PU501.16 324.78,5.45 324.89,5.57 324.89,5.83 324.82,5.9 PU501.17
N51087711: length 1.2
  TOP w0.109: v1(323.07,1.27) 323.48,1.68 PR513.1
N51088117: length 2.4
  TOP w0.109: PR514.2 v1(323.29,11.86)
  TOP w0.508: PC531.1 PR514.2
N51093717:
  vias: v1(49.98,5.9)
N51093758: length 1.9
  BOTTOM w0.109: v1(52.16,2.69) 51.94,2.91 PR114.1
  BOTTOM w0.381: PR114.1 52.76,3.63 PC128.2
N51093811: length 2.9
  BOTTOM w0.109: v1(49.43,12.75) 50.14,12.04 PC115.1
  BOTTOM w0.508: PC115.1 50.79,12.03 PR111.2
N51093813: length 7.2
  TOP w0.508: PR105.1 129.08,111.42 128.66,111 128.66,109.49 129.36,108.79 131.65,108.79 131.96,109.11 PR104.1
  vias: v1(134.1,109.31)
N51093882: length 1.8
  TOP w0.109: v1(131.71,111.03) PR106.1
  TOP w0.508: PR106.1 PC112.2
N51093922: length 2.4
  TOP w0.109: v1(141.46,110.81) PC110.1
  TOP w0.508: PC110.1 140.31,112.04 PR101.2
N51431640: length 8
  TOP w0.109: PQ705.1 89.48,38.25 v1(88.4,39.32)
  TOP w0.254: PQ705.1 89.48,35.54 v2(89.19,35.25) 89.94,34.51 89.94,34.47 PR732.1 PR731.2
  BOTTOM w0.254: v2(89.19,35.25) 88.91,35.25 88.53,34.88 PQ700.4
N51464097: length 3.9
  BOTTOM w0.109: v1(35.51,9.78) 35.51,10.35 35.82,10.67 35.94,10.67 36.35,11.08 36.35,11.47 36.55,11.67 PR2152.2
  BOTTOM w0.254: PR2152.2 36.29,12.18 36.06,12.41 PQ2110.2
N51464100: length 1.9
  BOTTOM w0.109: v1(31.87,12.45) PR2153.2
  BOTTOM w0.254: PQ2110.5 33.39,12.41 33.35,12.45 PR2153.2
N51464118: length 3.4
  BOTTOM w0.109: v1(38.87,9.07) 38.87,10.2 38.22,10.86 PQ2112.2
  BOTTOM w0.254: PQ2112.2 37.4,10.86 37.37,10.82 PR2154.2
N51464121: length 2.3
  BOTTOM w0.109: PQ2112.5 40.51,10.86 40.57,10.92 PR2157.2 41.21,10.92 v1(41.78,10.35)
N51464131: length 3
  BOTTOM w0.109: v1(39.62,12.75) 39.62,12.63 40.55,11.7 PR2156.2 40.75,11.7 41.19,12.14 41.89,12.14 PQ2111.5
N51464171: length 2.1
  BOTTOM w0.109: PR2155.2 45.55,12.02 v1(45.73,12.19)
  BOTTOM w0.254: PQ2111.2 44.03,12.13 44.15,12.02 PR2155.2
N51851482: length 13
  TOP w0.109: v2(256.45,24.48) 257.49,23.44 257.49,19.86 T297.1 ; v2(253.77,30.34) 253.69,30.34 253.42,30.61 UC1.BL31
  IN1 w0.102: v2(256.45,24.48) 255.88,25.05 255.88,26.76 254.35,28.29 254.35,29.76 v2(253.77,30.34)
N51851500: length 12.7
  TOP w0.109: T298.1 225.73,46.77 v2(225.73,47.37) ; v2(236.23,47.46) UC1.AJ8
  IN2 w0.081: v2(225.73,47.37) 225.73,47.47 226.26,48 235.7,48 v2(236.23,47.46)
N51851520: length 22.3
  TOP w0.109: UC1.G13 239.92,64.37 v2(240,64.37)
  BOTTOM w0.076: 234.64,67.01 235.21,66.44 235.34,66.44 236.45,65.32 236.45,64.83 236.61,64.67 237.62,64.67 238.28,64.02 238.66,64.02 239.01,64.37 v2(240,64.37)
  BOTTOM w0.109: T299.1 222.74,69.48 230.45,69.48 231.34,68.59 231.58,68.59 232.22,67.95 233.7,67.95 234.64,67.01
N51851540: length 6.7
  TOP w0.109: UC1.C38 258.35,66.62 259,67.27 259,68.12 258.31,68.81 258.31,70.14 259.79,71.62 T300.1
N51851560: length 5.1
  TOP w0.109: T301.1 231.35,71.24 UC1.C1
N51851580: length 14.9
  TOP w0.109: v2(230.41,25.85) 230.41,27.46 231.21,28.26 231.82,28.26 UC1.BR2
  BOTTOM w0.109: T302.1 220.25,24.84 228.44,24.84 229.45,25.85 v2(230.41,25.85)
N51851600: length 13.1
  TOP w0.109: v2(229.93,25.38) 229.93,26.47 230.12,26.65 230.12,27.49 231.24,28.62 UC1.BP1
  BOTTOM w0.109: T303.1 221.31,24.6 228.54,24.6 229.31,25.38 v2(229.93,25.38)
N51851620: length 5.5
  TOP w0.109: UC1.B38 258.63,67.4 258.81,67.57 258.81,68.05 258.13,68.73 258.13,70.35 258.29,70.51 258.29,71.55 T304.1
N51851640: length 5
  TOP w0.109: UC1.B2 232.01,69.15 232.86,70 232.86,71.39 T305.1
N52218840: length 3.7
  TOP w0.203: PR1170.2 298.84,38.11 v1(298.99,38.27) 299.48,38.75 300.43,38.75 300.75,39.07 PU1100.27
N52320463: length 18.2
  TOP w0.109: JDGFF2.E2 247.55,88.12 247.97,87.7 247.97,87.33 247.68,87.04 247.39,87.04 247.17,86.81 247.17,86.37 246.5,85.71 243.78,85.71 v1(243.08,85.02) 242.65,84.58 237.47,84.58 237.19,84.3 234.87,84.3 v2(234.32,83.74)
  BOTTOM w0.109: DV44.2 233.65,83.07 v2(234.32,83.74)
N54556025: length 4.3
  TOP w0.109: PD11.2 86.97,26.88 86.52,27.33 v1(86.52,29.31)
  TOP w0.254: PR8.2 87.09,26.14 87.48,26.53 PD11.2
N54556028: length 5.3
  TOP w0.109: v1(85.02,28.51) 85.58,27.96 PD11.1
  TOP w0.381: PD11.1 85.58,27.25 85.31,26.98 84.61,26.98 84,26.37 84,24.53 PQ3.6
N54556584: length 2.6
  TOP w0.109: PD12.2 51.65,25.15 v1(50.89,24.39)
  TOP w0.254: PR33.2 51.94,25.19 PD12.2
N54556800: length 2.2
  TOP w0.254: PD12.1 53.02,25.27 PQ6.6
N54556836: length 1.6
  BOTTOM w0.254: PD13.2 50.05,32.83 50.05,32.15 PR51.2
N61680769: length 3.5
  BOTTOM w0.109: v1(52.72,33.52) 52.44,33.52 52.15,33.82 PD13.1
  BOTTOM w0.254: PD13.1 50.81,33.02 PQ9.6
N61687377: length 1
  TOP w0.508: PC405.1 161.27,89.83 161.09,89.65 PR403.2
N61688443: length 45.5
  TOP w0.109: v2(132.03,15.51) 129.55,15.51 128.66,16.4 125.37,16.4 124.2,17.57 119.03,17.57 118.3,18.3 117.42,18.3 117.17,18.56 117.17,19.55 117.09,19.63 116.01,19.63 114.89,20.74 114.89,20.95 114.65,21.19 112.21,21.19 111.94,21.47 111.94,23.71 112.09,23.87 112.09,25.31 111.83,25.57 111.83,25.82 111.55,26.1 v1(111.26,26.1) PR809.2 PR807.2 ; PR810.1 140.6,19.88 140.6,17.35 139.55,16.3 137.96,16.3 137.23,15.57 136.63,15.57 136.01,14.94 135.71,14.94 135.64,14.87 135.64,14.7 134.69,13.76 v2(134.69,13.35)
  IN1 w0.102: v2(134.69,13.35) 134.19,13.35 v2(132.03,15.51)
N61690744: length 2.5
  TOP w0.109: PR903.2 104.8,23.46 v1(104.4,23.85)
  TOP w0.254: PC903.1 105.56,22.52 PR903.2
N61692023: length 0.8
  BOTTOM w0.109: v2(290.79,26.62) 290.4,26.62 v1(290.08,26.94)
N61692025:
  vias: v2(291.02,26.02)
N61692045: length 4.9
  TOP w0.109: PC1244.2 293.4,25.27 294.22,24.45 v1(294.31,24.45)
  TOP w0.305: PU1203.3 291.26,24.61 PR1212.2 293.13,25.27 PC1244.2
N61692067: length 7
  TOP w0.109: v1(278.75,32.25) 278.15,31.65 PR1215.1
  TOP w0.381: PL1205.3 278.39,26.92 278.66,27.19 278.66,29.35 278.15,29.86 PR1215.1
N61692081: length 2.2
  TOP w0.109: PR1211.2 v1(294.19,26.37)
  TOP w0.508: PC1243.1 293.17,26.39 PR1211.2
N61692131: length 2.9
  BOTTOM w0.109: PR1213.1 v1(282.53,25.86)
  BOTTOM w0.508: PC1246.2 PR1213.1
N61692583: length 6.3
  TOP w0.109: v1(277.45,32.31) 278.11,32.97 PR1214.1
  TOP w0.305: PL1204.3 277.82,37.61 278.11,37.33 PR1214.1
N61692600: length 3
  TOP w0.109: v1(294.46,37.42) 294,36.96 292.55,36.96 PR1209.1
N61692604: length 1.4
  TOP w0.109: PC1233.2 291.9,39.61 v1(292.31,40.03)
N61692626: length 2.3
  TOP w0.109: v1(294.35,38.78) 293.29,38.78
  TOP w0.508: PR1209.2 293.29,37.63 PC1233.1
N61692634: length 4.9
  TOP w0.109: PC1234.2 294.08,36.45 v1(294.41,36.12)
  TOP w0.254: PC1234.2 293.18,36.42 PR1208.2 291.23,35.66 PU1202.3
N61692676: length 3.2
  BOTTOM w0.109: v1(283.16,36.4) PR1210.1
  BOTTOM w0.508: PR1210.1 285.19,35.89 285.19,35 PC1236.2
N61733264: length 14.2
  TOP w0.109: v2(51.76,32.59) 51.89,32.71 PD14.1 51.89,34.61 v1(52.31,35.03) ; v2(54.18,26.95) 53.86,27.27 53.86,28.84 53.92,28.91 PQ4.2
  IN1 w0.102: v2(54.18,26.95) 51.56,26.95 50.92,27.59 50.92,31.69 51.76,32.53 v2(51.76,32.59)
N61733291: length 8.8
  TOP w0.109: v1(46.63,32.36) 47.05,32.78 v2(47.32,32.78) PD15.1
  IN4 w0.102: v2(52.02,28.72) 47.95,32.78 v2(47.32,32.78)
  BOTTOM w0.109: v2(52.02,28.72) 51.75,28.98 PQ7.2
N61859075: length 3.2
  TOP w0.203: v2(67.16,20.09) 67.16,20.26 67.54,20.64 68.63,20.64 68.88,20.89 PU700.15
  TOP w0.254: v2(67.16,20.09) 67.16,19.81 67.33,19.64 PR724.2
N63151956: length 4.1
  TOP w0.102: 121.76,38.24 122,38 123.12,38 123.3,38.18 124.08,38.18 124.21,38.31 124.83,38.31 UH1.BC22
  TOP w0.109: T307.1 121.23,38.55 121.54,38.24 121.76,38.24
N63151958: length 4.3
  TOP w0.102: UH1.BF23 123.35,37.75 121.98,37.75
  TOP w0.109: T306.1 119.67,37.7 120.46,37.7 120.8,38.04 121.68,38.04 121.98,37.75
N63155819: length 1.5
  TOP w0.102: UH1.Y14 136.61,42.3 v2(136.73,42.18)
  BOTTOM w0.109: v2(136.73,42.18) 136.45,42.18 T288.1
N63155821: length 1.1
  TOP w0.109: UH1.Y15 v2(136.76,41.52)
  BOTTOM w0.109: T289.1 137.09,41.85 v2(136.76,41.52)
N63155823: length 1.6
  TOP w0.102: v2(137.99,30.9) 137.82,31.07 UH1.U37
  BOTTOM w0.109: v2(137.99,30.9) 138.68,30.21 T290.1
N63155825: length 1.2
  TOP w0.109: UH1.U35 137.71,31.6 v2(137.99,31.6)
  BOTTOM w0.109: v2(137.99,31.6) 138.14,31.45 T291.1
N63155827: length 1.1
  TOP w0.102: UH1.AH15 v2(131.67,41.52)
  BOTTOM w0.109: T294.1 131.84,41.7 v2(131.67,41.52)
N63155829: length 1.2
  TOP w0.102: UH1.AH14 v2(131.65,42.3)
  BOTTOM w0.109: T295.1 131.65,42.87 v2(131.65,42.3)
N63156852: length 3.4
  TOP w0.109: v1(116.22,21.73) 116.22,21.35 116.66,20.9 QH6.1 117.36,20.9 118.52,22.07 RH433.2
N63173356: length 2.1
  TOP w0.109: T49.1 183.88,58.73 JDIMM2.165
N63173755: length 3.4
  TOP w0.109: JDIMM2.162 172.43,57.98 172.34,58.08 171.52,58.08 171.19,57.75 v2(171.19,57.52)
  BOTTOM w0.109: T48.1 171.19,57.94 v2(171.19,57.52)
N63181367: length 5.3
  BOTTOM w0.102: JDIMM3.162 195.59,57.98 200.16,57.98 T50.1
N63181369: length 2.2
  BOTTOM w0.109: JDIMM3.165 185.33,58.72 T51.1
N63187763: length 2.2
  TOP w0.109: JDIMM4.162 185.48,57.98 T52.1
N63187777: length 2.8
  TOP w0.102: T53.1 197.43,58.94 197.21,58.73 JDIMM4.165
N63193970: length 2.6
  BOTTOM w0.109: v1(388.05,46.6) 388.01,46.56 RI92.2 387.61,45.22 UI5.7
N63193981: length 2.3
  BOTTOM w0.109: UI5.24 381.91,45.22 v1(381.39,45.74) 381.38,45.75 RI93.2
N63195390: length 3.1
  TOP w0.109: UI2.16 381.49,38.38 381.45,38.42 RI71.2 380.91,39.56 380.55,39.92 v1(380.34,39.92)
N63195630: length 2.8
  TOP w0.109: v1(112.9,151.4) 112.9,151.1 113.43,150.56 RI79.2 113.87,150.26 114.1,150.03 UI3.16
N63195786: length 3.8
  TOP w0.109: RI14.2 380.07,58.74 378.9,58.74 v1(378.66,58.98)
  TOP w0.254: RI14.2 381.09,59.21 381.23,59.35 UI1.16
N63195930: length 3.2
  BOTTOM w0.109: UI4.7 383.85,55.89 RI76.2 385.19,57.23 v1(385.19,57.72)
N63195950: length 3.1
  BOTTOM w0.109: RI77.2 376.47,55.31 v1(377.22,56.05) 377.73,56.05 377.9,55.89 UI4.24
N63205753: length 5
  BOTTOM w0.109: v1(25.79,1.68) 24.19,1.68 23.96,1.9 RR237.1 23.96,2.46 23.53,2.9 23.53,3.11 23.19,3.44 UR3.3
N63206214:
  vias: v1(9.18,18.13) v2(8.53,17.44) v2(8.51,16.83) v2(8.66,16.25) v2(27.52,13.47) v2(27.81,14) v2(28.12,13.48)
N63206790: length 1.9
  BOTTOM w0.109: UR3.7 14.26,4.71 13.4,5.58 RR238.1
N63210465: length 1.8
  BOTTOM w0.254: UZ12.27 138.8,20.54 138.77,20.57 138.77,21.17 138.76,21.19 RZ62.1
N63261697: length 2.7
  BOTTOM w0.109: QE12.1 152.92,77.8 152.65,78.07 RE94.1 v1(150.92,78.07)
N63261780: length 23.3
  TOP w0.109: RE703.2 124.76,65.55 v1(125.05,65.26) 125.42,64.89 v2(126.21,64.89) ; UE1.M12 v2(142.01,70.08)
  IN4 w0.102: v2(142.01,70.08) 141.61,69.67 141.61,67.12 141.25,66.77 137.42,66.77 137.06,66.4 134.35,66.4 132.92,64.97 129.84,64.97 129.37,65.43 126.76,65.43 v2(126.21,64.89)
N63261795: length 10.7
  TOP w0.109: UE1.G4 v2(134.87,74.08) ; RE548.2 133.76,68.15 v2(133.73,68.19)
  BOTTOM w0.109: v2(134.87,74.08) 134.87,73.95 135.27,73.55 135.27,73.15 135.54,72.88 136.59,72.88 136.84,72.63 136.84,71.52 136.62,71.3 136.37,71.3 136.09,71.03 136.09,69.98 135.46,69.35 v1(134.38,69.35) 133.73,68.7 v2(133.73,68.19)
N63261829: length 2
  TOP w0.109: RE350.2 142.9,66.47 v1(142.62,66.19)
  TOP w0.254: RE350.2 CE57.1
N63264088: length 7.4
  TOP w0.109: RE57.1 129.6,82.73 130.41,81.92 RE58.1 130.72,81.7 130.76,81.7 130.99,81.47 130.99,81.35 131.21,81.12 131.62,81.12 131.83,81.33 132.32,81.33 v1(132.41,81.24) 133.09,80.56 133.09,79.84 132.87,79.62 132.69,79.62 132.46,79.39 132.46,78.83 UE1.B1
N63264181: length 3.3
  TOP w0.109: RE318.2 131.25,74.63 131.81,74.07 132.96,74.07 133.34,74.45 UE1.G2
N63264846: length 3.1
  TOP w0.109: v1(148.5,88.32) RE546.2 147.44,87.18 147.61,87.02 QE17.1
N63272832: length 3.2
  BOTTOM w0.109: QE11.3 158.72,59.51 158.95,59.28 159.35,59.28 RE90.1 RE70.1 v1(159.38,57.44)
N63272852: length 2.5
  BOTTOM w0.109: QE4.2 161.25,58.36 RE70.2 160.3,57.64 v1(160.78,57.15)
N63274676: length 4.2
  BOTTOM w0.109: UE12.4 163.1,74.13 163.18,74.06 CE342.1 163.55,74.42 163.71,74.58 v1(165.15,74.58)
N63282244: length 4.3
  TOP w0.203: UA1.33 385.36,24.01 385.98,24.64 v2(386.19,24.64) 386.46,24.91 RA213.1
  BOTTOM w0.109: RA213.1 v1(386.84,25.91)
  BOTTOM w0.203: RA213.1 386.46,24.91 v2(386.19,24.64)
N63282319: length 2.5
  TOP w0.203: 386.15,24.14 385.96,24.14 385.49,23.68 385.36,23.68 385.29,23.61 UA1.32
  TOP w0.254: CA25.2 386.6,24.14 386.15,24.14
N63282335: length 4.3
  TOP w0.203: 384.74,19.37 384.71,19.41 384.12,19.41 383.93,19.6 UA1.24
  TOP w0.381: CA232.1 CA29.1 385.49,18.86 v1(385.44,18.91) 384.99,19.37 384.74,19.37
N63282517: length 4.9
  TOP w0.203: v2(384.8,27.47) 384.52,27.47 383.53,26.49 UA1.38
  BOTTOM w0.381: CA35.2 386.27,28.25 v1(385.98,27.96) 385.49,27.47 v2(384.8,27.47)
N63282540: length 4.7
  TOP w0.203: UA1.39 383.13,25.97 383.13,26.65 v1(383.66,27.17) 384.71,28.22 CA51.2
  TOP w0.508: RA44.2 385.9,28.95 385.53,28.58 385.17,28.58 CA51.2
N63282645: length 3.8
  TOP w0.109: v2(390.56,21.27) 390.08,21.27 v4(389.81,21.01)
  TOP w1.016: JHP1.5 397.28,20 395.55,21.73
  vias: v2(390.57,21.88)
N63282767: length 2.8
  TOP w0.203: v1(382.85,18.71) 382.73,18.82 UA1.21
  TOP w0.381: CA52.2 383.49,17.72 382.85,18.36 v1(382.85,18.71)
N63282827: length 3.8
  TOP w0.203: UA1.23 383.53,19.34 383.82,19.05 383.98,19.05 v1(384.15,18.88)
  TOP w0.381: v1(384.15,18.88) 384.91,18.12 CA29.2 CA232.2
N63282834: length 2.6
  TOP w0.203: UA1.19 381.93,19.38
  TOP w0.254: CA53.2 381.55,18.33 v1(381.55,18.88) 381.55,18.99 381.93,19.38
N63282842: length 3
  TOP w0.109: v1(376.65,17.68) 377.32,17.02 CA33.1 378.15,17.02 378.34,16.83 378.79,16.83 RA17.2
N63302772: length 2.8
  TOP w0.254: UZ23.6 366.4,12.31 v2(366.55,12.46)
  BOTTOM w0.254: CZ130.1 365.7,12.46 v2(366.55,12.46)
N63303945: length 4.4
  BOTTOM w0.109: JNGFF3.10 328.35,29.79 329.04,29.1 RN217.1 329.87,28.52 v1(330.29,28.11)
N63303993: length 14.6
  TOP w0.076: 382,8.59 382,7.93 382,7.93 JNGFF4.10
  TOP w0.109: 382,8.59 381.72,8.87 381.72,10.25 381.24,10.73 381.24,11.3 380.59,11.95 v1(373.97,11.95) 372.6,11.95 371.73,12.82 RN218.1
N63304099: length 3.5
  TOP w0.109: UZ23.3 362.61,12.31 362.49,12.19 UZ60.4 361.65,11.82 v1(362.59,10.88)
N63307260: length 3
  BOTTOM w0.109: JNGFF5.10 326.4,55.1 v1(328.47,55.1) 329.41,55.1 RN216.1
N63307264: length 3.6
  TOP w0.109: v2(137.04,88.65) 136.71,88.97 v1(136.01,88.97) 135.74,88.69 RN474.1
  BOTTOM w0.109: JNGFF6.10 v2(137.04,88.65)
N63309556: length 1.9
  TOP w0.109: C193.2 147.54,106.24 147.54,105.33 147.62,105.25 147.63,105.24 UZ44.12
N63309591: length 2.5
  BOTTOM w0.109: UZ7.6 168.13,135.5 C195.1 v1(169.24,135.5)
N63309639: length 4.3
  TOP w0.109: UZ44.10 148.43,105.46 148.51,105.54 C192.2 148.51,106.43 149.02,106.94 149.02,107.62 v1(148.33,108.31)
N63309692: length 1.5
  TOP w0.109: UZ9.12 v2(331.23,19.43) 330.62,19.43 C202.2
N63309706: length 2.8
  TOP w0.109: UZ9.10 331.64,20.23 331.4,20.46 C201.2 330.6,20.86 v1(330.01,21.45)
N63309775: length 3
  BOTTOM w0.109: C207.1 v1(355.47,14.59)
  BOTTOM w0.254: C207.1 354.87,13.01 354.55,13.01 354.37,12.83 UZ58.6
N63309827: length 3.1
  BOTTOM w0.109: UZ59.6 127.33,83.79 126.96,84.16 C209.1 v1(125.94,85.24)
N63354804: length 2.2
  BOTTOM w0.109: YT1.1 30.01,37.93 29.75,38.19 CT21.1 30.58,38.57 RT394.2
N63359901: length 6.7
  TOP w0.109: v1(48.84,15.34) 48.4,15.79 47.58,15.79 46.88,15.08 45.52,15.08 QT2.2 45.13,14.69 RT546.1 44.44,14.59 RT545.1 CT375.1
N63359905: length 2.2
  TOP w0.109: RT546.2 43.07,14.69 v1(42.73,15.03) 42.41,15.35 QT4.6
N63359909: length 14.5
  TOP w0.508: QT2.3 44.64,12.95 RT545.2 CT375.2 43.55,12.68 43.01,12.14 41.48,12.14 41.01,11.67 RT547.1 40.21,11.06 40.03,11.24 RT548.2 37.3,11.24 36.62,11.92 v1(36.62,12.66) 37.12,13.16 37.12,13.69 37.42,14 QT3.3
N63359919: length 5.3
  TOP w0.109: CT376.1 RT550.2 43.44,15.51 v1(42.63,16.31) 41.79,16.31 41.02,15.55 41.02,15.13 41.45,14.7 QT4.5
N63359925: length 6.2
  TOP w0.109: RT548.1 38.97,11.81 v1(38.25,11.81)
  TOP w0.254: RT548.1 39.32,12.59 39.34,12.62 RT549.1 39.34,13.39 38.67,14.07 QT3.2 38.92,15.23 39.45,14.7 QT4.2
N63359927: length 2.2
  TOP w0.109: QT4.3 40.1,13.13 RT549.2 40.63,12.6 v1(41.2,12.6)
N63361205: length 7.4
  TOP w0.381: RT542.1 40.18,17.22 CT372.1 42.42,17.02 44.99,17.02 v1(45.49,16.52) 46.18,16.52 46.18,16.51 UT7.5
N63361207:
  vias: v1(45.3,17.88)
N63361304: length 16.8
  TOP w0.508: v2(46.68,22.24) 47.16,21.77 DT64.2 ; v2(54.71,13.66) 54.71,14.73 QT10.1
  IN1 w0.508: v2(54.71,13.66) 52.7,15.66 52.7,18.26 51.14,19.82 48.05,19.82 46.68,21.19 v2(46.68,22.24)
  BOTTOM w0.109: v1(46.96,21.38) 46.68,21.66 v2(46.68,22.24)
N63372869: length 5.9
  TOP w0.109: UV24.4 113.79,145.05 RV3.1 115.09,145.19 DV42.1 116.28,144.7 116.44,144.54 DV3.1 117.04,143.93 v1(116.66,143.55)
N63372900: length 6.2
  TOP w0.109: v2(112.53,144.29) 111.39,144.29 110.62,145.05 UV24.3
  BOTTOM w0.109: RV843.2 v1(112.53,145.06) v2(112.53,144.29)
N63373086: length 4.1
  TOP w0.109: LV1.1 124.24,116.39 122.81,117.82 v2(122.58,117.82) 122.1,117.82 121.7,118.22 JEDP1.18
N63496140: length 1.6
  TOP w0.254: UZ45.6 v2(336.27,13.19) 336.63,13.19 CZ121.1
N63496197: length 1.4
  TOP w0.109: UZ42.6 141.48,14.11 CZ521.2
N63496456: length 5.6
  TOP w0.109: UZ41.3 300.07,67.05 v2(300.17,66.94)
  BOTTOM w0.109: RZ549.2 RZ548.2 300.15,66.92 v2(300.17,66.94) 302.58,66.94 v1(303.21,67.58)
N63496796: length 2.3
  TOP w0.109: UZ42.3 137.76,14.11 137.13,13.48 136.73,13.48 136.61,13.59 RZ509.2
N63496843: length 2.3
  TOP w0.203: UZ40.12 369.12,34.96 v2(369.33,34.75) 369.76,34.75 CZ523.2
  BOTTOM w0.109: v1(369.97,35.27) 369.45,34.75 v2(369.33,34.75)
N63496855: length 1.4
  TOP w0.203: UZ40.10 v2(369.33,34.16) 369.82,34.16 CZ522.2
N63496880: length 2.7
  TOP w0.109: QZ20.1 131.89,85.93 v1(131.57,85.93) 131.45,85.81 RZ514.2
N63496917: length 3.3
  TOP w0.109: UZ43.6 91.64,57.67 91.36,57.95 91.36,58.61 CZ515.2 v1(91.89,60.2)
N63496989: length 2.2
  TOP w0.203: UZ41.12 296.75,67.05 v1(296.39,67.41) 295.69,67.41 CZ517.2
N63496991: length 4.5
  TOP w0.109: v1(293.61,67.86) 293.61,68.06 294.11,68.56 295,68.56 CZ516.2
  TOP w0.203: CZ516.2 296.47,68.09 296.7,67.85 UZ41.10
N63894512: length 5
  TOP w0.109: CA233.2 386.12,18.56 386.12,18.04 v1(386.34,17.81)
  TOP w0.203: 385.27,20.42 385.27,20.69 385.14,20.81 UA1.25
  TOP w0.381: 385.27,20.42 385.27,19.93 385.56,19.64 CA49.2 CA233.2
N64705983: length 105.5
  TOP w0.109: v2(129.74,20.78) 129.37,20.41 128.35,20.41 127.9,20.86 127.9,22.57 128.65,23.32 128.65,24.1 128.22,24.53 128.13,24.53 127.65,25.01 127.65,25.63 127.91,25.89 UH1.AU47
  IN2 w0.081: v2(129.74,20.78) 129.93,20.78 131.37,22.22 133.91,22.22 134.19,21.94 134.19,20.91 134.58,20.51 134.58,20.38 134.8,20.16 136.21,20.16 136.55,20.51 136.55,21.75 137.49,22.68 139.25,22.68 140.92,24.35 145.49,24.35 146.9,22.94 v2(147.42,22.94)
  IN3 w0.081: v2(164.01,72.18) 164.01,72 167.02,68.99 167.02,64.43 163.79,61.2 161.57,61.2 160.32,59.95 160.32,36.4 164.3,32.42 164.3,30.89 164.95,30.23 164.95,27.36 160.58,22.99 159.2,22.99 157.24,21.03 153.58,21.03 151.42,23.2 147.7,23.2 147.44,22.94 v2(147.42,22.94)
  BOTTOM w0.109: v1(164.36,71.74) 164.36,71.82 v2(164.01,72.18) 163.9,72.07 RH6.1
N64891293: length 2.4
  TOP w0.109: UE1.K12 v2(142.01,71.68)
  BOTTOM w0.109: v2(142.01,71.68) v1(142.57,71.68) 142.93,71.68 RE745.2
N64891506: length 1.8
  TOP w0.109: UE1.M11 v2(141.21,70.08)
  BOTTOM w0.109: RE746.1 141.36,69.93 v2(141.21,70.08) 141.21,70.08 v1(140.85,70.44)
N64891509: length 32
  TOP w0.109: UE1.H9 v2(139.61,73.28)
  IN4 w0.102: v2(139.61,73.28) 139.18,73.71 138.42,73.71 137.89,74.23 137.89,76.67 137.73,76.83 133.88,76.83 133.42,77.28 132,77.28 131.91,77.19 130.6,77.19 130,77.79 127.34,77.79 126.69,78.44 124.88,78.44 123.92,77.48 121.15,77.48 120.48,76.82 119.77,76.82 119.11,77.48 116.79,77.48 116.18,76.88 v2(115.3,76.88)
  BOTTOM w0.109: v2(115.3,76.88) v1(115.78,76.4) 116.37,75.81 RE743.1
N64894761: length 4.6
  TOP w0.109: v1(112.61,62.8) 112.76,62.96 112.76,63.68 113.42,64.34 RT456.2 RT445.2 114.06,65.23 114.23,65.05 UT32.1
N64894763: length 2.3
  TOP w0.109: UT32.3 114.42,63.75 114.06,63.39 RT448.2 v1(113.9,62.5)
N64894971: length 2
  TOP w0.109: v1(114.32,60.01) 114.6,60.29 RT500.2 114.81,61.04 UT34.2
N64983618: length 4.9
  TOP w0.109: v1(306.3,74.55) 306.22,74.55 305.32,75.45 RV50.1 305.25,75.51 304.62,76.14 304.19,76.14 304.06,76.27 303.48,76.27 302.97,76.78 UV8.20
N64983738: length 4.9
  TOP w0.109: v1(302.65,73.69) 302.65,73.98 302.95,74.27 302.95,75.02 303.43,75.5 CV75.1 302.56,76.41 302.19,76.41 301.77,76.83 UV8.17
N64988392: length 3.6
  BOTTOM w0.109: UV66.37 52.85,46.52 52.6,46.27 52.6,43.63 T315.1
N64988396: length 8.6
  TOP w0.109: T316.1 84.48,56.59 83.54,55.66 82.74,55.66 81.35,54.26 79.8,54.26 79.47,53.93 UV67.37
N65041103: length 3.9
  BOTTOM w0.109: v1(134.44,12.91) 133.98,13.36 133.98,15.2 134.34,15.56 CZ56.1 RZ63.1
N65096928: length 3
  BOTTOM w0.109: JNGFF3.8 328.19,30.29 328.49,29.99 RN219.1
N65096993: length 6.4
  TOP w0.109: JNGFF4.8 382.5,8.43 381.96,8.97 381.96,10.35 381.47,10.83 381.47,11.4 v1(380.31,12.56) 380.06,12.81 RN220.1
N65097064: length 4.7
  BOTTOM w0.109: JNGFF5.8 326.4,55.6 327.22,55.6 327.37,55.45 328.49,55.45 328.64,55.59 330.47,55.59 RN475.1
N65097129: length 2.8
  TOP w0.109: v2(137.62,88.65) 137.2,88.23 136.8,88.23 RN476.1
  BOTTOM w0.109: v2(137.62,88.65) 137.62,88.85 137.53,88.93 JNGFF6.8
N65689457: length 4.7
  TOP w0.109: UL1.2 156.77,138.03 157.41,137.4 157.41,136.11 v1(157.87,135.65) 158.32,135.21 RL10.2
N65690245: length 21.7
  TOP w0.109: RL19.2 v1(138.12,150.84) 143.28,150.84 JLOM1.B1
N65690269: length 21.3
  TOP w0.109: RL20.2 134.06,151.14 134.31,151.4 v1(136.13,151.4) 143.18,151.4 150.32,158.54 JLOM1.B3
N65690285: length 3.4
  BOTTOM w0.109: RL14.2 v1(137.81,158.45) 138.24,158.45 138.89,159.1 138.89,160.17 JLOM1.A2
N65693167: length 2.4
  BOTTOM w0.102: UT5.K11 22.73,35.37 22.81,35.37 23.01,35.58 23.01,36.07 23.61,36.67 23.71,36.67 RT608.2
N65693169: length 2.3
  BOTTOM w0.102: RT609.2 23.73,36.86 23.53,36.86 22.82,36.15 22.82,35.66 22.74,35.58 22.64,35.58 UT5.L11
N65693231: length 4.7
  BOTTOM w0.102: UT5.A10 22.04,30.67 22.26,30.45 22.26,30.37 22.96,29.67 22.96,29.44 v3(23.15,29.24) 23.45,28.95 23.58,28.95 23.84,28.69 23.84,28.46 24.7,27.6 24.92,27.6 RT606.1
N65693249: length 4.3
  BOTTOM w0.102: UT5.A11 22.53,30.67 22.45,30.59 22.45,30.45 23.15,29.75 23.15,29.52 23.53,29.14 23.66,29.14 24.03,28.77 24.03,28.59 24.79,27.83 24.9,27.83 RT607.1
N65693414: length 3.5
  BOTTOM w0.076: UT5.B8 20.79,30.93 20.79,30.36 21.85,29.29 21.85,28.7 RT589.1
N65693416: length 3.5
  BOTTOM w0.076: UT5.B9 21.28,30.92 21.28,30.38
  BOTTOM w0.109: 21.28,30.38 22.27,29.39 22.27,28.73 RT590.1
N65693455: length 5.9
  TOP w0.109: v2(37.58,22.28) 37.68,22.38 38.54,22.38 38.72,22.55 UT9.2
  BOTTOM w0.109: UT10.4 35.24,21.82 35.84,21.22 v1(36.13,21.22) 36.67,21.22 37.03,21.59 37.03,21.86 37.45,22.28 v2(37.58,22.28)
N65693509: length 2
  TOP w0.254: UT9.5 40.95,23.96 41.39,24.4 v2(41.39,24.57)
  BOTTOM w0.254: v2(41.39,24.57) 41.15,24.81 CT377.1
N65693585: length 14.1
  TOP w0.109: v1(35.55,26.23) 35.72,26.41 v2(36.12,26.41)
  IN1 w0.102: v2(36.12,26.41) 34.59,27.93 32.76,27.93 32.18,27.35 30.2,27.35 28.54,25.69 28.54,25.06 28.27,24.78 27.97,24.78 27.77,24.98 v2(27.53,24.98)
  BOTTOM w0.109: v2(27.53,24.98) 27.53,24.6 27.4,24.47 QT9.1 ; v2(36.12,26.41) 36.2,26.48 RT588.2
N65693599: length 23.6
  TOP w0.109: v2(44.65,29.99) v1(45.25,29.99)
  IN1 w0.102: v2(28.09,25.41) 28.09,26.04 31.06,29.01 32.42,29.01 33.14,28.29 34.92,28.29 36.52,26.68 39.8,26.68 40.69,27.57 42.24,27.57 v2(44.65,29.99)
  BOTTOM w0.109: QT8.1 28.9,25.03 28.52,25.41 v2(28.09,25.41) ; RT586.2 44.1,29.99 v2(44.65,29.99)
