# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CPU_DP1_AUXN: length 267.6
  TOP w0.076: UC1.E27 250.56,65.35 v2(250.23,65.03)
  IN2 w0.094: v2(54.05,57.7) 53.88,57.86 53.75,57.86 53.61,57.72 53.61,56.74 54.94,55.41 54.94,44.57 52.09,41.72 52.09,39.69 54.18,37.61 58.01,37.61 59.08,38.67 85.35,38.67 86.46,39.79 89.89,39.79 90.52,40.41 90.52,42.09 93.08,44.66 93.08,51.47 100.93,59.32 102.39,59.32 102.94,59.88 102.94,60.97 109.55,67.58 112.21,67.58 115.26,70.63 118.06,70.63 118.82,71.39 118.82,72.83 120.88,74.9 121.56,74.9 126,79.33 126,79.67 128.08,81.75 128.08,82.92 128.67,83.51 129.43,83.51 130.02,84.1 133.39,84.1 134.2,84.92 137.76,84.92 138.71,83.97 141.79,83.97 142,83.76 144.06,83.76 144.65,84.36 148.12,84.36 148.24,84.23 167.07,84.23 168.37,85.53 180.48,85.53 180.65,85.36 195.06,85.36 196.49,83.94 211.43,83.94 213.87,81.49 219.78,81.49 220.6,80.67 220.6,74.34 227.05,67.89 235.8,67.89 238.2,70.29 247.71,70.29 249.25,68.74 249.25,68.34 249.81,67.77 250.39,67.77 251.57,66.59 251.57,66.08 250.9,65.42 250.85,65.42 250.66,65.22 250.43,65.22 v2(250.23,65.03)
  BOTTOM w0.102: CV877.1 54.76,57.28 54.76,57.89 54.57,58.09 54.44,58.09 v2(54.05,57.7)
CPU_DP1_AUXN_C: length 1.8
  BOTTOM w0.102: UV66.59 54.8,55.33 54.9,55.44 54.9,55.58 54.65,55.83 54.65,56.14 CV877.2
CPU_DP1_AUXP: length 267.7
  TOP w0.076: UC1.D27 250.58,66 v2(250.24,65.66)
  IN2 w0.094: v2(250.24,65.66) 250.47,65.42 250.58,65.42 250.77,65.61 250.82,65.61 251.37,66.16 251.37,66.51 250.31,67.58 249.73,67.58 249.06,68.25 249.06,68.66 247.63,70.09 238.29,70.09 235.89,67.69 226.97,67.69 220.4,74.25 220.4,80.59 219.7,81.3 213.79,81.3 211.35,83.74 196.41,83.74 194.98,85.17 180.57,85.17 180.4,85.33 168.45,85.33 167.15,84.03 148.16,84.03 148.04,84.16 144.73,84.16 144.14,83.56 141.91,83.56 141.71,83.77 138.63,83.77 137.68,84.72 134.28,84.72 133.47,83.91 130.1,83.91 129.52,83.32 128.75,83.32 128.28,82.84 128.28,81.67 126.2,79.59 126.2,79.25 121.64,74.7 120.96,74.7 119.01,72.75 119.01,71.31 118.14,70.44 115.34,70.44 112.29,67.39 109.63,67.39 103.13,60.89 103.13,59.79 102.47,59.13 101.01,59.13 93.28,51.39 93.28,44.58 90.71,42.01 90.71,40.33 89.97,39.59 86.54,39.59 85.43,38.48 59.16,38.48 58.09,37.41 54.09,37.41 51.9,39.61 51.9,41.8 54.74,44.65 54.74,55.33 53.41,56.66 53.41,57.8 53.67,58.06 53.83,58.06 v2(54.05,58.28)
  BOTTOM w0.102: CV876.1 54.95,57.06 54.95,57.97 54.65,58.28 v2(54.05,58.28)
CPU_DP1_AUXP_C: length 1.8
  BOTTOM w0.102: CV876.2 54.84,56.14 54.84,55.91 55.09,55.66 55.09,55.44 55.2,55.33 UV66.60
CPU_DP1_N0: length 263.3
  TOP w0.076: v2(263.59,63.03) 263.26,63.36 263.15,63.36 262.48,62.69 258.33,62.69 258.19,62.55 257.05,62.55 256.97,62.47 256.97,62.27 257.04,62.2 UC1.K37
  IN2 w0.094: v2(263.59,63.03) 263.87,63.3 264.08,63.3 264.34,63.56 264.34,66.56 263.67,67.22 263.67,68.1 259.36,72.41 259.14,72.41 256.56,75 255.23,75 254.73,74.5 239.42,74.5 238,75.91 232.94,75.91 230.25,73.22 225.84,73.22 223.73,75.33 223.73,80.95 220.72,83.96 216.35,83.96 213.13,87.19 197.52,87.19 196.31,88.41 184.55,88.41 183.84,89.11 175.29,89.11 174.2,88.02 166.06,88.02 164.65,86.61 150.44,86.61 149.76,87.28 147.44,87.28 147.03,87.69 145.64,87.69 145.23,87.28 141.56,87.28 141.06,87.78 133.43,87.78 133.12,87.47 127.98,87.47 127.14,86.63 126,86.63 122.1,82.74 122.1,82.44 120.07,80.41 120.07,80.07 116.56,76.56 116.2,76.56 114.81,75.16 114.75,75.11 114.3,74.66 114.3,74.66 113.78,74.14 112.59,74.14 110.13,71.67 109.92,71.67 95.78,57.54 95.17,57.54 90.7,53.07 90.7,45.76 87.55,42.6 84.2,42.6 82.75,41.15 72.95,41.15 72.14,41.96 70.99,41.96 70.73,41.7 70.1,41.7 68.59,43.22 68.59,43.99 67.35,45.22 66.72,45.22 65.66,46.27 65.66,47.02 64.9,47.78 63.52,47.78 63.44,47.71 63.26,47.52 63.26,47.12 v2(62.96,46.83)
  BOTTOM w0.102: v2(62.96,46.83) 63.23,46.83 63.53,47.12 63.53,47.49 62.52,48.5 61.17,48.5 CV869.2
CPU_DP1_N0_C: length 2.2
  BOTTOM w0.102: CV869.1 60.14,48.5 59.96,48.5 59.83,48.62 59.02,48.62 58.91,48.52 UV66.15
CPU_DP1_N1: length 249.9
  TOP w0.076: v2(255.04,63.36) 255.37,63.03 UC1.J34
  IN2 w0.094: v2(61.68,46.4) 61.68,46.64 61.46,46.85 61.29,46.85 60.59,46.15 60.59,43.91 61.66,42.84 62.66,42.84 66.16,39.33 84.87,39.33 86,40.46 89.65,40.46 89.92,40.74 89.92,42.45 92.49,45.02 92.49,51.72 109.62,68.85 110.95,68.85 113.64,71.54 116.69,71.54 120.68,75.53 121.25,75.53 124.88,79.17 124.88,80.47 125.48,81.08 126.56,81.08 126.87,81.39 126.87,82.68 129.04,84.85 132,84.85 132.66,85.51 138.06,85.51 138.12,85.45 143.14,85.45 143.46,85.13 148.86,85.13 149.16,84.82 166.24,84.82 167.55,86.14 180.78,86.14 180.96,85.96 182.74,85.96 183.18,86.4 194.96,86.4 196.58,84.77 212.54,84.77 215.23,82.09 220.04,82.09 221.23,80.9 221.23,74.82 226.47,69.58 231.71,69.58 235.69,73.55 236.97,73.55 238.64,71.88 247.38,71.88 251.23,68.04 253.27,68.04 254.85,66.46 254.85,64.76 254.27,64.18 254.15,63.82 254.03,63.45 254.03,63.2 254.51,62.72 255.37,62.72 255.51,62.86 255.51,63 255.42,63.09 255.29,63.09 255.2,62.99 255.01,62.99 254.92,63.09 254.92,63.24 v2(255.04,63.36)
  BOTTOM w0.102: v2(61.68,46.4) 61.32,46.75 61.07,46.75 CV871.2
CPU_DP1_N1_C: length 2.4
  BOTTOM w0.102: UV66.18 58.72,47.32 58.83,47.42 59.28,47.42 59.59,47.12 59.59,46.97 59.81,46.74 59.99,46.74 CV871.1
CPU_DP1_N2: length 255.6
  TOP w0.076: v2(263,65.23) 262.63,64.86 262.21,64.86 262.12,64.96 260.3,64.96 259.32,63.98 257.85,63.98 257.56,64.27 257.03,64.27 256.82,64.06 256.82,63.92 UC1.H36
  IN2 w0.094: v2(65.3,44.47) 65.59,44.47 65.76,44.3 65.76,43.79 69.2,40.36 83.39,40.36 84.6,41.57 87.64,41.57 91.49,45.43 91.49,52.13 109.21,69.85 110.43,69.85 112.47,71.88 112.47,72.26 113.56,73.35 114.19,73.35 116.62,75.77 117.8,75.77 120.55,78.52 122.02,78.52 122.89,79.39 122.89,82.39 126.35,85.84 131.47,85.84 132.31,86.68 133.45,86.68 133.76,86.99 140.38,86.99 140.89,86.48 143.58,86.48 143.85,86.21 149.49,86.21 149.88,85.82 165.13,85.82 166.49,87.18 174.51,87.18 175.59,88.26 183.55,88.26 184.31,87.5 196.02,87.5 197.27,86.25 212.9,86.25 216.06,83.09 220.47,83.09 222.62,80.94 222.62,75.17 225.36,72.43 231.06,72.43 233.71,75.08 237.65,75.08 239.41,73.33 253.95,73.33 255.33,71.95 255.33,71.29 255.93,70.69 256.6,70.69 257.24,71.33 258.81,71.33 260.05,70.1 260.05,68.43 260.72,67.76 261.86,67.76 263.55,66.08 263.55,65.15 263.37,64.98 263.26,64.98 v2(263,65.23)
  BOTTOM w0.102: CV873.2 64.22,45.33 65.54,45.33 65.8,45.07 65.8,44.75 65.52,44.47 v2(65.3,44.47)
CPU_DP1_N2_C: length 5.6
  BOTTOM w0.102: UV66.21 58.91,46.12 59.02,46.22 59.52,46.22 60.41,45.33 60.63,45.33 60.67,45.29 61.25,45.29 61.29,45.33 v3(62.35,45.33) 63.18,45.33 CV873.1
CPU_DP1_N3: length 252.8
  TOP w0.076: UC1.J38 257.83,63.24 257.76,63.32 257.76,63.46 257.88,63.58 258.12,63.58 258.36,63.35 259.6,63.35 260.17,63.92 261.08,63.92 v2(261.44,64.28)
  IN2 w0.094: v2(62.48,43.98) 62.69,43.98 62.86,43.8 62.86,43.21 66.31,39.76 83.98,39.76 85.09,40.87 87.78,40.87 92.09,45.18 92.09,51.89 109.45,69.25 110.76,69.25 113.29,71.78 113.29,72.15 113.82,72.68 114.46,72.68 116.6,74.82 117.68,74.82 117.93,74.56 118.95,74.56 119.58,75.2 119.58,75.83 120.09,76.34 121.02,76.34 124.46,79.78 124.46,81.24 126.03,82.81 126.33,82.81 128.77,85.25 131.73,85.25 132.57,86.09 133.7,86.09 134.01,86.4 139.93,86.4 140.46,85.87 143.3,85.87 143.62,85.55 149.17,85.55 149.5,85.22 165.71,85.22 167.05,86.56 179.2,86.56 179.9,87.26 182.21,87.26 182.58,86.9 195.64,86.9 197.12,85.42 212.68,85.42 215.6,82.5 220.23,82.5 221.66,81.06 221.66,75.16 225.03,71.8 233.27,71.8 235.91,74.44 236.93,74.44 238.78,72.59 253.77,72.59 254.74,71.63 254.74,70.38 256.33,68.8 256.33,68.21 257.8,66.74 258.48,66.74 259.36,65.87 260.46,65.87 262.02,64.31 262.02,64.08 261.88,63.93 261.57,63.93 261.44,64.07 v2(261.44,64.28)
  BOTTOM w0.102: v2(62.48,43.98) 62.78,43.98 62.86,44.06 62.86,44.4 62.76,44.49 61.62,44.49 61.52,44.4 61.13,44.4 CV875.2
CPU_DP1_N3_C: length 2.9
  BOTTOM w0.102: UV66.23 58.73,45.32 58.84,45.43 59.12,45.43 59.34,45.21 v3(59.34,44.92) 59.34,44.58 59.62,44.31 60.01,44.31 CV875.1
CPU_DP1_P0: length 263.3
  TOP w0.076: UC1.K36 256.82,62.34 256.82,62.54 256.98,62.7 258.13,62.7 258.27,62.84 262.42,62.84 263.08,63.51 263.26,63.51 v2(263.59,63.84)
  IN2 w0.094: v2(63.95,46.83) 63.95,46.66 63.86,46.57 63.6,46.57 63.45,46.71 63.45,47.44 63.58,47.57 63.6,47.59 64.82,47.59 65.47,46.94 65.47,46.19 66.64,45.02 67.27,45.02 68.39,43.9 68.39,43.14 70.02,41.51 70.81,41.51 71.07,41.76 72.06,41.76 72.87,40.95 82.83,40.95 84.28,42.41 87.63,42.41 90.9,45.67 90.9,52.99 95.26,57.34 95.86,57.34 110,71.48 110.21,71.48 112.67,73.94 113.86,73.94 113.86,73.94 116.28,76.36 116.64,76.36 120.27,79.99 120.27,80.33 122.3,82.36 122.3,82.66 126.08,86.44 127.22,86.44 128.06,87.28 133.2,87.28 133.51,87.59 140.98,87.59 141.48,87.09 145.31,87.09 145.72,87.49 146.95,87.49 147.36,87.09 149.68,87.09 150.35,86.41 164.73,86.41 166.14,87.82 174.28,87.82 175.37,88.91 183.76,88.91 184.46,88.21 196.22,88.21 197.44,86.99 213.05,86.99 216.27,83.77 220.64,83.77 223.53,80.87 223.53,75.25 225.76,73.02 230.33,73.02 233.02,75.72 237.92,75.72 239.34,74.3 254.81,74.3 255.31,74.8 256.48,74.8 259.06,72.22 259.28,72.22 263.47,68.02 263.47,67.14 264.14,66.48 264.14,63.64 264,63.5 263.7,63.5 263.59,63.61 v2(263.59,63.84)
  BOTTOM w0.102: CV868.2 61.17,48.69 62.6,48.69 63.72,47.57 63.72,47.06 v2(63.95,46.83)
CPU_DP1_P0_C: length 2.2
  BOTTOM w0.102: CV868.1 60.14,48.69 60.04,48.69 59.91,48.81 v3(59.47,48.81) 59.02,48.81 58.91,48.92 UV66.14
CPU_DP1_P1: length 250
  TOP w0.076: v2(255.69,63.36) 256.02,63.03 UC1.J35
  IN2 w0.094: v2(61.62,47.34) 61.33,47.05 61.21,47.05 60.39,46.23 60.39,43.82 61.57,42.64 62.58,42.64 66.08,39.14 84.95,39.14 86.08,40.27 89.73,40.27 90.12,40.65 90.12,42.37 92.68,44.93 92.68,51.64 109.7,68.66 111.03,68.66 113.72,71.35 116.77,71.35 120.76,75.34 121.33,75.34 125.07,79.08 125.07,80.39 125.56,80.88 126.64,80.88 127.07,81.31 127.07,82.6 129.12,84.66 132.09,84.66 132.74,85.31 137.98,85.31 138.04,85.25 143.06,85.25 143.38,84.93 148.78,84.93 149.08,84.63 166.32,84.63 167.64,85.94 180.7,85.94 180.88,85.76 182.82,85.76 183.26,86.2 194.88,86.2 196.5,84.58 212.46,84.58 215.15,81.89 219.96,81.89 221.04,80.82 221.04,74.74 226.39,69.38 231.8,69.38 235.77,73.36 236.89,73.36 238.56,71.69 247.3,71.69 251.14,67.84 253.19,67.84 254.65,66.38 254.65,64.84 254.43,64.62 254.1,64.28 253.98,63.92 253.84,63.49 253.84,63.12 254.43,62.53 255.45,62.53 255.69,62.77 v2(255.69,63.36)
  BOTTOM w0.102: CV870.2 61.01,46.94 61.38,46.94 61.62,47.18 v2(61.62,47.34)
CPU_DP1_P1_C: length 2.4
  BOTTOM w0.102: CV870.1 60.04,46.94 59.89,46.94 59.78,47.05 59.78,47.2 59.36,47.61 58.83,47.61 58.72,47.72 UV66.17
CPU_DP1_P2: length 255.7
  TOP w0.076: UC1.H37 257.06,63.78 256.97,63.87 256.97,64 257.09,64.12 257.49,64.12 257.79,63.82 259.38,63.82 260.36,64.8 262.06,64.8 262.15,64.71 262.78,64.71 263,64.49 v2(263,64.48)
  IN2 w0.094: v2(263,64.48) 263.3,64.78 263.45,64.78 263.74,65.07 263.74,66.16 261.95,67.96 260.8,67.96 260.24,68.52 260.24,70.18 258.89,71.53 257.16,71.53 256.52,70.88 256.01,70.88 255.53,71.37 255.53,72.03 254.04,73.52 239.49,73.52 237.73,75.28 233.63,75.28 230.98,72.63 225.44,72.63 222.82,75.25 222.82,81.02 220.55,83.29 216.14,83.29 212.98,86.44 197.35,86.44 196.1,87.69 184.39,87.69 183.63,88.45 175.51,88.45 174.43,87.37 166.41,87.37 165.05,86.01 149.96,86.01 149.57,86.41 143.93,86.41 143.66,86.67 140.97,86.67 140.46,87.19 133.68,87.19 133.37,86.88 132.22,86.88 131.39,86.04 126.26,86.04 122.7,82.47 122.7,79.47 121.94,78.71 120.47,78.71 117.72,75.97 116.54,75.97 114.11,73.54 113.48,73.54 112.27,72.34 112.27,71.96 110.35,70.04 109.13,70.04 91.3,52.21 91.3,45.51 87.55,41.76 84.52,41.76 83.31,40.55 69.28,40.55 65.96,43.87 65.96,44.16 v2(66.27,44.47)
  BOTTOM w0.102: CV872.2 64.21,45.52 65.62,45.52 65.99,45.15 65.99,44.74 v2(66.27,44.47)
CPU_DP1_P2_C: length 5.6
  BOTTOM w0.102: CV872.1 63.19,45.52 62.68,45.52 62.65,45.56 62.06,45.56 62.03,45.52 v3(60.96,45.52) 60.49,45.52 59.6,46.41 59.02,46.41 58.91,46.52 UV66.20
CPU_DP1_P3: length 252.9
  TOP w0.076: v2(261.46,63.46) 261.15,63.77 260.23,63.77 259.66,63.2 258.34,63.2 258.1,62.95 257.85,62.95 257.81,62.99 UC1.J37
  IN2 w0.094: v2(63.35,43.98) 63.06,43.7 63.06,43.29 66.39,39.96 83.9,39.96 85.01,41.07 87.7,41.07 91.89,45.26 91.89,51.97 109.37,69.45 110.68,69.45 113.1,71.86 113.1,72.23 113.74,72.87 114.38,72.87 116.52,75.01 117.76,75.01 118.01,74.76 118.86,74.76 119.39,75.28 119.39,75.92 120.01,76.54 120.94,76.54 124.26,79.86 124.26,81.32 125.95,83.01 126.25,83.01 128.69,85.45 131.65,85.45 132.49,86.28 133.62,86.28 133.93,86.59 140.01,86.59 140.54,86.06 143.39,86.06 143.7,85.75 149.25,85.75 149.58,85.42 165.63,85.42 166.97,86.76 179.12,86.76 179.81,87.45 182.3,87.45 182.66,87.09 195.72,87.09 197.2,85.61 212.76,85.61 215.68,82.69 220.31,82.69 221.86,81.14 221.86,75.24 225.11,71.99 233.19,71.99 235.83,74.63 237.01,74.63 238.86,72.79 253.86,72.79 254.93,71.71 254.93,70.46 256.52,68.88 256.52,68.3 257.88,66.94 258.56,66.94 259.44,66.06 260.54,66.06 262.22,64.39 262.22,64 261.96,63.74 261.73,63.74 v2(261.46,63.46)
  BOTTOM w0.102: CV874.2 60.95,44.59 61.44,44.59 61.54,44.68 62.84,44.68 63.05,44.48 63.05,44.28 v2(63.35,43.98)
CPU_DP1_P3_C: length 2.9
  BOTTOM w0.102: CV874.1 60.01,44.5 59.7,44.5 59.53,44.66 59.53,45.28 59.2,45.62 58.86,45.62 58.76,45.72 UV66.22
CPU_DP2_AUXN: length 70.1
  TOP w0.076: v2(249.45,65.03) 249.51,65.03 UC1.E26
  TOP w0.102: CV74.1 306.42,77.43 306.42,76.97 v2(306.69,76.69)
  IN1 w0.076: 254.67,65.28 254.67,65.26 254.69,65.25 254.69,65.03 254.37,64.72 254.37,64.09 253.7,63.43 252.05,63.43 251.94,63.32 250.96,63.32 250.7,63.59 250.7,64.06 250.09,64.66 249.66,64.66 249.45,64.88 v2(249.45,65.03)
  IN1 w0.102: 254.67,65.28 254.67,69.04 257.78,72.15 265.79,72.15 270.34,76.7 279.98,76.7 280.52,76.16 283.06,76.16 284.04,77.13 286.49,77.13 287.11,76.5 294.47,76.5 295.55,77.58 306.04,77.58 306.4,77.22 306.4,76.98 v2(306.69,76.69)
CPU_DP2_AUXN_C: length 4
  TOP w0.102: CV74.2 306.52,78.37 306.52,79.11 305.96,79.68 v3(304.86,79.68) 304.26,79.68 304.19,79.74 UV8.25
CPU_DP2_AUXP: length 70.2
  TOP w0.076: UC1.F26 249.77,64.7 v2(249.45,64.38)
  TOP w0.102: CV73.1 306.23,77.2 306.23,76.95 305.96,76.68 v2(305.81,76.68)
  IN1 w0.076: 254.86,65.28 254.86,65.26 254.84,65.25 254.84,64.97 254.52,64.65 254.52,64.03 253.76,63.27 252.11,63.27 252,63.17 250.9,63.17 250.54,63.52 250.54,64 250.03,64.51 249.58,64.51 v2(249.45,64.38)
  IN1 w0.102: v2(305.81,76.68) 305.9,76.59 306.04,76.59 306.22,76.77 306.22,77.14 305.96,77.4 295.63,77.4 294.55,76.32 287.03,76.32 286.41,76.94 284.12,76.94 283.14,75.97 280.45,75.97 279.9,76.51 270.42,76.51 265.87,71.96 257.85,71.96 254.86,68.96 254.86,65.28
CPU_DP2_AUXP_C: length 3.9
  TOP w0.102: CV73.2 305.83,78.25 306.33,78.75 306.33,78.98 v3(306.11,79.2) 305.83,79.49 305.19,79.49 305.15,79.45 304.57,79.45 304.53,79.49 304.3,79.49 304.15,79.34 UV8.24
CPU_DP2_N0: length 49.2
  TOP w0.076: UC1.H33 254.72,63.84 v2(255.03,64.15)
  TOP w0.102: CV66.1 296.53,74.18 296.53,73.47 v2(296.84,73.16)
  IN1 w0.076: 257.43,63.73 257.42,63.73 257.4,63.75 255.55,63.75 255.49,63.8 v2(255.03,64.15)
  IN1 w0.102: 257.43,63.73 258.2,63.73 259.88,65.42 259.88,66.87 260.78,67.77 264.68,67.77 265.89,68.98 267.31,68.98 268,69.66 270,69.66 270.77,70.43 278.75,70.43 279.82,71.49 280.58,71.49 281.3,72.21 296.3,72.21 296.53,72.44 296.53,72.84 v2(296.84,73.16)
CPU_DP2_N0_C: length 3.1
  TOP w0.102: UV8.7 297.77,76.98 297.64,76.86 297.64,76.56 v3(297.31,76.23) 297.03,75.95 296.67,75.95 296.59,75.86 296.59,75.54 CV66.2
CPU_DP2_N1: length 50.3
  TOP w0.076: UC1.G38 257.81,64.28 257.72,64.37 257.72,64.46 257.86,64.61 258.93,64.61 260.48,66.16 260.48,66.83 260.5,66.83 260.5,66.87
  TOP w0.102: v2(261.32,68.4) 261.32,68.59 261.22,68.69 260.85,68.69 260.5,68.34 260.5,66.87 ; CV68.1 298.42,74.25 298.42,73.36 v2(298.69,73.1)
  IN1 w0.102: v2(298.69,73.1) 298.46,72.87 298.46,72.58 298.26,72.38 297.75,72.38 297.35,72.78 297.35,73.29 296.44,74.2 294.91,74.2 293.76,73.05 269.94,73.05 266.52,69.63 265.52,69.63 264.51,68.62 261.54,68.62 v2(261.32,68.4)
CPU_DP2_N1_C: length 2.5
  TOP w0.102: UV8.10 298.97,76.98 298.85,76.87 298.85,76.26 298.46,75.87 298.46,75.5 CV68.2
CPU_DP2_N2: length 54.5
  TOP w0.076: v2(256.4,64.97) 256.02,64.6 UC1.F35
  TOP w0.102: CV70.1 300.32,74.32 300.32,73.9 v2(300.73,73.49)
  IN1 w0.076: v2(256.4,64.97) 256.31,65.05 256.19,65.05 256.1,64.96 256.1,64.73 256.34,64.49 256.96,64.49 256.98,64.51 256.99,64.51
  IN1 w0.102: v2(300.73,73.49) 300.44,73.78 300.44,74.26 299.59,75.11 292.24,75.11 291.82,74.69 289.76,74.69 289.43,75.02 286.75,75.02 285.56,73.83 269.54,73.83 266.58,70.88 261.55,70.88 259.72,69.04 259.72,67.95 259.12,67.35 259.12,65.87 257.76,64.51 256.99,64.51
CPU_DP2_N2_C: length 2.5
  TOP w0.102: UV8.13 300.17,76.74 300.06,76.63 300.06,76.49 300.27,76.28 300.27,75.57 CV70.2
CPU_DP2_N3: length 61
  TOP w0.076: UC1.E36 256.76,65.42 257.03,65.68 257.15,65.76 257.26,65.79 257.5,65.79 257.77,65.53 258.81,65.53 259.71,66.42 259.71,66.73 259.69,66.75 259.69,66.77
  TOP w0.102: v2(258.76,69.15) 258.57,69.34 258.57,69.52 258.67,69.62 259.13,69.62 259.69,69.06 259.69,66.77 ; v2(302.48,73.17) 302.14,73.51 302.14,74.3 CV72.1
  IN1 w0.102: v2(258.76,69.15) 258.57,69.34 258.37,69.34 258.06,69.65 258.06,70.17 259.4,71.51 266.11,71.51 270.7,76.1 279.73,76.1 281.35,74.49 285.25,74.49 286.39,75.62 289.84,75.62 290.13,75.33 291.59,75.33 292.01,75.76 300.43,75.76 302.18,74 302.18,73.47 v2(302.48,73.17)
CPU_DP2_N3_C: length 3
  TOP w0.102: CV72.2 302.14,75.59 302.14,76.07 301.92,76.28 301.47,76.28 301.26,76.49 301.26,76.93 301.37,77.03 UV8.16
CPU_DP2_P0: length 49.2
  TOP w0.076: v2(255.69,64.14) 255.37,63.82 UC1.H34
  TOP w0.102: v2(295.92,73.16) 296.34,73.58 296.34,74.32 CV65.1
  IN1 w0.076: v2(255.69,64.14) 255.61,64.22 255.61,64.42 255.69,64.49 255.85,64.49 256.05,64.3 256.05,63.96 256.11,63.9 257.4,63.9 257.42,63.92 257.43,63.92
  IN1 w0.102: v2(295.92,73.16) 296.23,73.16 296.34,73.05 296.34,72.52 296.22,72.4 281.22,72.4 280.5,71.68 279.74,71.68 278.67,70.62 270.69,70.62 269.92,69.85 267.92,69.85 267.23,69.17 265.81,69.17 264.6,67.96 260.7,67.96 259.69,66.95 259.69,65.49 258.12,63.92 257.43,63.92
CPU_DP2_P0_C: length 3
  TOP w0.102: CV65.2 296.4,75.52 296.4,75.94 296.59,76.14 296.9,76.14 297.45,76.7 297.45,76.87 297.37,76.96 UV8.6
CPU_DP2_P1: length 50.2
  TOP w0.076: 260.31,66.87 260.31,66.85 260.33,66.83 260.33,66.23 258.86,64.76 257.8,64.76 257.61,64.56 UC1.F37
  TOP w0.102: 260.31,66.87 260.31,68.42 260.77,68.88 261.09,68.88 v2(261.32,69.11) ; v2(297.97,73.1) 298.23,73.36 298.23,74.25 CV67.1
  IN1 w0.102: v2(297.97,73.1) 298.27,72.8 298.27,72.65 298.18,72.57 297.83,72.57 297.54,72.86 297.54,73.37 296.52,74.39 294.83,74.39 293.68,73.24 269.87,73.24 266.45,69.82 265.44,69.82 264.44,68.81 261.32,68.81 261.25,68.88 261.25,69.04 v2(261.32,69.11)
CPU_DP2_P1_C: length 2.6
  TOP w0.102: UV8.9 298.57,76.97 298.66,76.87 298.66,76.34 298.27,75.95 298.27,75.57 CV67.2
CPU_DP2_P2: length 54.5
  TOP w0.076: v2(255.74,64.97) 255.37,64.6 UC1.F34
  TOP w0.102: v2(299.86,73.46) 300.13,73.74 300.13,74.24 CV69.1
  IN1 w0.076: 256.99,64.32 256.98,64.32 256.96,64.34 256.28,64.34 255.95,64.66 255.95,64.76 v2(255.74,64.97)
  IN1 w0.102: v2(299.86,73.46) 299.95,73.37 300.09,73.37 300.25,73.52 300.25,74.18 299.51,74.92 292.31,74.92 291.9,74.5 289.68,74.5 289.36,74.83 286.83,74.83 285.64,73.65 269.62,73.65 266.66,70.69 261.63,70.69 259.9,68.96 259.9,67.87 259.31,67.27 259.31,65.79 257.84,64.32 256.99,64.32
CPU_DP2_P2_C: length 2.5
  TOP w0.102: UV8.12 299.77,76.74 299.87,76.63 299.87,76.41 300.08,76.2 300.08,75.54 CV69.2
CPU_DP2_P3: length 61
  TOP w0.076: 259.88,66.77 259.88,66.75 259.86,66.73 259.86,66.36 258.88,65.38 257.7,65.38 257.44,65.64 257.28,65.64 257.22,65.62 257.12,65.56 257.04,65.48 257.04,65.33 257.1,65.28 257.25,65.28 UC1.E37
  TOP w0.102: 259.88,66.77 259.88,69.14 259.21,69.81 258.93,69.81 v2(258.76,69.98) ; CV71.1 301.95,74.28 301.95,73.54 v2(301.57,73.16)
  IN1 w0.102: v2(258.76,69.98) 258.92,69.83 258.92,69.66 258.79,69.53 258.45,69.53 258.25,69.73 258.25,70.1 259.48,71.33 266.19,71.33 270.78,75.92 279.66,75.92 281.27,74.3 285.33,74.3 286.47,75.44 289.77,75.44 290.06,75.15 291.66,75.15 292.09,75.57 300.35,75.57 301.99,73.92 301.99,73.14 301.88,73.03 301.71,73.03 v2(301.57,73.16)
CPU_DP2_P3_C: length 3
  TOP w0.102: CV71.2 301.94,75.56 301.94,75.99 301.84,76.09 301.39,76.09 301.07,76.42 301.07,76.94 300.97,77.04 UV8.15
CPU_DP3_AUXN: length 49.5
  TOP w0.076: UC1.B27 250.51,67.42 250.27,67.42 250.13,67.55 250.13,68.09 250.31,68.27 250.31,68.8 250.06,69.05 250.06,69.47 249.88,69.65 249.88,69.67
  TOP w0.109: JDGFF4.B6 282.96,90.52 282.74,90.74 281.75,90.74 v2(281.64,90.85) ; v2(256.51,74.19) 253.31,74.19 249.88,70.76 249.88,69.67
  IN4 w0.102: v2(281.64,90.85) 281.41,90.85 280.74,90.18 280.74,88.91 279.66,87.82 277.13,87.82 275.9,86.59 275.09,86.59 273.28,84.78 271.35,84.78 271.09,84.52 270.2,84.52 266.83,81.14 259.72,81.14 256.67,78.09 256.67,75.6 257.25,75.02 257.25,74.37 257.07,74.19 v2(256.51,74.19)
CPU_DP3_AUXP: length 49.4
  TOP w0.076: 250.4,69.67 250.4,69.65 250.22,69.47 250.22,69.11 250.46,68.87 250.46,68.2 250.28,68.02 250.28,67.62 250.33,67.57 250.62,67.57 250.72,67.68 250.72,67.86 UC1.A27
  TOP w0.109: v2(281.64,90.13) 281.73,90.22 282.53,90.22 282.83,89.92 JDGFF4.B5 ; v2(256.51,73.25) 256.63,73.37 256.63,73.59 256.55,73.67 253.52,73.67 250.4,70.54 250.4,69.67
  IN4 w0.102: v2(256.51,73.25) 256.89,73.63 257.3,73.63 257.81,74.14 257.81,75.25 257.23,75.83 257.23,77.86 259.95,80.58 267.06,80.58 270.43,83.96 271.32,83.96 271.58,84.22 273.51,84.22 275.32,86.03 276.13,86.03 277.37,87.26 279.89,87.26 281.3,88.68 281.3,89.95 281.48,90.13 v2(281.64,90.13)
CPU_DP3_N0: length 52.3
  TOP w0.076: UC1.D34 254.9,66.45 254.9,66.96 255.33,67.38 255.33,68.16 255.14,68.35 255.14,68.72 255.41,68.99 255.41,69.25 255.42,69.26
  TOP w0.109: JDGFF4.A2 284.25,88.12 284.44,88.31 286.44,88.31 286.65,88.53 286.65,89 286.58,89.07 286.3,89.07 286.17,88.94 v2(286.17,88.79) ; v2(257.28,70.68) 256.43,70.68 255.72,69.96 255.72,69.56 255.42,69.26
  IN4 w0.076: v2(257.28,70.68) 257.28,70.38 257.35,70.31 258.18,70.31 258.57,70.7 258.88,70.7 259.08,70.9 259.08,71.19 259.09,71.2
  IN4 w0.102: 259.09,71.2 259.74,71.85 265.37,71.85 267.37,73.86 267.37,75.82 269.08,77.52 269.08,78.1 272.95,81.97 275.05,81.97 275.96,82.88 282.33,82.88 282.84,83.39 282.84,83.96 283.4,84.52 286.07,84.52 286.61,85.07 286.61,88.69 286.51,88.79 v2(286.17,88.79)
CPU_DP3_N1: length 54.7
  TOP w0.076: v2(257.65,69.49) 257.27,69.11 257.02,69.11 256.93,69.03 256.72,69.03 256.13,68.44 256.13,67.84 255.93,67.64 255.93,67.42 255.79,67.28 UC1.B34
  TOP w0.109: v2(285.39,90.38) 285.39,90.46 285.57,90.64 285.79,90.64 285.88,90.55 285.88,90.05 285.67,89.84 284.41,89.84 284.32,89.92 JDGFF4.A5
  IN4 w0.076: 260.97,70.11 260.76,69.9 260.26,69.9 259.7,69.34 259.7,68.56 259.32,68.18 258.91,68.18 258.46,68.63 258.46,68.93 258.28,69.11 257.78,69.11 257.65,69.24 v2(257.65,69.49)
  IN4 w0.102: 260.97,70.11 262.12,70.11 262.36,69.86 264.15,69.86 264.64,70.35 265.7,70.35 268.85,73.5 268.85,75.41 271.04,77.61 271.04,78.1 273.26,80.31 275.11,80.31 276.53,81.73 285.26,81.73 288.12,84.6 288.12,88.64 287.41,89.35 286.31,89.35 285.83,89.83 285.83,90.47 285.71,90.59 285.51,90.59 285.39,90.48 v2(285.39,90.38)
CPU_DP3_N2: length 60.6
  TOP w0.076: v2(254.17,65.68) 254.49,65.35 UC1.E33
  TOP w0.109: v2(285.45,92.27) 285.45,92.37 285.57,92.49 285.83,92.49 285.96,92.36 285.96,91.97 285.63,91.64 284.67,91.64 284.58,91.72 JDGFF4.A8
  IN4 w0.076: 258.21,65.41 258.19,65.41 257.99,65.21 257.55,65.21 257.26,65.5 255.07,65.5 255,65.42 254.42,65.42 v2(254.17,65.68)
  IN4 w0.102: 258.21,65.41 259.94,65.41 261.37,66.84 261.62,66.84 262.41,67.63 264,67.63 265.54,69.17 266.27,69.17 270.31,73.21 270.31,75.18 273.58,78.45 275.38,78.45 275.92,79 278.17,79 279.75,80.58 285.47,80.58 289.28,84.39 289.89,84.39 290.75,85.24 290.75,86.78 289.33,88.2 289.33,89.31 287.52,91.11 286.54,91.11 285.92,91.73 285.92,92.45 285.81,92.55 285.54,92.55 285.45,92.46 v2(285.45,92.27)
CPU_DP3_N3: length 41.8
  TOP w0.076: 254.62,71.23 254.62,71.21 254.8,71.03 254.8,70.03 254.18,69.41 254.18,68.41 254.51,68.09 254.51,67.57 254.56,67.52 UC1.B33
  TOP w0.109: v2(256.53,72.53) 256.43,72.43 255.38,72.43 254.62,71.66 254.62,71.23 ; JDGFF4.B3 282.61,88.72 v2(282.19,88.31)
  IN4 w0.102: v2(256.53,72.53) 256.58,72.47 257.51,72.47 259.36,74.32 259.36,76.68 262.09,79.41 268.41,79.41 272.19,83.19 274.06,83.19 276.02,85.16 277.05,85.16 278.07,86.17 279.98,86.17 282.12,88.31 v2(282.19,88.31)
CPU_DP3_P0: length 52.3
  TOP w0.076: 255.79,68.9 255.78,68.89 255.52,68.89 255.29,68.66 255.29,68.41 255.48,68.23 255.48,67.32 255.05,66.89 255.05,66.51 255.3,66.27 255.56,66.27 255.62,66.32 255.62,66.41 UC1.C34
  TOP w0.109: 255.79,68.9 256.23,69.34 256.23,69.75 256.65,70.16 257.08,70.16 v2(257.28,69.96) ; JDGFF4.A1 284.38,87.52 284.66,87.8 286.65,87.8 287.17,88.32 v2(287.17,88.82)
  IN4 w0.076: v2(257.28,69.96) 257.48,70.16 258.24,70.16 258.63,70.55 258.94,70.55 259.18,70.79 259.47,70.79 259.48,70.8
  IN4 w0.102: 259.48,70.8 259.97,71.3 265.6,71.3 267.93,73.62 267.93,75.58 269.63,77.29 269.63,77.86 273.18,81.41 275.28,81.41 276.19,82.32 282.56,82.32 283.4,83.16 283.4,83.73 283.63,83.96 286.3,83.96 287.17,84.83 v2(287.17,88.82)
CPU_DP3_P1: length 54.8
  TOP w0.076: v2(257.65,68.78) 257.47,68.96 257.08,68.96 256.99,68.87 256.78,68.87 256.28,68.37 256.28,67.78 256.08,67.58 256.08,67.41 256.18,67.31 256.49,67.31 UC1.B36
  TOP w0.109: v2(286.39,90.42) 286.39,89.83 285.88,89.32 JDGFF4.A4
  IN4 w0.076: 260.97,69.55 260.95,69.55 260.74,69.75 260.32,69.75 259.85,69.28 259.85,68.5 259.38,68.03 258.85,68.03 258.31,68.56 258.31,68.87 258.22,68.96 257.83,68.96 v2(257.65,68.78)
  IN4 w0.102: v2(286.39,90.42) 286.39,90.06 286.54,89.91 287.64,89.91 288.68,88.87 288.68,84.37 285.49,81.17 276.77,81.17 275.34,79.75 273.49,79.75 271.6,77.87 271.6,77.38 269.41,75.18 269.41,73.27 265.93,69.79 264.87,69.79 264.38,69.31 262.13,69.31 261.88,69.55 260.97,69.55
CPU_DP3_P2: length 60.6
  TOP w0.076: UC1.F33 254.49,64.7 v2(254.17,65.03)
  TOP w0.109: JDGFF4.A7 285.84,91.12 286.48,91.76 v2(286.48,92.28)
  IN4 w0.076: 258.21,64.85 258.19,64.85 257.99,65.06 257.49,65.06 257.2,65.35 255.13,65.35 255.06,65.27 254.41,65.27 v2(254.17,65.03)
  IN4 w0.102: 258.21,64.85 260.17,64.85 261.6,66.28 261.85,66.28 262.65,67.07 264.23,67.07 265.77,68.61 266.5,68.61 270.87,72.98 270.87,74.95 273.81,77.89 275.61,77.89 276.15,78.44 278.4,78.44 279.98,80.02 285.71,80.02 289.51,83.83 290.12,83.83 291.31,85.01 291.31,87.01 289.89,88.43 289.89,89.54 287.76,91.67 286.77,91.67 286.48,91.97 286.48,92.28 v2(286.48,92.28)
CPU_DP3_P3: length 41.8
  TOP w0.076: UC1.C33 254.56,66.87 254.84,67.15 254.84,67.46 254.66,67.63 254.66,68.15 254.34,68.48 254.34,69.35 254.95,69.96 254.95,71.03 255.13,71.21 255.13,71.23
  TOP w0.109: v2(282.19,87.59) 282.72,88.12 JDGFF4.B2 ; 255.13,71.23 255.13,71.45 255.59,71.91 256.4,71.91 v2(256.54,71.77)
  IN4 w0.102: v2(282.19,87.59) 280.21,85.61 278.3,85.61 277.28,84.6 276.25,84.6 274.29,82.63 272.42,82.63 268.64,78.85 262.32,78.85 259.92,76.45 259.92,74.09 257.74,71.91 256.68,71.91 v2(256.54,71.77)
CPU_EDP_HPD: length 121.3
  TOP w0.109: UH1.AN6 129.53,46.03 129.2,46.35 v2(129.03,46.35) ; v2(152.46,115.8) 152.46,115.81 152.42,115.86 UV64.3
  IN1 w0.102: v2(128.75,54.66) 128.75,60.2 128.71,60.24 128.71,61.17 126.63,63.26 126.63,65.09 125.74,65.97 125.74,69.61 125.56,69.79 124.38,69.79 124.16,70.01 124.16,71.76 123.18,72.75 123.18,74.52 122.81,74.89 122.81,78.85 123.76,79.8 123.76,82.65 123.42,82.99 123.42,88.81 122.89,89.33 122.89,94.2 121.79,95.29 120.5,95.29 120.24,95.55 120.24,96.59 118.37,98.46 118.37,101.26 116.63,103 116.63,105.02 v2(119.95,108.33)
  IN2 w0.081: v2(152.46,115.8) 152.46,115.8 150.65,117.62 149.2,117.62 147.67,119.14 146.48,119.14 144.96,120.66 144.96,122.04 141.6,125.39 140.17,125.39 137.61,122.84 134.1,122.84 131.75,120.48 131.2,120.48 127.97,117.25 127.97,116.47 125.75,114.26 125.75,113.2 124.69,112.13 124.32,112.13 121.9,109.71 121.9,108.48 121.56,108.14 120.14,108.14 v2(119.95,108.33)
  BOTTOM w0.109: v2(129.03,46.35) 129.03,46.93 128.52,47.43 128.52,49.83 128.63,49.94 128.63,53.27 128.97,53.6 128.97,54.45 v2(128.75,54.66) 128.75,54.95 v1(129.18,55.37) RH1.2
CPU_VIDALERT#: length 26.4
  TOP w0.109: UC1.BH31 253.74,31.96 v2(253.74,31.89)
  BOTTOM w0.109: RC153.2 266.01,14.42 264.61,15.81 263.85,15.81 260.2,19.47 260.2,22.04 260.53,22.37 260.53,24.41 260.13,24.81 260.13,29.52 258.73,30.91 257.19,30.91 v1(256.87,31.23) 256.59,31.51 253.92,31.51 253.74,31.69 v2(253.74,31.89)
CPU_XDP_HOOK6: length 4.6
  BOTTOM w0.109: JXDP1.46 242.78,19.53 v1(243.59,20.34) 243.59,20.72 RC144.1 244.3,21.36 245.01,22.08 RC115.1
CPU_XDP_PRDY#: length 23.9
  TOP w0.089: 250.01,26.71 249.92,26.79 249.92,28.15 UC1.BP27
  TOP w0.109: 250.01,26.71 250.01,26.44 249.55,25.98 249.55,22.29 T189.1 248.28,21.02 248.28,19.12 249.36,18.04 252.34,18.04 252.92,17.45 254.28,17.45 v2(255.08,16.65)
  BOTTOM w0.109: RC314.1 258.16,13.26 256.95,14.48 255.69,14.48 255.08,15.08 JXDP1.5 255.09,15.66 255.09,16.64 v2(255.08,16.65)
CPU_XDP_PREQ#: length 24.7
  TOP w0.109: T190.1 v2(252.41,26.02) 252.41,26.75 252.32,26.84 252.32,30.39 252.61,30.7 UC1.BL30
  BOTTOM w0.109: JXDP1.3 255.68,17.1 256.07,17.49 257.18,17.49 257.45,17.22 257.45,15.91 257.78,15.58 RC315.1 258.32,16.16 RC138.2 258.12,17.81 257.05,18.89 257.05,21.13 256.03,22.14 256.03,22.91 253.92,25.02 253.41,25.02 v2(252.41,26.02)
CPU_XDP_PRS: length 2.8
  BOTTOM w0.109: JXDP1.60 238.58,18.91 238.3,19.19 238.08,19.19 237.99,19.28 RC127.1 236.6,19.28 v1(236.42,19.46)
CPU_XDP_TCLK: length 30.8
  TOP w0.109: UC1.BR28 251.51,27.65 251.51,24.16 v2(251.66,24.01)
  IN4 w0.102: v2(251.66,24.01) 251.66,23.76 251.37,23.48 251.37,23.27 251.05,22.94 250.77,22.94 250.3,23.41 247.5,23.41 246.81,24.1 245.65,24.1 243.75,22.19 242.59,22.19 240.87,20.47 240.87,18.08 240.03,17.24 240.03,14.98 v2(239.49,14.44)
  BOTTOM w0.109: v2(239.49,14.44) 239.48,14.45 JXDP1.57 239.48,16.14 237.51,18.11 RC139.1 236.03,18.11 RC143.1 ; v2(251.66,24.01) 251.54,23.89 T181.1
CPU_XDP_TDI: length 30.7
  TOP w0.109: UC1.BL32 v2(253.74,31.1)
  IN4 w0.102: v2(239.21,23.7) 239.14,23.78 239.14,24.69 241.83,27.38 241.83,30.74 242.72,31.63 249.25,31.63 249.97,30.9 249.97,29.28 250.18,29.07 251.1,29.07 252.45,30.42 253.13,30.42 253.74,31.03 v2(253.74,31.1)
  BOTTOM w0.109: JXDP1.56 239.78,19.28 240.21,19.7 240.21,20.56 239.99,20.77 239.81,20.77 239.6,20.98 239.14,20.98 239.04,21.08 239.04,22.03 238.67,22.41 RC229.1 238.58,23.29 T185.1 238.99,23.7 v2(239.21,23.7)
CPU_XDP_TDO: length 22.1
  TOP w0.109: v2(250.95,23.38) 250.96,23.39 250.96,25.77 251.18,25.99 UC1.BT28
  IN4 w0.102: v2(250.95,23.38) 250.73,23.6 247.6,23.6 246.88,24.32 245.59,24.32 243.96,22.69 242.92,22.69 242.63,22.98 v2(242.63,23.38)
  BOTTOM w0.109: T184.1 250.73,23.6 v2(250.95,23.38) ; RC135.1 242.88,23.63 v2(242.63,23.38) 242.63,23.14 242.82,22.95 242.82,21.59 242.42,21.19 RC230.1 241.84,20.7 CC306.1 241.21,20.7 240.83,20.32 240.83,19.2 240.98,19.04 JXDP1.52
CPU_XDP_TMS: length 23.5
  TOP w0.109: v2(250.42,24.06) 250.45,24.09 250.45,26.05 250.82,26.42 250.82,28.27 UC1.BP28
  IN2 w0.081: v2(239.14,19.73) 238.79,19.73 238.71,19.82 238.71,20.49 240.29,22.07 246.98,22.07 249.03,24.13 250.35,24.13 v2(250.42,24.06)
  BOTTOM w0.109: JXDP1.58 239.18,18.65 238.26,19.57 RC228.1 239.07,19.8 v2(239.14,19.73) ; T180.1 249.39,24.06 v2(250.42,24.06)
CPU_XDP_TRST#: length 259.2
  TOP w0.089: UH1.AM4 130.19,47.1 129.87,47.42 129.87,47.54 129.56,47.84 129.56,48.76 129.34,48.98 129.34,49.44 v2(129.03,49.75) ; UC1.BP30 252.76,28.38 253.23,27.91 253.23,26.89 253.16,26.82 253.16,25.44 253.32,25.28
  TOP w0.109: v2(260.3,6.62) 260.67,7 260.67,9 256.4,13.27 244.03,13.27 241.8,15.5 240.83,15.5 240.23,16.1 240.23,19 240.38,19.15 240.38,22.96 v2(240.61,23.19) ; v2(254.68,22.72) 254.43,22.72 254.21,22.94 254.21,23.02 253.7,23.53 253.7,24.9 253.32,25.28
  IN3 w0.081: v2(260.3,6.62) 256.86,6.62 254.52,8.96 246.65,8.96 241.98,4.29 168.07,4.29 167.03,5.33 158.39,5.33 154.65,9.07 149.5,9.07 147.99,10.58 141.44,10.58 140.59,11.43 133.77,11.43 133.18,12.03 130.73,12.03 129.81,12.95 128.98,12.95 128.47,13.46 124.11,13.46 119.23,18.34 119.23,20.68 118.67,21.24 118.67,23.93 120.06,25.33 120.06,27.7 119.29,28.47 119.29,29.29 119.9,29.91 119.9,31.59 119.68,31.82 119.68,34.89 119.94,35.14 119.94,36.81 120.24,37.11 120.24,44.42 120.77,44.96 120.77,46.52 121.1,46.84 122.6,46.84 123.93,48.17 126.14,48.17 126.22,48.09 127.73,48.09 128.57,48.94 128.57,49.3 v2(129.03,49.75) ; v2(254.68,22.72) 253.35,24.06 252.49,24.06 251.16,25.39 250.43,25.39 248.87,23.83 247.72,23.83 246.34,22.45 244.58,22.45 243.14,23.89 240.93,23.89 240.61,23.57 v2(240.61,23.19)
  BOTTOM w0.109: T179.1 255.03,20.71 255.03,22.37 v2(254.68,22.72) ; JXDP1.54 240.38,19.1 240.54,19.26 240.54,20.61 240.13,21.02 239.94,21.02 RC136.1 239.5,21.49 239.51,21.5 240.27,21.5 240.31,21.47 CC308.1 240.35,21.47 240.77,21.89 240.77,21.95 240.81,21.98 240.81,23 v2(240.61,23.19)
CS_1.2V: length 4.6
  TOP w0.109: PR201.2 v1(116.61,9.96)
  TOP w0.203: PU200.13 113.17,10.79 113.59,10.38 115.2,10.38 PR201.2
CSCOMP_2PH: length 55.4
  TOP w0.203: 302.35,38.51 PU1100.31
  TOP w0.254: 302.35,38.51 302.35,37.75 301.62,37.02 PR1139.2 301.62,35.2 PR1141.1 300.66,35.16 PC1125.1 PC1124.1 300.93,34.17 301.07,34.3 v2(301.44,34.3) ; v2(279.27,13.76) 279.32,13.71 PH1102.1
  BOTTOM w0.254: v2(279.27,13.76) 279.27,13.86 279.68,14.26 281.46,14.26 282.01,13.71 282.01,12.79 283.31,11.5 287.65,11.5 287.91,11.24 293.56,11.24 298.15,15.83 298.15,17.2 299.37,18.43 v1(299.37,22.43) 299.37,23.4 305.2,29.22 305.2,32.36 303.83,33.73 301.97,33.73 301.44,34.26 v2(301.44,34.3)
CSCOMP_4PH: length 32.7
  TOP w0.152: PH1101.1 280.77,52.47 v2(280.79,52.44)
  TOP w0.203: PU1100.8 302.75,46.84 302.4,47.18 PC1121.1 302.4,48.64 PC1122.2 PR1138.1 303.27,50.41 PR1140.1 303.28,50.63 302.82,51.09 v2(302.32,51.09)
  IN4 w0.152: v2(302.32,51.09) 302.54,50.88 302.54,50.03 302,49.49 301.51,49.49 300.92,50.08 295.58,50.08 292.73,52.92 281.28,52.92 v2(280.79,52.44)
CSN_1PH: length 55.6
  TOP w0.109: v2(311.86,43.96) 311.85,43.94 PR1169.1
  TOP w0.152: v2(277.54,62.7) 277.54,62.7 PH1100.1 277.54,64.06 277.84,64.36 277.84,66.24 277.45,66.63 PL1800.3
  IN1 w0.152: v2(311.86,43.96) 312.08,44.18 312.08,50.29 311,51.38 311,58.59 308.23,61.36 297,61.36 295.91,62.45 285.31,62.45 285.06,62.7 v2(277.54,62.7)
CSN_1PH_R: length 6.3
  TOP w0.203: PR1169.2 310.09,43.83 PC1104.1 PC1102.1 308.19,43.6 v2(307.54,43.6) 307.41,43.6 307.16,43.35 PU1100.48
  BOTTOM w0.152: v1(306.9,45.18) PC1137.1
  BOTTOM w0.203: v2(307.54,43.6) 307.26,43.88 307.17,43.88 PC1137.1
CSON_1: length 19
  TOP w0.254: PC720.1 71.06,18.65 PR728.1 71.24,18.47 71.24,18 PC719.2 71.22,17.61 71.22,16.81 v1(72.65,15.38) 75.51,15.38 78.01,12.89 78.01,9.19 77.54,8.73 77.54,6.18 77.29,5.92 PR715.3
CSOP_1: length 19.2
  TOP w0.254: PR715.2 78.11,5.92 77.92,6.11 77.92,8.57 78.39,9.03 78.39,13.05 v1(75.67,15.76) 72.81,15.76 71.62,16.96 71.62,17.46 PC719.1 71.63,18.12 71.63,18.39 PR727.1 71.88,18.65 PC718.2
CSP1_2PH: length 4.8
  TOP w0.203: PR1160.1 298.94,37.23 PC1132.2 299.03,37.69 299.59,38.25 v1(300.49,38.25) 301.15,38.91 PU1100.28
CSP1_4PH: length 7.7
  TOP w0.203: PC1131.2 300.09,47.64 v2(300.09,47.08) 300.61,47.08 301.55,46.14 PU1100.11
  BOTTOM w0.254: v2(300.09,47.08) v2(300.09,49.61) 300.09,50.5 PR1154.2
CSP2_4PH: length 8
  TOP w0.203: PC1133.2 299.26,47.17 v2(299.46,46.97) 299.82,46.61 v1(300.28,46.61) 300.59,46.61 301.15,46.06 PU1100.12
  BOTTOM w0.254: v2(299.46,46.97) 299.26,47.17 299.26,51.07 PR1161.2
CSP3_4PH: length 10.7
  TOP w0.109: v1(297.79,49.65) 297.79,48.34 298.37,47.76 PC1135.2
  TOP w0.203: PU1100.13 300.75,45.99 300.51,46.23 299.49,46.23 v2(298.85,46.87) 298.37,47.35 PC1135.2
  BOTTOM w0.254: PR1163.2 298.85,50.79 v2(298.85,46.87)
CSP4_4PH: length 20.8
  TOP w0.203: v2(295.43,39) v1(296.06,39.64) 297.33,39.64 PC1136.2 298.65,39 299.79,40.15 PU1100.26
  BOTTOM w0.254: PR1164.2 296.06,51.32 293.55,48.81 293.55,40.88 v2(295.43,39)
CSP_1PH: length 59
  TOP w0.203: v2(310.74,42.37) 310.48,42.37 310.23,42.62 PR1101.2 309.79,42.98 309.73,42.92 PC1104.2 PC1102.2 308.24,43.09 307.51,43.09 v1(307.37,42.95) PU1100.47
  IN1 w0.152: v2(310.74,42.37) 310.86,42.48 312.08,42.48 312.64,43.04 312.64,50.49 311.53,51.6 311.53,58.81 308.45,61.89 297.22,61.89 296.13,62.98 285.54,62.98 285.28,63.24 279.22,63.24 v2(278.92,63.54)
  BOTTOM w0.152: v2(278.92,63.54) 278.92,64.16 PR1102.1
CSREF_2PH: length 60.2
  TOP w0.203: v2(301.44,38.5) 301.44,38.75 301.55,38.85 PU1100.29
  TOP w0.254: v2(299.54,36.69) 299.94,37.1 PC1132.1 300.26,37.32 v2(301.44,38.5)
  BOTTOM w0.254: PR1703.2 v1(278.28,14.37) 278.28,12.42 280.25,10.45 294.14,10.45 299.23,15.54 299.23,16.81 300.25,17.83 300.25,22.79 306.17,28.7 306.17,32.56 302.04,36.69 v2(299.54,36.69) ; PC1126.1 301.24,38.7 v2(301.44,38.5)
CSREF_4PH: length 67.2
  TOP w0.203: PU1100.10 301.95,46.33 301.72,46.55 v2(301.72,46.67) 301.6,46.67 300.84,47.44 300.84,48.43 300.68,48.58 300.19,48.58 PC1131.1 299.28,48.62 PC1133.1 298.38,48.59 PC1135.1 v2(298.37,49.27)
  TOP w0.254: PC1136.1 296.19,39 v2(296.16,39.03) ; PR1203.2 278.66,52.59 v2(278.38,52.31) 278.99,52.31 279.27,52.04 PR1207.2 ; PR1214.2 279.03,35.25 v2(279.12,35.34)
  TOP w0.305: PR1214.2 279.22,33.17 279.22,31.36 PR1215.2
  IN4 w0.254: v2(279.12,35.34) 278.38,36.08 v2(278.38,52.31) 279.07,52.31 279.45,51.93 280.97,51.93 281.53,52.49 287.77,52.49 288.47,51.79 290.14,51.79 290.84,52.49 292.45,52.49 295.4,49.54 298.09,49.54 v2(298.37,49.27) 298.37,48.76 296.97,47.36 296.97,39.84 v2(296.16,39.03)
  BOTTOM w0.109: v1(302.38,47.46) PC1123.2
  BOTTOM w0.203: v2(301.72,46.67) 302.09,46.31 PC1123.2
CSSN_1: length 3.6
  TOP w0.109: v2(92.33,31.45) v1(92.86,31.45)
  TOP w0.254: PR704.1 91.41,31.61 PR702.1 92.2,31.57 v2(92.33,31.45)
  BOTTOM w0.254: PR700.3 92.77,32.07 92.33,31.63 v2(92.33,31.45)
CSSN_2: length 26.1
  TOP w0.109: v2(88.15,32.49) 88.53,32.49 89.1,31.92 89.44,31.92 PR704.2 ; PU700.1 71.28,25.63 71.2,25.72 71.2,25.9 71.39,26.09 72.56,26.09 72.87,26.4 74.54,26.4 74.76,26.62 74.76,26.75 PC701.2 v2(75.13,27.93) 75.17,27.97 PC702.1
  IN1 w0.102: v2(75.13,27.93) 74.93,28.13 74.93,28.24 75.08,28.39 75.31,28.39 75.75,27.95 77.86,27.95 79.66,29.75 85.61,29.75 86.91,31.04 86.91,32.16 87.59,32.84 87.89,32.84 88.15,32.5 v2(88.15,32.49)
  BOTTOM w0.109: v2(75.13,27.93) 75.13,28.07 v1(74.8,28.4)
CSSP_1: length 4.2
  TOP w0.109: v2(92.33,32.68) 93.44,32.68 v1(93.48,32.64)
  TOP w0.254: v2(92.33,32.68) 92.32,32.68 92.13,32.49 PR702.2 91.42,32.46 PR703.1
  BOTTOM w0.254: v2(92.33,32.68) 92.33,32.39 92.01,32.07 PR700.2
CSSP_2: length 26.1
  TOP w0.109: PU700.2 70.88,25.69 70.96,25.77 70.96,26 71.3,26.33 72.46,26.33 72.77,26.63 74.44,26.63 74.52,26.71 74.52,26.81 PC701.1 74.21,27.72 v2(74.45,27.95) 74.26,28.13 PC700.2 ; PR703.2 89.44,32.15 89.2,32.15 88.65,32.7 v2(88.65,32.99)
  IN1 w0.102: v2(74.45,27.95) 74.7,28.2 74.7,28.34 74.98,28.62 75.4,28.62 75.84,28.18 77.76,28.18 79.56,29.98 85.52,29.98 86.68,31.13 86.68,32.25 87.5,33.07 88,33.07 88.06,32.99 v2(88.65,32.99)
CSSUM_2PH: length 11.3
  TOP w0.203: 300.44,36.48 301.44,37.48 301.44,37.73 301.95,38.23 PU1100.30
  TOP w0.254: 300.44,36.48 300.17,36.21 298.61,36.21 PR1145.1 298.58,35.72 299.25,35.05 PC1125.2 PC1124.2 299.67,34.14 299.67,33.42 299.92,33.16 v1(300.45,33.16) PR1144.2
CSSUM_4PH: length 11.4
  TOP w0.109: v1(295.7,51.01) PR1149.2
  TOP w0.203: PR1142.2 301.49,49.52 PC1122.1 301.48,48.64 PC1121.2 301.48,47.56 302.35,46.7 PU1100.9
  TOP w0.305: PR1142.2 300.95,50.07 300.95,50.97 PR1143.2 299.57,51.06 PR1146.2 298.27,51.03 PR1148.2 PR1149.2
CV2_ON: length 231.6
  TOP w0.109: v2(152.71,71.59) 152.71,72.07 151.78,73 151.78,74.12 v2(151.57,74.32) ; v2(336.75,58.31) 336.49,58.05 JUSH1.24
  VCC w0.086: v2(151.57,74.32) 151.57,74.4 153.79,76.61 153.79,77.61 156.94,80.77 156.94,91.76 160.5,95.32 170.99,95.32 171.65,95.98 179.12,95.98 183.8,91.3 185.17,91.3 185.65,90.82 194.47,90.82 195.12,91.47 221.2,91.47 227.94,84.73 231.74,84.73 234.56,81.91 238.6,81.91 241.62,78.89 252.86,78.89 255.33,81.35 263.26,81.35 263.97,82.06 267.47,82.06 268.89,83.47 270.82,83.47 271.1,83.2 v2(271.1,82.78)
  IN3 w0.081: v2(336.75,58.31) 326.02,58.31 325.24,59.09 322.34,59.09 314.84,66.59 313.23,68.2 313.23,74.08 309.11,78.2 306.22,78.2 304,80.42 294.31,80.42 293.46,81.27 281.64,81.27 281.25,81.65 272.03,81.65 271.1,82.59 v2(271.1,82.78)
  BOTTOM w0.109: v2(271.1,82.78) v1(271.68,82.78) ; RE539.2 153.14,71.15 v2(152.71,71.59)
CV2_ON_R: length 20.3
  TOP w0.109: UE1.H8 v2(138.81,73.28) ; v2(147.79,72.11) 151.6,72.11 v1(151.95,71.76) 152.6,71.11 155.47,71.11 v2(155.6,70.98)
  BOTTOM w0.109: RE539.1 155.43,71.15 v2(155.6,70.98) ; RE736.2 138.81,73.29 v2(138.81,73.28) 139.22,73.69 142.94,73.69 144.51,72.11 v2(147.79,72.11)
DAT_TP_SIO_I2C_CLK: length 180
  TOP w0.109: UE1.C12 v2(142.04,78.05)
  IN1 w0.102: v2(27.89,12.03) 27.89,12.57 28.6,13.28 28.6,15.03 31.49,17.92 39.98,17.92 40.56,17.34 42.77,17.34 44.88,19.45 44.88,20.61 45.92,21.66 45.92,22.67 46.38,23.13 48.51,23.13 48.92,22.72 48.92,22.04 49.07,21.88 51.53,21.88 51.64,21.78 55.5,21.78 58.8,25.08 63.78,25.08 64.59,25.9 72.24,25.9 72.8,25.33 74.18,25.33 74.47,25.62 78.08,25.62 79.48,27.02 79.48,27.06 79.47,27.07 v2(79.47,28.08)
  IN3 w0.081: v2(142.04,78.05) 142.04,77.36 141.64,76.95 141.64,76.23 142.4,75.47 142.4,74.9 145.08,72.22 145.08,68.55 143.63,67.11 143.63,66.71 141.44,64.51 141.39,64.51 141.14,64.26 140.96,64.26 140.61,63.91 140.61,63.45 140.5,63.34 139.53,63.34 138.82,62.63 134.55,62.63 134.02,62.09 133.32,62.09 132.03,60.8 127.38,60.8 126.18,62 122.81,62 118.11,57.3 118.11,57 116.76,55.65 114.32,55.65 112.11,53.44 112.11,43.85 110.82,42.56 110.82,33.7 110.28,33.16 109.72,33.16 108.98,32.42 108.98,31.71 108.53,31.27 108.53,28.7 108.22,28.38 102.3,28.38 101.41,29.28 97.62,29.28 94.67,32.23 88.58,32.23 84.01,27.65 79.91,27.65 v2(79.47,28.08)
  BOTTOM w0.109: v1(27.21,12.03) v2(27.89,12.03) 28.45,12.59 28.89,12.59 CZ80.1 29.24,11.82 29.16,11.74 29.16,11.43 RZ22.2 29.2,11.38 RZ347.1
DAT_TP_SIO_R: length 23.1
  TOP w0.109: v2(26.64,2.17) 25.93,1.46 20.03,1.46 19.34,2.15 19.34,3.06 JKBTP1.13
  BOTTOM w0.109: v2(26.64,2.17) 26.64,3.14 v1(27.9,4.4) 28.72,5.22 28.72,6.11 28.72,6.11 28.72,7.63 27.68,8.68 26.29,8.68 25.83,9.13 25.83,10.28 26.18,10.63 28.28,10.63 ; 28.28,10.63 RZ22.1 ; 28.28,10.63 RZ18.2
DCIN1_EN: length 94.5
  TOP w0.109: UE1.K4 v2(134.87,71.68) ; PR15.1 89.48,17.08 v2(89.1,16.7)
  IN3 w0.081: v2(134.87,71.68) 134.45,71.26 133.37,71.26 132.87,70.75 132.87,69.99 132.64,69.77 132.07,69.77 131.89,69.95 127.85,69.95 127.54,70.26 126.56,70.26 126.12,70.7 123.79,70.7 122.45,69.36 121.35,69.36 120.88,69.82 120.2,69.82 117.89,67.52 117.89,66.71 115.6,64.42 115.6,63.55 114.5,62.45 114.5,62.17 112.26,59.93 112.26,58.24 111.52,57.5 107.37,57.5 103.6,53.73 103.19,53.73 102.25,52.79 100.3,52.79 98.7,51.18 98.7,45.32 97.73,44.35 97.73,34.65 97.51,34.43 v2(97.27,34.43)
  IN4 w0.102: v2(89.1,16.7) 89.48,17.08 89.48,18.71 93.73,22.96 94.64,22.96 94.85,22.75 95.84,22.75 98.64,25.54 99.91,25.54 100.19,25.83 100.19,30.88 98.17,32.91 97.23,32.91 96.82,33.31 96.82,33.99 v2(97.27,34.43)
  BOTTOM w0.109: v1(134.49,72.07) 134.87,71.7 v2(134.87,71.68)
DCIN2_EN: length 118.5
  TOP w0.109: v2(55.52,33.25) 55.48,33.29 PR36.1 ; v2(142.01,70.88) UE1.L12
  IN2 w0.081: v2(55.52,33.25) 56.16,33.89 63.32,33.89 67.13,37.71 85.7,37.71 86.88,38.89 90.89,38.89 92.85,40.85 92.85,42.35 94.24,43.74 94.24,51.07 95.9,52.72 97.71,52.72 99.31,54.32 99.31,55.46 101.28,57.43 103.51,57.43 104.52,58.43 106.41,58.43 106.75,58.77 111.32,58.77 118.67,66.12 v2(118.76,66.12)
  IN4 w0.102: v2(142.01,70.88) 142.18,71.05 142.41,71.05 142.64,71.28 142.98,71.28 144.41,69.85 144.41,67.32 141.67,64.58 137.46,64.58 136.8,63.92 125.79,63.92 125.22,64.5 125.22,64.96 124.84,65.34 120.55,65.34 119.77,66.12 v2(118.76,66.12)
  BOTTOM w0.109: v2(142.01,70.88) 142.01,70.8 v1(142.42,70.4)
DCIN3_EN: length 126.8
  TOP w0.109: v2(87.58,37.54) 87.39,37.73 87.39,42.02 88.85,43.48 88.85,51.27 86.84,53.28 86.84,53.79 87.22,54.16 99.59,54.16 100.86,52.89 104.15,52.89 v2(104.61,53.35) ; UE1.J6 v2(136.47,72.48)
  IN1 w0.102: v2(78.31,27.04) 77.95,26.68 73.96,26.68 73.63,27.02 69.09,27.02 68.2,26.13 64.17,26.13 63.41,25.36 59.06,25.36 v2(58.57,25.86)
  IN3 w0.081: v2(104.61,53.35) 104.61,54.42 107.49,57.29 111.6,57.29 112.47,58.16 112.47,59.82 114.71,62.06 114.71,62.36 115.81,63.46 115.81,64.3 118.23,66.72 119.19,66.72 119.58,67.11 119.58,67.55 120.93,68.9 122.71,68.9 123.38,68.23 126.74,68.23 127.95,69.45 130.92,69.45 131.43,68.94 131.43,68.54 131.65,68.33 132.45,68.33 134.62,70.5 135.13,70.5 135.28,70.65 135.28,71.92 135.46,72.1 136.08,72.1 v2(136.47,72.48)
  IN3 w0.102: v2(87.58,37.54) 87.34,37.3 87.34,31.55 84.08,28.3 80.66,28.3 80.26,28.69 79.5,28.69 78.31,27.5 v2(78.31,27.04)
  BOTTOM w0.109: PR54.1 52.58,25.68 53.64,25.68 53.74,25.78 54.49,25.78 55.06,26.35 v1(57.69,26.35) 58.07,26.35 v2(58.57,25.86)
DCIN_ACOK: length 11.8
  BOTTOM w0.109: v1(80.64,23.12) 80.64,23.38 80,24.02 PR2042.2 79.32,24.35 79.32,25.43 77.76,27 PU2004.7 76.24,27 PR2039.1 75.65,27.36 74.45,27.36 74,27.81 74,27.87 PC2018.1 73.61,28.16 PR2009.1 73.61,27.41 PQ2007.5
DDR4_DRAMRST#_PCH: length 68.5
  TOP w0.109: v2(157.58,45.13) 160.64,42.07 v2(164.76,42.07) ; UH1.BB46 125.08,25.61 125.17,25.52 125.17,25.26 125.26,25.17 125.26,24.37 v2(125.21,24.33)
  IN3 w0.081: v2(157.58,45.13) 157.58,33.37 151.03,26.81 145.68,26.81 145.1,26.23 143.2,26.23 142.59,25.62 135.4,25.62 134.57,26.46 134.57,27.22 133.53,28.26 133.53,29.86 133.37,30.01 132.11,30.01 132.04,29.94 131.34,29.94 130.76,30.52 130.76,30.52 130.21,30.52 129.6,29.91 129.6,29.12 128.42,27.93 128.42,27.41 127.89,26.88 127.64,26.88 125.21,24.46 v2(125.21,24.33)
  BOTTOM w0.109: v2(164.76,42.07) 164.93,42.23 v1(165.25,42.23) RD4.2 CD5.1 167.12,42.19 RD77.1 168.78,42.19 RD76.1
DDR_A_ACT#: length 77.6
  TOP w0.076: UC1.AU3 232.57,40.71 232.39,40.71 232.32,40.63 232.32,40.42 232.24,40.35 230.73,40.35 230.31,40.76 228.66,40.76 v2(228.26,40.37)
  TOP w0.211: v2(177.15,43.99) 177.15,43.98 177.15,43.49 176.94,43.28 176.64,43.28 176.34,43.58 175.83,43.58 175.62,43.37 175.62,43.2 175.41,42.99 175.11,42.99 174.9,43.2 174.9,43.49 174.41,43.98 JDIMM2.114
  IN1 w0.188: v2(177.15,43.99) 176.61,43.44 176.61,43.17 176.77,43.01 178.33,43.01 178.84,42.51 181.08,42.51 181.94,41.66 187.39,41.66 188.59,40.45 192.94,40.45 193.27,40.12 200.54,40.12 204.39,36.27 214.86,36.27 215.04,36.1 215.04,35.85 214.86,35.68 213.28,35.68 213.1,35.5 213.1,35.26 213.28,35.08 215.61,35.08 216.8,36.27 218.51,36.27 219.87,37.62 221.68,37.62 222.4,38.35 223.9,38.35 224.63,39.08 226.97,39.08 v2(228.26,40.37)
  BOTTOM w0.211: v2(177.15,43.99) 177.6,43.54 180.07,43.54 180.52,43.98 JDIMM1.114
DDR_A_ALERT#: length 77.3
  TOP w0.076: v2(228.9,39.75) v1(229.41,39.75) 229.78,39.75 230.06,40.03 233.35,40.03 UC1.AU5
  TOP w0.211: v2(176.44,44.12) 176.69,44.37 176.81,44.37 176.96,44.53 176.96,44.64 176.82,44.79 176.26,44.79 176.04,44.57 175.78,44.57 175.55,44.79 175.36,44.79 175.22,44.65 175.22,44.35 175.39,44.19 175.39,43.88 175.27,43.75 175.09,43.75 174.88,43.96 174.88,44.37 174.77,44.48 JDIMM2.116
  IN1 w0.188: v2(176.44,44.12) 176.05,43.73 176.05,42.85 176.34,42.56 178.05,42.56 179.04,41.57 181.33,41.57 181.68,41.21 184.5,41.21 185.04,40.67 187.58,40.67 188.87,39.38 200.52,39.38 204.17,35.74 211.87,35.74 213.06,34.55 216.64,34.55 217.73,35.64 218.88,35.64 220.22,36.98 222.05,36.98 222.59,37.53 224.51,37.53 224.95,37.97 226.63,37.97 228.41,39.75 v2(228.9,39.75)
  BOTTOM w0.211: JDIMM1.116 180.52,44.48 179.9,43.87 177.98,43.87 177.42,44.43 176.75,44.43 v2(176.44,44.12)
DDR_A_BA0: length 79.4
  TOP w0.076: UC1.AH5 233.45,47.67 230.39,47.67 v2(230.13,47.41)
  TOP w0.211: JDIMM2.150 174.41,54.98 174.68,54.71 175.19,54.71 175.46,54.98 175.46,55.63 175.71,55.88 176.85,55.88 v2(177.29,55.44)
  IN1 w0.076: 220.98,50.3 221.51,50.3 223.33,48.48 228.11,48.48 228.72,47.87 231.57,47.87 231.64,47.79 231.64,47.15 231.38,46.89 230.65,46.89 v2(230.13,47.41)
  IN1 w0.188: v2(177.29,55.44) 177.29,55.12 177.47,54.95 180.28,54.95 180.31,54.91 186.39,54.91 186.96,55.47 187.57,55.47 188.86,56.76 190.17,56.76 190.77,57.36 193.3,57.36 194.46,56.2 194.73,56.2 194.9,56.37 194.9,56.98 195.07,57.16 195.32,57.16 195.49,56.98 195.49,56.37 195.67,56.2 197.64,56.2 198.08,55.76 204.67,55.76 204.84,55.59 204.84,55.38 205.02,55.21 205.26,55.21 205.44,55.38 205.44,55.59 205.61,55.76 205.86,55.76 206.03,55.59 206.03,55.38 206.21,55.21 206.45,55.21 206.63,55.38 206.63,55.59 206.8,55.76 208.83,55.76 214.34,50.25 215.13,50.25 215.81,50.93 217.62,50.93 218.25,50.3 220.98,50.3
  BOTTOM w0.211: v2(177.29,55.44) 177.72,55.01 180.27,55.01 180.29,54.98 JDIMM1.150
DDR_A_BA1: length 77.7
  TOP w0.076: UC1.AH1 228.96,48.17 v2(228.2,47.41)
  TOP w0.211: JDIMM2.145 181.36,53.73 181.12,53.49 181.12,52.74 180.91,52.53 180.59,52.53 180.38,52.74 180.38,53.07 180.16,53.28 179.85,53.28 179.69,53.12 179.69,52.72 179.54,52.57 179.24,52.57 179.08,52.73 179.08,53.5 v2(179.56,53.98)
  IN1 w0.076: v2(228.2,47.41) 227.62,48 222.55,48 221.36,49.19 220.95,49.19
  IN1 w0.188: 220.95,49.19 213.9,49.19 208.42,54.67 208.17,54.67 208,54.49 208,54.25 210.74,51.51 210.74,51.26 210.56,51.09 210.32,51.09 207.75,53.65 205.81,53.65 205.33,54.13 204.4,54.13 203.82,54.7 197.64,54.7 197.2,55.14 194.02,55.14 193.46,55.69 189.3,55.69 188.01,54.41 187.4,54.41 186.83,53.85 179.7,53.85 v2(179.56,53.98)
  BOTTOM w0.211: v2(179.56,53.98) 179.16,54.38 175.7,54.38 175.05,53.73 JDIMM1.145
DDR_A_BG0: length 72.1
  TOP w0.076: UC1.AU1 230.78,40.63 230.36,41.04 228.41,41.04 227.87,40.51 227.87,39.74 v1(226.73,38.61) 226,37.87 v2(226,37.06)
  TOP w0.211: JDIMM2.115 181.07,44.23 180.2,43.36 179.12,43.36 177.87,42.12 177.42,42.12 v2(177.4,42.15)
  IN1 w0.188: v2(226,37.06) 225.91,37.15 225.16,37.15 224.71,36.7 222.59,36.7 222.24,36.35 220.5,36.35 219.17,35.02 217.85,35.02 216.86,34.02 212.84,34.02 211.65,35.21 203.95,35.21 200.96,38.2 196.55,38.2 196.05,38.71 188.46,38.71 186.93,40.24 184.74,40.24 184.4,40.58 181.13,40.58 180.57,41.14 178.8,41.14 177.82,42.12 177.42,42.12 v2(177.4,42.15)
  BOTTOM w0.211: JDIMM1.115 174.94,44.23 175.49,43.69 176.81,43.69 177.62,42.87 177.62,42.37 v2(177.4,42.15)
