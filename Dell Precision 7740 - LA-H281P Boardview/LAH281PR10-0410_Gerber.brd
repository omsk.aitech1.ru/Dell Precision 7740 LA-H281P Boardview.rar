# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_MA7: length 66.1
  TOP w0.076: v2(237.53,44.72) UC1.AN10
  TOP w0.211: v2(191.1,46.14) 191.1,46.36 190.89,46.58 189.39,46.58 189.17,46.36 189.17,45.87 189.01,45.7 188.62,45.7 188.34,45.98 JDIMM4.122
  IN4 w0.076: 221.39,41.64 221.75,42 224.75,42 226.04,43.28 234.25,43.28 235.07,44.1 235.73,44.1 235.97,44.34 237.15,44.34 v2(237.53,44.72)
  IN4 w0.188: 221.39,41.64 217.93,38.17 215.95,38.17 215.26,38.86 207.76,38.86 207.58,39.04 207.58,39.28 207.76,39.46 208.15,39.46 208.33,39.63 208.33,39.88 208.15,40.05 204.85,40.05 200.93,43.97 196.22,43.97 195.04,45.14 192.67,45.14 192.11,45.7 191.62,45.7 191.06,45.14 190.73,45.14 190.56,45.31 190.56,45.61 v2(191.1,46.14)
  BOTTOM w0.211: v2(191.1,46.14) 191.55,45.69 193.98,45.69 194.26,45.98 195.59,45.98 JDIMM3.122
DDR_B_MA8: length 68.7
  TOP w0.076: v2(236.23,44.72) UC1.AN8
  TOP w0.211: v2(192.34,46.14) 192,45.8 192,45.58 192.13,45.45 192.36,45.45 192.57,45.66 194.15,45.66 194.47,45.98 194.47,46.53 194.66,46.73 JDIMM4.125
  IN4 w0.076: v2(236.23,44.72) 236.09,44.72 235.71,44.34 235.04,44.34 234.19,43.49 225.85,43.49 224.66,42.31 221.31,42.31
  IN4 w0.188: 221.31,42.31 217.71,38.7 216.17,38.7 215.48,39.39 209.03,39.39 208.86,39.57 208.86,39.81 209.03,39.99 212.67,39.99 212.84,40.16 212.84,40.41 212.67,40.58 205.07,40.58 201.18,44.46 196.48,44.46 195.33,45.62 192.87,45.62 v2(192.34,46.14)
  BOTTOM w0.211: v2(192.34,46.14) 191.86,46.62 188.92,46.62 188.82,46.72 JDIMM3.125
DDR_B_MA9: length 65.3
  TOP w0.076: v2(238.18,42.89) UC1.AR11
  TOP w0.211: JDIMM4.121 194.65,45.73 194.15,45.22 194.15,44.74 193.87,44.45 193.64,44.45 193.45,44.64 193.45,45.21 193.32,45.35 192.72,45.35 192.36,44.99 192.36,44.77 192.57,44.56 192.9,44.56 193.03,44.43 v2(193.03,44.17)
  IN4 w0.076: 222.28,40.71 222.4,40.83 222.4,41.25 222.63,41.48 226.55,41.48 226.94,41.86 229.73,41.86 230.73,42.87 234.42,42.87 235.26,43.7 235.82,43.7 236.1,43.42 237.27,43.42 237.34,43.36 237.72,43.36 v2(238.18,42.89)
  IN4 w0.188: 222.28,40.71 218.68,37.11 215.08,37.11 214.91,37.29 214.91,37.62 214.73,37.79 214.48,37.79 214.31,37.62 214.31,37.29 214.14,37.11 213.94,37.11 213.25,37.8 207.32,37.8 206.13,38.99 204.41,38.99 200.89,42.5 196.26,42.5 194.6,44.17 v2(193.03,44.17)
  BOTTOM w0.211: v2(193.03,44.17) 193.02,44.18 193.02,44.22 192.64,44.6 191.94,44.93 189.75,44.93 188.96,45.73 187.4,45.73 JDIMM3.121
DDR_B_MA10: length 71
  TOP w0.076: v2(235.58,48.38) UC1.AH7
  TOP w0.211: JDIMM4.146 186.61,53.98 186.45,53.81 186.45,53.52 186.73,53.24 188.02,53.24 188.86,54.07 v2(190.37,54.07)
  IN4 w0.076: v2(235.58,48.38) 235.51,48.44 231.62,48.44 231.5,48.56 223.7,48.56 221.57,50.7 221.51,50.7
  IN4 w0.188: 221.51,50.7 217.65,50.7 217.41,50.93 215.94,50.93 215.67,51.21 214.8,51.21 211.42,54.58 208.37,54.58 207.6,55.35 204.02,55.35 202.91,54.24 196.37,54.24 195.96,53.83 192.44,53.83 192.14,53.52 189.86,53.52 189.25,54.13 186.01,54.13 185.79,54.36 185.79,54.63 186,54.84 189.61,54.84 v2(190.37,54.07)
  BOTTOM w0.211: JDIMM3.146 193.59,53.98 193.39,54.17 192.27,54.17 191.75,53.64 190.8,53.64 v2(190.37,54.07)
DDR_B_MA11: length 71
  TOP w0.076: v2(238.18,44.72) UC1.AN11
  TOP w0.211: JDIMM4.120 188.17,45.48 188.41,45.23 189.78,45.23 190.22,44.79 190.98,44.79 191.13,44.95 191.13,45.37 190.98,45.53 190.49,45.53 v2(189.88,46.14)
  IN4 w0.076: 221.57,40.75 221.67,40.85 221.67,41.26 222.16,41.75 224.86,41.75 226.18,43.07 234.33,43.07 235.18,43.92 235.84,43.92 236.08,44.17 237.3,44.17 237.41,44.27 237.73,44.27 v2(238.18,44.72)
  IN4 w0.188: 221.57,40.75 218.46,37.64 215.73,37.64 215.04,38.33 207.54,38.33 206.35,39.52 204.63,39.52 201.12,43.03 196.48,43.03 194.82,44.68 188.71,44.68 188.36,45.04 188.36,45.48 188.72,45.84 189.57,45.84 v2(189.88,46.14)
  BOTTOM w0.211: JDIMM3.120 195.59,45.48 194.45,45.48 194.32,45.34 190.69,45.34 v2(189.88,46.14)
DDR_B_MA12: length 65.4
  TOP w0.076: v2(237.53,42.89) UC1.AR10
  TOP w0.211: JDIMM4.119 194.85,45.23 194.52,44.89 194.52,44.62 193.62,43.73 191.97,43.73 191.76,43.94 v2(191.76,44.16)
  IN4 w0.076: v2(237.53,42.89) 237.17,43.25 235.97,43.25 235.71,43.52 235.32,43.52 234.47,42.66 230.77,42.66 229.72,41.62 227.72,41.62 226.62,40.52 223.78,40.52
  IN4 w0.188: 223.78,40.52 222.84,40.52 218.9,36.58 213.21,36.58 213.03,36.76 213.03,37.07 212.86,37.25 212.61,37.25 212.44,37.07 212.44,36.76 212.26,36.58 212.02,36.58 211.84,36.76 211.84,37.07 211.67,37.25 211.42,37.25 211.25,37.07 211.25,36.76 211.08,36.58 210.83,36.58 210.65,36.76 210.65,37.07 210.48,37.25 210.23,37.25 210.06,37.07 210.06,36.76 209.89,36.58 209.66,36.58 208.97,37.26 207.1,37.26 205.91,38.46 204.19,38.46 200.74,41.91 196.19,41.91 194.34,43.75 191.92,43.75 191.76,43.91 v2(191.76,44.16)
  BOTTOM w0.211: v2(191.76,44.16) 191.76,44.39 191.58,44.58 189.46,44.58 188.81,45.23 187.4,45.23 JDIMM3.119
DDR_B_MA13: length 72
  TOP w0.076: v2(236.88,50.21) UC1.AF9
  TOP w0.211: JDIMM4.158 188.55,56.98 188.61,56.91 189.87,56.91 190.08,57.12 190.08,57.52 190.29,57.73 190.73,57.73 190.94,57.51 v2(190.94,56.75)
  IN4 w0.076: v2(236.88,50.21) 236.49,50.6 235.36,50.6 235.21,50.75 226.87,50.75 226.01,51.61
  IN4 w0.188: v2(190.94,56.75) 190.23,56.75 189.65,57.33 189.65,57.78 189.85,57.98 190.12,57.98 190.69,57.42 190.95,57.42 191.42,57.89 193.79,57.89 194.28,58.37 194.86,58.37 196.53,60.04 199.81,60.04 202.8,63.02 204,63.02 204.24,63.27 204.93,63.27 205.7,64.04 206.36,64.04 206.56,63.83 206.56,63.2 206.74,63.02 206.98,63.02 207.16,63.2 207.16,64.07 207.31,64.23 207.56,64.23 207.75,64.04 207.75,63.4 207.92,63.23 208.17,63.23 208.35,63.41 208.35,64.07 208.5,64.23 208.81,64.23 214.52,58.51 214.74,58.51 217.07,56.18 217.43,56.18 218.85,54.76 222.86,54.76 226.01,51.61
  BOTTOM w0.211: v2(190.94,56.75) 191.44,57.26 194.57,57.26 194.86,56.97 JDIMM3.158
DDR_B_MA14: length 67.3
  TOP w0.076: v2(238.18,48.38) UC1.AH11
  TOP w0.211: JDIMM4.151 194.8,55.23 194.3,55.72 193.93,55.72 193.72,55.51 193.72,54.89 193.51,54.68 192.51,54.68 v2(191.92,55.27)
  IN4 w0.076: v2(238.18,48.38) 237.77,47.96 237.43,47.96 237.21,48.19 237.21,48.66 237.11,48.76 235.99,48.76 235.78,48.97 235.4,48.97 235.21,48.78 231.99,48.78 231.81,48.96 224.43,48.96 223.75,49.65 223.75,50.11 223.19,50.66
  IN4 w0.188: v2(191.92,55.27) 192.38,54.8 195.44,54.8 196.02,55.38 196.59,55.38 197.23,56.03 200.01,56.03 200.47,56.49 210.1,56.49 210.27,56.66 210.27,56.91 210.1,57.08 209.01,57.08 208.84,57.26 208.84,57.5 209.01,57.68 210.64,57.68 211.22,57.1 211.22,56.85 211.08,56.7 211.08,56.46 211.25,56.28 211.5,56.28 211.64,56.43 211.89,56.43 212.21,56.11 212.21,55.3 215.15,52.36 217.48,52.36 218.09,51.76 222.09,51.76 223.19,50.66
  BOTTOM w0.211: v2(191.92,55.27) 191.46,55.72 188.96,55.72 188.46,55.22 JDIMM3.151
DDR_B_MA15: length 70.3
  TOP w0.076: v2(236.23,50.21) UC1.AF8
  TOP w0.211: v2(191.7,56.76) 191.17,56.23 190.64,56.23 190.39,56.48 JDIMM4.156
  IN4 w0.076: v2(236.23,50.21) 236.21,50.23 235.46,50.23 235.1,50.59 226.6,50.59 225.29,51.9
  IN4 w0.188: 225.29,51.9 222.87,54.32 218.73,54.32 217.4,55.65 216.85,55.65 214.77,57.73 214.55,57.73 210.62,61.67 210.02,61.67 209.81,61.87 209.81,62.47 209.1,63.19 208.89,63.19 208.68,62.98 208.68,62.63 208.5,62.45 208.07,62.45 207.82,62.7 207.5,62.7 207.29,62.49 206.87,62.49 206.71,62.34 206.71,61.81 206.57,61.67 206.23,61.67 206.05,61.84 206.05,63.05 205.88,63.22 205.64,63.22 205.46,63.05 205.46,61.84 205.29,61.67 205.04,61.67 204.87,61.84 204.87,62.58 204.71,62.74 204.46,62.74 204.27,62.55 204.27,61.84 204.1,61.67 203.85,61.67 203.68,61.84 203.68,62.3 203.5,62.48 203.26,62.48 203.08,62.3 203.08,61.84 202.91,61.67 202.19,61.67 201.63,61.1 201.63,60.7 201.47,60.55 201.07,60.55 200.03,59.51 196.75,59.51 194.96,57.72 194.54,57.72 194.09,57.27 193.2,57.27 193.07,57.41 192.57,57.41 192.43,57.27 192.12,57.27 191.94,57.46 191.64,57.46 191.47,57.28 191.47,56.99 v2(191.7,56.76)
  BOTTOM w0.211: JDIMM3.156 194.82,56.47 194.46,56.84 193.53,56.84 193.33,56.64 193.33,56.42 193.12,56.21 192.25,56.21 v2(191.7,56.76)
DDR_B_MA16: length 72.1
  TOP w0.076: v2(237.57,48.38) 237.25,47.93 UC1.AH10
  TOP w0.211: v2(193.17,55.28) 192.72,55.73 188.87,55.73 188.61,55.48 JDIMM4.152
  IN4 w0.076: v2(237.57,48.38) 237.57,48.38 237.57,48.68 237.33,48.92 236.06,48.92 235.85,49.13 235.33,49.13 235.14,48.95 232.14,48.95 231.94,49.14 224.83,49.14 224.57,49.39 224.57,50.06 224.25,50.38
  IN4 w0.188: 224.25,50.38 222.23,52.4 218.19,52.4 217.58,53 215.26,53 212.74,55.52 212.74,56.33 209.67,59.4 207.6,59.4 207.42,59.22 207.42,58.98 207.6,58.8 209.34,58.8 209.51,58.63 209.51,58.38 209.34,58.21 208.49,58.21 208.3,58.02 208.3,57.23 208.09,57.02 205.52,57.02 205.35,57.19 205.35,57.56 205.18,57.73 204.93,57.73 204.76,57.56 204.76,57.19 204.58,57.02 203.64,57.02 203.46,57.19 203.46,57.56 203.29,57.73 203.04,57.73 202.87,57.56 202.87,57.19 202.69,57.02 202.47,57.02 201.8,57.69 201.43,57.69 200.98,57.24 197.69,57.24 196.38,55.93 195.88,55.93 195.23,55.28 v2(193.17,55.28)
  BOTTOM w0.203: JDIMM3.152 195.59,55.48 194.72,55.48 194.51,55.68 194.51,56.3 194.3,56.51 193.92,56.51 193.57,56.16 193.57,55.8 194.29,55.08 194.29,54.89 194.05,54.66 193.84,54.66 193.22,55.28 v2(193.17,55.28)
DDR_B_ODT0: length 61.9
  TOP w0.076: v2(234.95,50.23) 235.26,49.92 UC1.AF7
  TOP w0.168: JDIMM4.155 194.52,56.23 194.35,56.39 193.3,56.39 v2(192.92,56.77)
  IN4 w0.076: 225.22,51.57 226.37,50.42 233.23,50.42 233.42,50.23 v2(234.95,50.23)
  IN4 w0.152: v2(192.92,56.77) 194.5,56.77 194.94,57.21 195.41,57.21 197.03,58.83 200.32,58.83 201.34,59.86 201.74,59.86 201.89,59.71 201.89,59.51 202.04,59.36 202.3,59.36 202.45,59.51 202.45,59.71 202.6,59.86 204.96,59.86 205.11,60.01 205.11,60.27 204.96,60.42 202.46,60.42 202.31,60.57 202.31,60.83 202.47,60.99 207.35,60.99 207.5,61.14 207.5,61.64 207.65,61.79 207.91,61.79 208.06,61.64 208.06,61.14 208.21,60.99 208.46,60.99 208.62,61.14 208.62,61.64 208.77,61.79 209.02,61.79 209.18,61.64 209.18,61.14 209.33,60.99 210.33,60.99 215.05,56.27 215.27,56.27 215.65,55.89 215.65,55.68 215.36,55.39 215.36,55.17 215.54,54.99 215.75,54.99 215.97,55.21 216.04,55.28 216.26,55.28 216.7,54.85 217.53,54.85 218.59,53.79 223,53.79 225.22,51.57
DDR_B_ODT1: length 64.2
  TOP w0.076: v2(236.23,51.12) UC1.AE8
  TOP w0.168: JDIMM4.161 193.75,57.73 192.55,58.92 v2(192.55,59.56)
  IN4 w0.076: 219.91,55.82 220.12,55.61 223.13,55.61 227.42,51.32 235.25,51.32 235.46,51.53 235.74,51.53 235.94,51.32 236.03,51.32 v2(236.23,51.12)
  IN4 w0.152: v2(192.55,59.56) 192.31,59.8 192.31,59.98 192.52,60.19 192.71,60.19 193.09,59.81 193.44,59.81 193.79,60.16 194.4,60.16 196.16,61.93 196.51,61.93 196.67,62.08 196.67,62.36 196.79,62.48 197.19,62.48 197.44,62.23 197.73,62.23 197.99,62.48 198.32,62.48 198.58,62.22 198.96,62.22 199.22,62.48 199.78,62.48 201.92,64.62 203.34,64.62 204.5,65.78 205.12,65.78 205.27,65.94 205.27,66.38 205.42,66.54 205.68,66.54 205.83,66.38 205.83,66.06 205.98,65.91 206.24,65.91 206.39,66.06 206.39,66.38 206.54,66.54 206.79,66.54 206.95,66.38 206.95,66.06 207.1,65.91 207.35,65.91 207.51,66.06 207.51,66.38 207.66,66.54 207.91,66.54 208.06,66.38 208.06,66.06 208.22,65.91 208.47,65.91 208.62,66.06 208.62,66.38 208.78,66.54 209.03,66.54 209.18,66.38 209.18,66.06 209.33,65.91 210.06,65.91 211.49,64.48 211.49,64.27 211.37,64.15 211.37,63.93 211.55,63.75 211.76,63.75 211.88,63.87 212.1,63.87 212.28,63.69 212.28,63.48 212.16,63.36 212.16,63.14 212.34,62.96 212.55,62.96 212.67,63.08 212.89,63.08 213.24,62.73 213.24,62.56 213.12,62.43 213.12,62.17 215.19,60.1 215.63,60.1 219.91,55.82
DDR_B_ODT2: length 65.8
  TOP w0.076: v2(236.88,51.12) UC1.AE9
  IN4 w0.076: 220.45,55.95 220.63,55.78 223.26,55.78 227.55,51.49 235.18,51.49 235.41,51.72 235.81,51.72 236.04,51.49 236.51,51.49 v2(236.88,51.12)
  IN4 w0.152: 220.45,55.95 215.85,60.56 215.38,60.56 213.7,62.23 213.7,62.92 209.62,66.99 205.07,66.99 203.15,65.07 201.73,65.07 199.6,62.94 196.52,62.94 194.2,60.61 192.17,60.61 191.64,60.08 188.82,60.08 188.68,59.93 188.68,59.67 188.76,59.58 v2(189.96,59.58)
  BOTTOM w0.168: JDIMM3.155 188.69,56.22 190.14,57.67 190.14,58.31 189.96,58.49 v2(189.96,59.58)
DDR_B_ODT3: length 67.3
  TOP w0.076: v2(238.18,51.12) UC1.AE11
  IN4 w0.076: 220.97,56.15 221.17,55.94 223.33,55.94 227.44,51.83 231.57,51.83 231.98,52.24 233.93,52.24 234.5,51.66 235.12,51.66 235.34,51.88 235.88,51.88 236.1,51.66 237.1,51.66 237.14,51.62 237.69,51.62 v2(238.18,51.12)
  IN4 w0.152: 220.97,56.15 216.1,61.01 215.57,61.01 214.16,62.42 214.16,63.11 209.81,67.45 204.88,67.45 202.97,65.54 201.55,65.54 199.41,63.39 196.33,63.39 194.02,61.08 188.68,61.08 188.56,60.95 188.56,60.65 188.68,60.54 v2(190.1,60.54)
  BOTTOM w0.168: JDIMM3.161 187.4,57.73 188.41,57.73 188.89,58.2 188.89,59.91 189.52,60.54 v2(190.1,60.54)
DDR_B_PARITY: length 66.9
  TOP w0.076: v2(235.58,47.46) UC1.AJ7
  TOP w0.211: JDIMM4.143 194.85,51.23 194.42,51.65 192.75,51.65 191.86,52.55 189.42,52.55 v2(188.97,52.1)
  IN4 w0.076: 221.98,49.11 222.14,49.11 223.18,48.07 231.21,48.07 231.33,47.95 234.97,47.95 235.45,47.46 v2(235.58,47.46)
  IN4 w0.188: 221.98,49.11 217.8,49.11 217.56,48.86 214.22,48.86 211.28,51.8 201.39,51.8 200.62,52.57 192.72,52.57 192.17,53.11 190.31,53.11 190.04,52.83 189.72,52.83 188.97,53.59 188.73,53.59 188.47,53.33 188.47,53.01 188.97,52.51 v2(188.97,52.1)
  BOTTOM w0.211: JDIMM3.143 188.03,51.22 188.24,51.44 188.24,52.19 187.76,52.67 187.76,53.05 187.99,53.27 190.04,53.27 190.21,53.1 190.21,52.76 190,52.55 189.16,52.55 188.97,52.36 v2(188.97,52.1)
DDR_RCOMP0: length 7.5
  TOP w0.127: v1(226.65,66.88) 227.1,67.32 RC5.2
  TOP w0.305: UC1.G1 231.35,64.44 229.85,65.94 229.85,66.7 228.59,67.96 RC5.2
DDR_RCOMP1: length 6.9
  TOP w0.127: v1(225.19,64.26) 225.4,64.47 226.78,64.47 227.11,64.13 RC6.2
  TOP w0.305: RC6.2 228.59,64 228.86,64.26 230.39,64.26 231.15,63.51 UC1.H1
DDR_RCOMP2: length 5.6
  TOP w0.305: RC7.2 227.27,63.39 v1(228.17,63.39) 229.03,63.39 229.43,63.79 229.9,63.79 230.8,62.89 231.48,62.89 231.8,63.21 UC1.J2
DDR_VTT_CTRL: length 101.4
  TOP w0.102: v2(237.29,21.43) 237.65,21.43 237.89,21.68 237.89,24.4 238.28,24.78 238.71,24.78 238.95,25.02 238.95,25.78 239.37,26.2 UC1.BT13
  BOTTOM w0.109: v2(237.29,21.43) 236.02,21.43 228.66,14.07 214.9,14.07 212.53,11.71 183.32,11.71 180.71,14.32 179.42,14.32 177.62,12.52 171.85,12.52 171.02,11.7 163.82,11.7 163.1,12.41 155.89,12.41 155.64,12.65 151.83,12.65 v4(151.61,12.87) 151.08,13.4 UD1.2
DDR_XDP_WAN_SMBCLK: length 398.5
  TOP w0.109: v2(111.09,21.65) 110.82,21.92 RH333.1 110.5,22.67 QH4.1 ; v2(184.55,81.37) 184.4,81.22 183.45,81.22 182.97,80.73 JDIMM2.253 ; v2(198.61,79.78) 197.66,80.73 JDIMM4.253
  IN1 w0.102: v2(111.09,21.65) 110.09,22.65 109.79,22.65 107.96,24.48 107.96,25.32 107.45,25.83 106.41,25.83 105.89,25.32 105.89,25 105.64,24.75 104.44,24.75 104.19,25.01 104.19,26.02 103.81,26.4 103.81,27.8 104.97,28.96 104.97,31.18 105.46,31.67 105.46,33.73 100.01,39.18 98.64,39.18 97.76,40.06 97.76,45.99 97.17,46.58 97.17,51.46 101.52,55.81 102.54,55.81 103.53,56.8 105.94,56.8 107.4,58.25 107.4,62.01 105.84,63.57 105.84,66.48 108.84,69.48 108.84,75.31 110.35,76.82 110.35,81.64 109.61,82.37 109.61,84.52 109.13,85.01 109.13,87.62 v2(109.44,87.92) ; v2(240.74,16.93) 240.87,17.06 240.87,20.78 239.62,22.03 239.62,23.11 241.37,24.87 241.37,25.1 v2(241.13,25.35)
  IN2 w0.081: v2(162.93,98.89) 163.12,99.08 163.12,99.37 162.56,99.94 155.01,99.94 153.62,101.34 151.51,101.34 150.95,100.78 150.95,100.14 150.44,99.63 149.07,99.63 147.62,98.19 143.01,98.19 141.81,99.39 136.77,99.39 135.81,98.44 126.22,98.44 125.2,99.46 120.89,99.46 117.46,96.03 114.12,96.03 113.13,95.04 113.13,91.18 111.19,89.25 109.78,89.25 109.19,88.66 109.19,88.17 v2(109.44,87.92) ; v2(198.61,79.78) 198.4,79.98 198.4,80.22 197.76,80.86 186.89,80.86 185.95,81.8 184.99,81.8 v2(184.55,81.37) 182.22,81.37 179.74,83.86 179.14,83.86 178.99,84.01 v2(178.79,84.01)
  IN4 w0.102: v2(240.74,16.93) 240.98,16.68 240.98,16.24 241.15,16.07 243.48,16.07 244.32,16.91 245.87,16.91 246.03,17.07 247.62,17.07 248,17.45 255.58,17.45 256.65,16.38 257.77,16.38 259.64,14.52 269.33,14.52 272.07,11.77 291.25,11.77 291.87,12.4 291.87,13.33 294.9,16.35 296,16.35 303.39,23.74 303.55,23.74 304.01,23.28 v2(304.01,23.24)
  BOTTOM w0.102: 174.64,80.73 175.21,81.31 175.21,83.54 176.13,84.46 178.34,84.46 v2(178.79,84.01)
  BOTTOM w0.109: v2(240.74,16.93) 240.95,16.72 240.95,16.22 240.68,15.96 JXDP1.53 ; JDIMM1.253 174.64,80.73 ; v2(241.13,25.35) 241.34,25.13 241.34,25.03 241.23,24.92 239.09,24.92 237.94,23.76 237.94,23.52 237.53,23.1 229.71,23.1 228.92,23.89 217.26,23.89 211.26,29.9 211.26,68.27 204.49,75.04 201.81,75.04 200.65,76.2 199.5,76.2 198.41,77.29 198.41,79.21 198.61,79.41 v2(198.61,79.78) ; JDIMM3.253 185.2,80.73 v2(184.55,81.37) ; v2(178.79,84.01) 179.03,84.01 179.18,84.17 179.18,84.31 177.97,85.52 175.01,85.52 173.01,87.52 173.01,93.67 172.82,93.87 166.93,93.87 163.16,97.65 163.16,98.67 v2(162.93,98.89)
  BOTTOM w0.203: LGA1.1 v2(304.01,23.24)
DDR_XDP_WAN_SMBDAT: length 397.3
  TOP w0.102: JDIMM2.254 174.77,80.98 175.18,81.4 175.18,83.49 176.18,84.5 178.99,84.5 179.43,84.05 179.43,83.94 v2(178.92,83.43)
  TOP w0.109: QH4.4 107.94,24.93 RH374.1 107.58,24.98 v2(107.28,24.68) ; v2(185.16,81.37) 185.18,81.35 185.64,81.35 186.01,80.98 JDIMM4.254
  IN1 w0.102: v2(108.72,87.92) 108.9,87.74 108.9,84.91 109.38,84.43 109.38,82.28 110.12,81.54 110.12,76.92 108.61,75.41 108.61,69.57 105.61,66.57 105.61,63.48 107.17,61.92 107.17,58.35 105.85,57.03 103.44,57.03 102.45,56.03 101.43,56.03 96.94,51.55 96.94,46.48 97.53,45.89 97.53,39.96 98.54,38.95 99.92,38.95 105.23,33.64 105.23,31.77 104.74,31.28 104.74,29.05 103.58,27.89 103.58,26.3 103.96,25.92 103.96,24.91 104.35,24.53 105.74,24.53 106.12,24.91 106.12,25.22 106.5,25.61 107.35,25.61 107.73,25.22 107.73,24.81 107.6,24.68 v2(107.28,24.68) ; v2(241.45,16.93) 241.1,17.28 241.1,20.88 239.85,22.13 239.85,23.02 241.6,24.77 241.6,25.11 v2(241.84,25.35)
  IN2 w0.081: v2(178.92,83.43) 178.92,83.52 179.03,83.63 179.64,83.63 182.13,81.14 184.15,81.14 184.38,80.91 184.71,80.91 v2(185.16,81.37) 185.18,81.35 186.08,81.35 186.8,80.63 197.67,80.63 198.17,80.13 198.17,79.98 v2(197.97,79.78) ; v2(108.72,87.92) 108.96,88.17 108.96,88.76 109.68,89.47 111.1,89.47 112.9,91.28 112.9,95.13 114,96.24 117.38,96.24 120.81,99.66 125.29,99.66 126.3,98.65 135.73,98.65 136.68,99.6 141.89,99.6 143.08,98.41 147.53,98.41 148.98,99.86 150.35,99.86 150.72,100.24 150.72,100.87 151.41,101.56 153.71,101.56 155.11,100.17 162.65,100.17 163.35,99.47 163.35,99.19 v2(163.65,98.89)
  IN4 w0.102: v2(304,24.74) 295.83,16.58 294.8,16.58 291.65,13.42 291.65,12.49 291.15,12 272.17,12 269.42,14.75 259.73,14.75 257.87,16.61 256.74,16.61 255.68,17.68 247.9,17.68 247.53,17.3 245.93,17.3 245.77,17.14 244.23,17.14 243.39,16.3 241.24,16.3 241.21,16.33 241.21,16.68 v2(241.45,16.93)
  BOTTOM w0.102: JDIMM3.254 195.59,80.98 196.93,80.98 ; 197.96,79.79 v2(197.97,79.78)
  BOTTOM w0.109: v2(241.45,16.93) 241.18,16.66 241.18,16.21 241.28,16.11 JXDP1.51 ; 196.93,80.98 197.25,80.98 197.96,80.27 197.96,79.79 ; v2(241.84,25.35) 241.58,25.08 241.58,24.93 241.32,24.68 239.19,24.68 238.17,23.66 238.17,23.42 237.62,22.87 229.61,22.87 228.82,23.65 217.17,23.65 211.02,29.8 211.02,68.17 204.39,74.8 201.71,74.8 200.55,75.96 199.4,75.96 198.17,77.19 198.17,79.21 197.97,79.41 v2(197.97,79.78) ; JDIMM1.254 180.73,80.98 179.72,81.99 179.72,82.62 v2(178.92,83.43) 179.42,83.93 179.42,84.41 178.07,85.76 175.11,85.76 173.25,87.62 173.25,93.77 172.92,94.1 167.03,94.1 163.39,97.75 163.39,98.64 v2(163.65,98.89)
  BOTTOM w0.203: LGA1.4 v2(304,24.74)
DEBUG_TX: length 7.3
  BOTTOM w0.109: v1(117.82,52.35) 117.82,52.96 117.09,53.69 RE30.1 RE74.2 116.58,54.56 116.33,54.31 JDEG1.9
DG_GPIO8: length 2.6
  TOP w0.109: RT503.1 RT553.1 42.07,50.92 41.59,50.44 v2(40.99,50.44)
  BOTTOM w0.109: UT1.W6 v2(40.99,50.44)
DG_PA_USB2_MXCTL: length 5.9
  BOTTOM w0.076: 39.02,52.87 39.02,52.34 UT1.R2
  BOTTOM w0.102: 39.02,52.87 39.02,53.56
  BOTTOM w0.109: RT508.1 40.03,57.25 40.03,55.11 39.02,54.1 39.02,53.56
DG_PB_USB2_MXCTL: length 3.4
  BOTTOM w0.109: RT509.1 39.57,55.03 38.72,54.18 v1(38.72,54.03) 38.72,53.69 38.79,53.62 UT1.R1
DGFF_ALERT#: length 59.9
  TOP w0.109: JDGFF1.A10 239.01,93.56 240.29,94.84 269.74,94.84 v2(271.09,93.49)
  BOTTOM w0.109: QV41.3 282.84,79.12 282.76,79.05 RV803.2 282.48,78.37 281.47,79.39 281,79.39 279.37,81.02 278.34,81.02 277.61,80.28 277.21,80.28 276.92,80.57 275.09,80.57 v1(271.35,84.31) 271.22,84.44 271.22,89.36 271.73,89.86 271.73,92.85 v2(271.09,93.49)
DGFF_BIA_PWM: length 113.2
  TOP w0.109: v2(233.73,83.83) 233.73,84.07 v1(234.01,84.36) 234.19,84.54 236.36,84.54 237.29,85.47 243.19,85.47 243.67,85.95 246.41,85.95 246.89,86.43 246.89,87.11 247.29,87.52 JDGFF2.E1 ; UV65.2 165.71,122.54 v2(165.81,122.44)
  IN1 w0.102: v2(226.03,92.7) 227.04,91.69 228.01,91.69 229.32,90.37 229.32,88.8 229.59,88.53 230.17,88.53 230.27,88.64 230.76,88.64 231.01,88.38 231.06,88.38 231.34,88.1 231.34,86.74 233.73,84.35 v2(233.73,83.83)
  VCC w0.086: v2(165.81,122.44) 167.76,120.49 167.76,111.95 167.15,111.34 167.15,104.39 170.82,100.72 177.56,100.72 184.56,93.71 225.12,93.71 226.03,92.8 v2(226.03,92.7)
DGFF_CLK_REQ#: length 68.6
  TOP w0.109: v2(290.18,86.01) 290.18,86.28 289.7,86.76 v1(289.33,86.76) 288.14,86.76 287.87,86.49 287.87,83.46 282.82,78.41 v2(282.82,76.75) ; JDGFF2.C9 251.02,92.32 251.28,92.58 251.28,93.49 v2(251.13,93.64)
  VCC w0.086: v2(290.18,86.01) 289.78,86.4 286.33,86.4 285.41,85.48 277.83,85.48 277.7,85.61 268.42,85.61 268.22,85.41 253.65,85.41 253.04,84.8 251.13,84.8 250.39,85.54 250.39,88.03 251.13,88.76 v2(251.13,93.64)
  BOTTOM w0.109: QV42.3 283.23,76.44 RV807.2 283.08,75.86 282.82,76.12 v2(282.82,76.75)
DGFF_DP_HDMI_HPD: length 244.6
  TOP w0.109: UE1.F5 136.04,75.26 v2(135.67,75.63) ; v2(224.72,87.02) 224.72,86.74 223.16,85.18 223.16,82.41 DV43.1 224.11,81.46 233.25,81.46 235.62,83.82 237.38,83.82 237.59,84.04 242.21,84.04 243.24,83 252.29,83 252.63,82.66 258.49,82.66 261.51,85.68 283.71,85.68 285.31,84.08 285.31,82.01 281.41,78.11 281.41,76.72 282.07,76.06 283.46,76.06 284.45,77.05 285.37,77.05 287.23,78.91 288.5,78.91 v2(289.51,79.92)
  IN2 w0.081: v2(149.63,74.75) 148.35,76.04 148.35,77.76 148.09,78.01 146.6,78.01 144.3,80.31 134.63,80.31 133.67,79.36 133.67,78.66 133.9,78.43 134.23,78.43 134.26,78.45 135,78.45 135.27,78.19 135.27,76.09 135.67,75.68 v2(135.67,75.63)
  IN3 w0.081: v2(149.63,74.75) 150.31,75.44 150.31,77.61 156.06,83.35 v2(159.66,83.35)
  BOTTOM w0.109: v2(159.66,83.35) 159.04,83.98 157,83.98 154.15,86.83 154.15,91.99 157.93,95.77 158.39,95.77 161.96,99.33 164.8,99.33 165.24,99.77 170.76,99.77 171.02,99.52 171.02,98.8 173.78,96.03 v1(174.13,96.03) 178.35,96.03 182.09,92.28 199.47,92.28 200.82,90.94 208.03,90.94 213.2,85.77 223.94,85.77 224.72,86.55 v2(224.72,87.02) ; v2(135.67,75.63) 136.04,76 136.04,76.67 136.22,76.85 137.49,76.85 138.26,77.62 138.97,77.62 138.97,77.62 141.42,77.62 141.62,77.81 141.62,78.23 RV905.1 ; DV33.1 292.58,73.7 292.99,74.11 292.99,75.89 292.54,76.34 292.54,80.83 291.77,81.6 290.72,81.6 290.52,81.4 DV32.1 290.11,80.38 289.97,80.38 v2(289.51,79.92)
DGFF_ENVDD: length 176.4
  TOP w0.109: DV3.3 v2(121.55,145.19) ; v2(248.24,86.91) 248.55,86.6 249.21,86.6 249.79,87.18 JDGFF2.D1
  IN2 w0.081: v2(159.2,132.86) 160.73,132.86 161.14,132.45 168.85,132.45 169.2,132.09 169.2,107.68 168.87,107.34 168.87,104.6 v2(169.93,103.54)
  VCC w0.086: v2(248.24,86.91) 248.22,86.89 247.36,86.89 246.31,85.85 239.67,85.85 239.16,86.35 236.98,86.35 236.39,86.95 236.39,87.71 235.85,88.24 235.85,91.86 235.35,92.37 232.25,92.37 231.39,93.23 231.39,93.46 230.65,94.21 184.78,94.21 175.6,103.39 170.08,103.39 v2(169.93,103.54)
  BOTTOM w0.109: v2(159.2,132.86) v1(158.39,133.67) 158.07,133.99 151.3,133.99 150.65,133.35 146.76,133.35 139.42,140.69 129.28,140.69 126.5,143.46 123.28,143.46 v2(121.55,145.19)
DGFF_IFP_HPD: length 18.5
  TOP w0.109: JDGFF1.C2 235.84,88.12 236.26,87.71 236.26,86.49 236,86.24 234.05,86.24 233.53,85.71 224.48,85.71 223.99,85.22 v1(223.99,83.68) DV43.2
DGFF_OVERT#: length 53.3
  TOP w0.109: v2(235.72,86.92) 235.71,86.93 JDGFF1.C1
  VCC w0.086: v2(282.14,83.39) 281.36,82.61 276.32,82.61 275.73,83.2 275.73,83.59 274.66,84.65 273.29,84.65 272.96,84.98 254.95,84.98 254.24,84.28 243.71,84.28 243.11,84.87 236.63,84.87 235.72,85.79 v2(235.72,86.92)
  BOTTOM w0.109: v2(235.72,86.92) v1(235.21,86.92) ; v2(282.14,83.39) 281.7,83.39 281.5,83.19 QV40.3 281.29,82.84 280.94,82.49 RV816.2
DGFF_PANEL_BKEN: length 123.1
  TOP w0.109: DV36.2 169.39,131.66 169.21,131.84 v2(168.6,131.84) ; JDGFF2.D2 249.32,88.12 248.89,87.69 v2(248.89,87.14)
  IN2 w0.081: v2(169.27,103.51) 168.66,104.11 168.66,131.78 v2(168.6,131.84)
  VCC w0.086: v2(248.89,87.14) 248.89,86.63 248.67,86.41 248.04,86.41 247.81,86.64 247.46,86.64 246.42,85.6 239.57,85.6 239.06,86.11 236.88,86.11 236.14,86.84 236.14,87.61 235.32,88.42 232.13,88.42 231.68,88.87 231.68,91.85 231.14,92.39 231.14,93.36 230.54,93.96 184.67,93.96 175.49,103.14 169.64,103.14 v2(169.27,103.51)
  BOTTOM w0.109: v2(168.6,131.84) v1(168.6,131.31)
DGFF_PWR_LEVEL: length 45.5
  TOP w0.109: JDGFF2.H10 243.19,94.43 243.36,94.61 268.96,94.61 v2(269.44,94.12)
  BOTTOM w0.109: UV60.4 278.09,81.78 278.38,82.07 278.38,82.25 278,82.63 RV819.2 277.35,83.26 277.35,83.65 276.96,84.04 v1(276.58,84.04) 276.58,84.13 273.75,86.97 273.65,86.97 271.96,88.65 271.96,93.2 271.04,94.12 v2(269.44,94.12)
DGFF_VGA_DIS#: length 122.5
  TOP w0.109: JDGFF1.D1 234.41,87.52 v2(234.15,87.78)
  VCC w0.086: v2(173.43,99.25) 173.86,98.82 178.76,98.82 184.36,93.22 223.94,93.22 225.12,92.04 227.18,92.04 229.22,89.99 229.22,88.84 229.55,88.51 230.17,88.51 230.3,88.64 231.39,88.64 231.85,88.18 233.75,88.18 v2(234.15,87.78)
  BOTTOM w0.109: v2(173.43,99.25) 171.73,99.25 170.97,100.01 165.14,100.01 164.7,99.57 161.86,99.57 158.33,96.04 157.7,96.04 153.9,92.24 153.9,86.75 156.9,83.74 158.49,83.74 159.3,82.94 160.43,82.94 165.96,77.4 v1(165.96,73.17) 165.96,72.82 164.53,71.39 160.86,71.39 160.68,71.56 UE12.8
DGPU_ALERT#: length 148.6
  VCC w0.086: v2(264.28,80.18) 255.61,80.18 253.25,77.82 241.26,77.82 239.51,79.57 234.81,79.57 231.34,83.03 222.93,83.03 215.97,89.99 196.86,89.99 196.14,89.27 185.09,89.27 184.78,89.58 182.49,89.58 181.79,90.29 181.79,90.88 180.29,92.38 177.33,92.38 176.88,92.82 169.18,92.82 168.58,93.42 167.78,93.42 166.67,92.31 166.67,89.81 162.71,85.86 v2(162.71,79.1)
  IN3 w0.081: v2(264.28,80.18) 264.76,80.66 269.1,80.66 269.98,79.77 275.97,79.77 276.35,79.39 282.04,79.39 v2(282.24,79.59)
  BOTTOM w0.109: v2(162.71,79.1) 163.23,78.58 163.23,78.26 163.75,77.74 v1(163.75,76.65) 163.75,75.63 RV904.2 163.15,75.03 UE12.2 ; v2(282.24,79.59) 282.24,79.85 281.94,80.15 281.64,80.15 281.41,80.38 281.41,80.47 281.03,80.85 QV41.1
DGPU_HOLD_RST#: length 225
  TOP w0.109: UH1.BB20 125.31,39.87 v2(125.25,39.93) ; v2(289,82.72) 288.91,82.81 v1(288.1,82.81) 287.8,82.81 285.07,80.08 285.07,78.09 v2(285.04,78.06)
  VCC w0.086: v2(160.93,62.91) 161.01,62.83 162.94,62.83 164.54,64.43 164.54,66.36 166.7,68.51 166.7,77.65 167.82,78.78 167.82,81.32 167.39,81.75 167.39,84.66 169.03,86.29 179.09,86.29 180.71,84.68 182.56,84.68 183.36,85.47 195.93,85.47 196.98,84.42 212.17,84.42 223.37,73.21 231.17,73.21 233.2,75.24 238.16,75.24 238.86,74.54 254.82,74.54 256.41,76.14 257.72,76.14 261.75,72.11 266.52,72.11 270.88,76.46 274.69,76.46 276.48,78.25 281.17,78.25 281.87,77.55 282.47,77.55 283.45,78.53 284.57,78.53 v2(285.04,78.06)
  IN3 w0.081: v2(125.25,39.93) 125.92,40.59 126.4,40.59 126.82,41.01 129.32,41.01 129.73,41.42 129.73,44.96 131.9,47.13 133.24,47.13 134.1,48 134.72,48 135.24,48.51 135.24,50.75 136.32,51.83 136.7,51.83 136.8,51.73 138.35,51.73 138.45,51.83 138.91,51.83 139.55,51.2 140.38,51.2 141.24,52.05 142.56,52.05 143.99,53.48 145.38,53.48 146.39,54.5 149.63,54.5 152.65,57.51 155.51,57.51 156.72,58.72 156.72,59.62 160,62.91 v2(160.93,62.91)
  BOTTOM w0.109: v2(289,82.72) 289,83.09 288.76,83.33 RV812.1 287.88,83.35 UV63.1 ; v2(125.25,39.93) 125.04,39.93 124.31,39.19 123.94,39.19 122.86,38.11 120.95,38.11 120.4,37.56 120.4,36.83 119.93,36.36 RH350.1
DGPU_PEX_RST#: length 67
  TOP w0.109: v2(233.3,87.75) 233.08,87.96 233.08,88.18 232.7,88.56 232.1,88.56 231.66,88.12 JDGFF1.F2
  VCC w0.086: v2(283.6,82.5) 283.45,82.35 276.28,82.35 275.51,83.11 275.51,83.45 274.56,84.4 273.19,84.4 272.85,84.74 255.05,84.74 254.22,83.91 243.4,83.91 242.81,84.5 235.6,84.5 233.72,86.38 233.72,86.65 233.3,87.07 v2(233.3,87.75)
  BOTTOM w0.109: DV34.1 285.37,82.05 UV63.4 284.26,82.05 284.12,81.9 284.12,81.65 284.56,81.21 RV813.1 284.28,80.26 v1(283.7,80.84) 283.04,81.5 QV41.2 282.38,81.5 282.2,81.68 282.2,82.24 QV40.2 283.27,82.84 v2(283.6,82.5)
DGPU_PEX_RST#_D: length 7
  BOTTOM w0.109: UV62.1 287.6,77.82 RV815.2 ; DV34.2 286.84,77.89 RV815.2 ; RV815.2 CV812.1 RV800.1 287.74,75.22 UV61.1 288.55,74.2 v1(288.49,74.14)
DGPU_PWR_EN: length 30.4
  TOP w0.109: UE1.M1 132.55,70.16 v2(132.37,70.16) ; UE11.2 111.25,63.65 v1(111.44,63.47) v2(112.8,62.11)
  IN3 w0.081: v2(132.37,70.16) 132.35,70.18 129.52,70.18 128.79,70.91 123.68,70.91 122.41,69.64 121.39,69.64 121,70.03 120.11,70.03 117.68,67.6 117.68,66.81 115.39,64.53 115.39,63.63 114.14,62.39 113.37,62.39 113.09,62.11 v2(112.8,62.11)
DGPU_PWR_EN_R: length 176.4
  TOP w0.109: v2(224.56,84.52) 224.93,84.89 225.46,84.89 v1(225.71,84.63) 226.05,84.29 232.13,84.29 232.84,85.01 236.16,85.01 237.09,85.94 242.88,85.94 243.36,86.42 245.32,86.42 245.79,86.9 245.79,87.84 246.07,88.12 JDGFF2.F2 ; UE11.4 110.95,63 111.96,61.99 111.96,61.17 112.21,60.91 112.76,60.91 113.37,60.3 113.37,59.15 113.78,58.73 113.78,57.14 114.63,56.29 116.23,56.29 117.58,54.94 118.37,54.94 v2(120.19,53.12)
  VCC w0.086: v2(224.56,84.52) 223.85,84.52 217.39,90.98 195.32,90.98 194.68,90.33 185.44,90.33 185.17,90.6 184,90.6 181.24,93.36 177.74,93.36 177.3,93.8 169.5,93.8 169.03,94.28 167.42,94.28 165.68,92.53 165.68,91.19 161.49,87 161.49,80.2 158.32,77.02 158.32,76.52 157.37,75.58 v2(156.48,75.58)
  IN3 w0.081: v2(120.19,53.12) 120.19,53.43 122.61,55.85 124.59,55.85 125.28,56.53 132.86,56.53 133.28,56.94 133.37,57.04 135.79,57.04 136.38,56.44 139.95,56.44 143.67,60.16 143.67,61.13 144.94,62.4 144.94,63.2 146.25,64.51 147.05,64.51 147.67,65.13 147.67,65.86 147.87,66.07 148.82,66.07 150.2,67.45 152.82,67.45 154.56,69.19 154.56,72.76 156.48,74.69 v2(156.48,75.58)
DGPU_PWROK: length 281
  TOP w0.109: UH1.AV16 127.49,41.61 127.4,41.7 v2(127.4,41.92) ; v2(226.12,87.51) 225.15,87.51 224.95,87.71 223.9,87.71 222.69,86.5 222.69,81.74 223.21,81.22 233.39,81.22 235.75,83.59 237.48,83.59 237.69,83.8 242.11,83.8 243.14,82.77 252.19,82.77 252.57,82.39 258.56,82.39 261.61,85.44 283.48,85.44 284.96,83.97 284.96,82.89 281.83,79.76 281.83,78.87 281.18,78.22 281.18,76.62 281.97,75.83 283.84,75.83 v2(284.45,76.44) ; UE1.M4 v2(134.87,70.08) ; v2(230.5,93.41) 230.91,93.01 230.91,92.48 231.07,92.32 JDGFF1.F9
  IN1 w0.102: v2(121.77,70.25) 122.04,69.97 122.04,68.88 122.58,68.34 122.58,61.96 123.14,61.4 123.14,56.17 124.32,54.99 124.32,54.1 124.64,53.78 124.64,48.45 125.42,47.67 125.42,46.85 125.09,46.52 125.09,46.22 125.24,46.07 125.24,44.87 125.56,44.55 125.56,43.45 125.87,43.15 125.87,42.93 125.71,42.77 125.71,42.35 126.49,41.57 127.05,41.57 v2(127.4,41.92) ; v2(148.87,96.06) 148.46,95.65 148.46,94.99 148.46,81.68 145.6,78.82 145.6,73.52 144.83,72.74 144.83,69.56 144.59,69.32 144.59,68.33 143.9,67.64 142.25,67.64 141.3,66.69 140.03,66.69 139.61,67.11 138.15,67.11 137.72,67.55 137.72,68.9 137.28,69.33 135.61,69.33 v2(134.87,70.08)
  IN2 w0.081: v2(174.83,99.22) 174.02,100.03 167.02,100.03 165.31,98.31 160.09,98.31 159.57,98.84 156.45,98.84 154.81,97.19 153.58,97.19 153.18,96.79 151.56,96.79 150.83,96.06 v2(148.87,96.06)
  VCC w0.086: v2(174.83,99.22) 178.71,99.22 184.46,93.47 224.07,93.47 225.25,92.28 227.28,92.28 227.37,92.19 229.31,92.19 229.49,92.37 230.63,92.37 230.9,92.64 230.9,93.02 v2(230.5,93.41)
  IN4 w0.102: v2(134.87,70.08) 133.84,70.08 132.71,68.95 132.17,68.95 131.91,69.21 131.91,69.69 130.69,70.9 127.25,70.9 127.01,70.67 125.77,70.67 125.4,71.04 122.56,71.04 v2(121.77,70.25)
  BOTTOM w0.109: QV42.2 285.08,77.07 v2(284.45,76.44) 284.95,75.95 RV806.2 285.88,74.9 RV818.1 RV800.2 ; v2(226.12,87.51) 226.12,88.42 v4(228.28,90.58) 229.94,92.24 230.5,92.24 230.83,92.57 230.83,93.08 v2(230.5,93.41)
DGPU_SELECT#: length 109.7
  TOP w0.109: UV65.1 165.06,122.77 v2(165.08,122.75) ; QV43.2 143.78,129.87 144.33,130.43 v1(144.33,132.47) 144.74,132.47 144.89,132.61 RV901.2 146.11,132.61 v2(146.4,132.91)
  IN2 w0.081: v2(165.08,122.75) 167.97,125.63 167.97,129.94 166.32,131.59 163.83,131.59 162.56,130.32 160.09,130.32 156.54,133.87 153.36,133.87 152.8,133.31 146.81,133.31 v2(146.4,132.91)
  BOTTOM w0.109: UE12.28 160.68,76.55 160.81,76.68 161.63,76.68 162.53,77.59 162.53,78.69 162.28,78.95 162.28,80.42 160.23,82.46 159.1,82.46 158.37,83.2 155.67,83.2 155.27,82.79 154.79,82.79 153.49,84.09 153.49,92.41 158.34,97.26 158.34,98.35 160.03,100.04 164.5,100.04 164.94,100.48 166.94,100.48 168.81,102.36 168.81,106.76 165.62,109.96 165.62,113.97 166.82,115.18 166.82,121.57 166.56,121.83 165.33,121.83 165.08,122.08 v2(165.08,122.75)
DGPU_TYPE#: length 80.4
  TOP w0.109: RV742.2 170.42,107.09 v1(170.42,104.47) v2(170.42,102.34) ; v2(223.9,87.12) 224.2,87.43 224.89,87.43 226.37,85.95 233.42,85.95 233.73,86.26 233.73,88.19 233.89,88.36 234.45,88.36 234.69,88.12 JDGFF1.D2
  BOTTOM w0.109: v2(223.9,87.12) 221.59,87.12 220.71,86.24 213.4,86.24 208.23,91.41 201.01,91.41 199.66,92.76 182.28,92.76 176.35,98.69 174.66,98.69 174.16,99.19 174.16,99.57 173.25,100.48 171.04,100.48 170.42,101.1 v2(170.42,102.34)
DID2_GPIO1: length 59.4
  TOP w0.109: v2(166.75,104.74) 166.75,105.08 165.35,106.48 164.3,106.48 163.48,107.3 163.48,108.06 163.74,108.32 RV738.2 164.17,108.4 RV741.2
  BOTTOM w0.109: v2(166.75,104.74) 166.75,106.26 167.43,106.95 167.94,106.95 168.58,106.31 168.58,102.46 166.84,100.72 164.84,100.72 164.4,100.28 159.93,100.28 157.7,98.04 v1(157.7,97.55) 157.7,96.95 153.25,92.51 153.25,83.99 154.69,82.56 155.37,82.56 155.77,82.96 158.27,82.96 159,82.23 160.13,82.23 162.04,80.32 162.04,78.79 162.3,78.54 162.3,77.69 161.53,76.93 160.72,76.93 160.61,76.81 160.41,76.81 160.23,76.63 UE12.27
DID2_GPIO1_HDR: length 4.3
  TOP w0.109: QV44.6 166.57,107.61 166.37,107.81 166.37,108.16 166.2,108.32 RV737.2 165.86,108.05 165.75,107.94 164.87,107.94 164.77,107.84 RV739.2 v1(163.83,107.44)
DID2_GPIO1_MUX: length 47.5
  TOP w0.109: RV738.1 RV737.1 165.28,108.41 165.87,109.01 v2(165.96,109.01) ; JEDP1.26 125.7,118.25 126.25,117.71 129.88,117.71 131.21,116.37 v2(131.21,116.27)
  IN2 w0.081: v2(131.21,116.27) 131.82,115.67 133.03,115.67 134,114.7 141.87,114.7 142.99,113.58 160.62,113.58 161.05,113.15 161.05,111.98 162.72,110.3 165.35,110.3 165.96,109.69 v2(165.96,109.01)
DID2_GPIO1_R: length 4.4
  TOP w0.109: RV740.2 169.68,108.78 169.55,108.91 QV44.3 ; RV740.2 170.15,107.79 170.71,107.79 v1(171.21,107.29) ; RV740.2 QV44.2
DID2_GPIO2: length 98.7
  TOP w0.109: JEDP1.27 126.2,118.09 126.35,117.94 129.98,117.94 130.45,117.47 131.07,117.47 131.84,116.7 v2(131.84,116.27)
  IN2 w0.081: v2(167.55,106.44) 167.55,108.4 165.43,110.52 162.8,110.52 161.26,112.05 161.26,113.22 160.7,113.78 143.08,113.78 141.95,114.91 134.09,114.91 133.12,115.87 132.23,115.87 v2(131.84,116.27)
  BOTTOM w0.109: v2(167.55,106.44) 167.9,106.44 168.34,106 168.34,102.55 166.74,100.95 164.75,100.95 164.31,100.51 159.67,100.51 v1(153.79,94.63) 153.02,93.86 153.02,83.89 154.59,82.32 155.46,82.32 155.87,82.73 158.17,82.73 158.91,81.99 160.03,81.99 161.77,80.26 161.77,78.73 162.05,78.45 162.05,78.06 161.81,77.82 161.21,77.82 160.45,77.05 160.1,77.05 159.78,76.74 UE12.26
DIFFOUT_2PH: length 4.1
  TOP w0.203: PU1100.35 303.95,38.84 303.89,38.78 303.89,38.29 v1(304.38,37.8) 305.13,37.05 PR1136.2 305.11,36.78 PR1134.1
DIFFOUT_4PH: length 5.4
  TOP w0.203: PU1100.4 304.35,46.57 304.67,46.9 305.55,46.9 305.64,46.81 v1(306.34,46.81) 306.41,46.81 306.84,47.24 PR1131.2 306.84,48.59 PC1114.2
DIMM1_SA0: length 11.7
  BOTTOM w0.109: RD78.1 RD18.1 181.05,88.37 180,87.32 180,85.39 181.48,83.91 182.66,83.91 183.04,83.53 183.04,81.71 182.81,81.48 JDIMM1.256
DIMM1_SA1: length 8.9
  BOTTOM w0.109: RD14.2 RD79.2 180.26,88 179.69,87.43 179.69,85.37 180.74,84.31 180.74,82.7 180.96,82.48 JDIMM1.260
DIMM1_SA2: length 23
  IN4 w0.102: v2(169.51,64.97) 170,64.47 170,62.08 171,61.08 171.88,61.08 172.76,60.2 180.52,60.2 180.97,59.74 v2(183.97,59.74)
  BOTTOM w0.109: JDIMM1.166 183.25,58.98 183.97,59.71 v2(183.97,59.74) ; v1(167.05,64.91) 167.09,64.91 167.11,64.9 RD80.2 168.84,64.9 RD15.2 169.45,64.91 v2(169.51,64.97)
DIMM2_SA0: length 13.3
  TOP w0.109: v1(173.23,91.47) 173.72,91.47 RD22.2 173.66,90.46 173.66,89.03 173.98,88.71 RD81.2 174.19,87.67 173.04,86.51 173.04,85.35 172.16,84.47 172.16,81.99 172.67,81.48 JDIMM2.256
DIMM2_SA1: length 12.2
  TOP w0.109: v1(176.16,91.63) 175.78,91.63 175.21,91.06 RD23.2 175.69,90.52 175.69,88.99 175.41,88.71 RD82.2 175.21,87.91 173.68,86.39 173.68,85.1 172.67,84.09 172.67,82.69 172.87,82.48 JDIMM2.260
DIMM2_SA2: length 5.8
  TOP w0.102: v2(171.16,60.11) 171.16,59.86 172.04,58.98 JDIMM2.166
  BOTTOM w0.109: v2(171.16,60.11) 170.71,60.56 RD83.2 170.7,60.73 RD24.2 170.7,62.14 v1(171.03,62.46)
DIMM3_SA0: length 6.3
  BOTTOM w0.109: JDIMM3.256 197.68,81.47 v1(199.3,79.86) 199.69,79.47 RD42.1 RD85.1
DIMM3_SA1: length 12.8
  BOTTOM w0.109: v1(206.11,79.26) 205.78,78.93 RD86.1 RD43.1 204.35,80.18 203.7,80.82 201.13,80.82 199.48,82.47 JDIMM3.260
DIMM3_SA2: length 3.6
  BOTTOM w0.109: RD40.2 RD87.2 197.5,59.25 197.23,58.97 JDIMM3.166
DIMM4_SA0: length 12.5
  TOP w0.102: 190,85.55 188.52,84.06 188.52,81.69 188.3,81.48 JDIMM4.256
  TOP w0.109: 190,85.55 190,86.62 192.32,88.94 RD89.2 192.37,89.37 RD46.2 193.05,90.11 v1(193.44,90.5)
DIMM4_SA1: length 11.1
  TOP w0.102: JDIMM4.260 188.1,82.48 188.22,82.6 188.22,84.36 189.63,85.77 189.63,87.24 191.17,88.77
  TOP w0.109: v1(190.47,90.6) 190.96,90.12 RD88.1 191.6,89.33 RD51.1 191.59,89.19 191.17,88.77
DIMM4_SA2: length 22.6
  TOP w0.109: JDIMM4.166 186.03,58.98 v2(185.23,59.77)
  IN3 w0.081: v2(185.23,59.77) 185.23,60.09 184.73,60.59 183.97,60.59 183.46,60.09 175.71,60.09 174.7,61.1 170.76,61.1 v2(169.49,62.37)
  BOTTOM w0.109: v2(169.49,62.37) 168.91,61.79 RD48.2 RD90.2 168.09,60.95 v1(168.26,60.78)
DISP_ON: length 69.4
  TOP w0.109: v2(122.2,132.02) 122.2,126.63 121.23,125.67 121.23,122.01 122.25,120.99 122.25,120.15 122.2,120.1 JEDP1.19 ; RV836.1 170.27,129.1 170.19,129.01 DV36.1 DV35.1 DV37.1 v2(166.08,127.92)
  IN2 w0.081: v2(122.2,132.02) 127,132.02 127.32,131.7 137.75,131.7 139.87,129.58 151.23,129.58 156.24,124.57 164.18,124.57 166.08,126.48 v2(166.08,127.92)
  BOTTOM w0.109: v2(166.08,127.92) v1(166.66,127.92)
DMI_CRX_PTX_N0: length 163.2
  TOP w0.076: UH1.C33 144.61,32.72 144.61,32.94 144.77,33.1 145.13,33.1 145.42,33.38 146.33,33.38 147.37,34.42 147.73,34.42 147.74,34.44 147.76,34.44 ; v2(236.97,69.9) 236.97,70.18 236.91,70.24 236.59,70.24 236.17,69.82 236.17,65.77 235.93,65.53 235.84,65.53 UC1.E8
  TOP w0.102: 147.76,34.44 155.99,34.44 v2(156.34,34.79)
  IN4 w0.102: v2(156.34,34.79) 156.61,34.79 156.75,34.66 156.75,34.44 156.6,34.29 155.5,34.29 155.15,34.64 155.15,40.05 161.9,46.8 161.9,56.49 162.7,57.29 164.03,58.62 164.03,61.09 164.08,61.14 166.25,63.31 166.25,69.48 169.6,72.83 169.6,75.34 169.16,75.78 169.16,81.69 175.74,88.27 183.7,88.27 184.84,87.14 192.26,87.14 193.73,88.6 217.85,88.6 223.07,83.39 230.37,83.39 237.99,75.77 237.99,69.99 236.95,68.95 236.42,68.95 236.2,69.17 236.2,69.93 236.58,70.3 237.19,70.3 237.29,70.19 237.29,70 237.19,69.9 v2(236.97,69.9)
DMI_CRX_PTX_N1: length 152.1
  TOP w0.076: UC1.F6 v2(234.51,65.05) ; 147.94,35.07 147.92,35.07 147.9,35.05 147.29,35.05 146.54,34.3 146.54,34.11 146.39,33.96 145.78,33.96 145.53,33.71 144.64,33.71 144.49,33.55 144.49,33.43 UH1.C32
  TOP w0.102: v2(156.53,35.53) 155.83,36.22 153.92,36.22 152.77,35.07 147.94,35.07
  IN4 w0.076: 234.22,67.3 234.22,67.28 234.23,67.27 234.23,66.94 233.94,66.64 233.94,66.12 234.01,66.05 234.01,65.39 234.15,65.25 234.31,65.25 v2(234.51,65.05)
  IN4 w0.102: v2(156.53,35.53) 156.35,35.34 156.21,35.34 156.11,35.44 156.11,35.95 156.52,36.36 157.78,36.36 159.59,38.17 159.59,41.16 163.96,45.54 163.96,50.44 163.59,50.81 163.59,54.82 165.88,57.11 165.88,60.19 166.52,60.84 167.57,60.84 168.24,61.51 168.24,64.33 167.71,64.87 167.71,67.9 173.65,73.84 173.65,84.17 174.78,85.3 184.04,85.3 184.6,85.86 192.94,85.86 194.49,87.41 217.36,87.41 222.57,82.2 229.87,82.2 233.87,78.2 233.87,69.37 234.22,69.03 234.22,67.3
DMI_CRX_PTX_N2: length 150.7
  TOP w0.076: UH1.C31 144.37,33.97 144.62,34.17 144.98,34.32 145.07,34.4 145.98,34.4 147.33,35.75 148.14,35.75 148.16,35.77 148.18,35.77 ; v2(233.74,65.01) 233.75,65.01 UC1.E5
  TOP w0.102: v2(161.53,40.09) 161.53,39.99 161.23,39.7 160.25,39.7 157.38,36.82 153.16,36.82 152.1,35.77 148.18,35.77
  IN4 w0.076: v2(233.74,65.01) 233.69,65.01 233.12,65.58 233.12,66.18 233.52,66.57 233.52,66.89 233.5,66.91 233.5,66.93
  IN4 w0.102: v2(161.53,40.09) 161.78,40.09 161.88,39.98 161.88,39.78 161.72,39.62 161.19,39.62 161.01,39.79 161.01,41.18 164.6,44.77 164.6,52.65 165.15,53.2 165.15,53.44 166.48,54.77 166.48,59.77 166.83,60.12 167.84,60.12 168.86,61.14 168.86,64.64 168.33,65.17 168.33,66.54 168.86,67.07 170.62,67.07 171.5,67.95 172.06,67.95 174.51,70.4 174.51,83 176.18,84.67 184.97,84.67 185.4,85.09 193.08,85.09 194.8,86.82 217.01,86.82 222.23,81.6 229.63,81.6 233.27,77.96 233.27,69.03 233.5,68.8 233.5,66.93
DMI_CRX_PTX_N3: length 154.6
  TOP w0.076: v2(236.79,63.69) UC1.J9 ; UH1.C29 144.84,34.68 144.99,34.6 145.84,34.6 147.46,36.23 148.87,36.23 148.89,36.21 148.91,36.21
  TOP w0.102: v2(156.87,38.1) 156.66,37.89 156.66,37.67 156.22,37.23 152.99,37.23 151.97,36.21 148.91,36.21
  IN4 w0.076: 236.16,66.12 236.16,65.11 236.57,64.7 236.57,64.17 236.51,64.11 236.51,63.97 v2(236.79,63.69)
  IN4 w0.102: v2(156.87,38.1) 156.59,37.82 156.59,37.51 156.72,37.39 157.39,37.39 158.54,38.55 158.54,42.71 162.44,46.61 162.44,56.07 165.08,58.71 165.1,58.73 165.1,61.57 166.86,63.33 166.86,68.32 170.5,71.96 170.5,82.18 175.05,86.73 179.11,86.73 179.74,87.36 182.07,87.36 182.7,86.73 192.64,86.73 194.11,88.2 217.68,88.2 222.9,82.98 230.2,82.98 237.26,75.92 237.26,72.4 236.46,71.6 236.46,71.15 235.53,70.22 235.53,67.79 236.16,67.16 236.16,66.12
DMI_CRX_PTX_P0: length 163.2
  TOP w0.076: UC1.D8 235.66,65.74 235.72,65.69 235.86,65.69 236.01,65.84 236.01,69.88 236.53,70.39 236.67,70.39 v2(236.97,70.69) ; UH1.B33 144.97,32.6 144.87,32.6 144.77,32.71 144.77,32.88 144.83,32.95 145.2,32.95 145.48,33.23 146.39,33.23 147.43,34.26 147.73,34.26 147.74,34.25 147.76,34.25
  TOP w0.102: 147.76,34.25 155.89,34.25 v2(156.34,33.79)
  IN4 w0.102: v2(236.97,70.69) 236.77,70.49 236.5,70.49 236.01,70 236.01,69.1 236.35,68.77 237.02,68.77 238.17,69.91 238.17,75.85 230.45,83.57 223.15,83.57 217.93,88.79 193.65,88.79 192.18,87.32 184.91,87.32 183.78,88.46 175.66,88.46 168.98,81.77 168.98,75.7 169.41,75.27 169.41,72.91 166.06,69.55 166.06,63.39 163.84,61.17 163.84,58.7 161.71,56.57 161.71,46.88 154.96,40.13 154.96,34.56 155.42,34.1 156.03,34.1 v2(156.34,33.79)
DMI_CRX_PTX_P1: length 152.1
  TOP w0.076: UC1.E6 234.86,65.35 v2(234.54,65.68) ; 147.94,34.88 147.92,34.88 147.9,34.9 147.35,34.9 146.7,34.24 146.7,34.05 146.46,33.81 145.85,33.81 145.59,33.56 144.71,33.56 144.64,33.49 144.64,33.41 144.71,33.34 UH1.B32
  TOP w0.102: v2(155.64,35.52) 155.75,35.41 155.95,35.41 156.05,35.5 156.05,35.74 155.75,36.03 154,36.03 152.85,34.88 147.94,34.88
  IN4 w0.076: 234.4,67.3 234.4,67.28 234.39,67.27 234.39,66.88 234.09,66.58 234.09,66.18 234.16,66.11 234.16,65.46 234.22,65.4 234.47,65.4 234.54,65.47 v2(234.54,65.68)
  IN4 w0.102: 234.4,67.3 234.4,69.1 234.06,69.45 234.06,78.28 229.95,82.38 222.65,82.38 217.43,87.6 194.42,87.6 192.86,86.04 184.52,86.04 183.96,85.49 174.7,85.49 173.46,84.25 173.46,73.92 167.52,67.98 167.52,64.79 168.06,64.26 168.06,61.58 167.5,61.02 166.45,61.02 165.69,60.27 165.69,57.19 163.4,54.89 163.4,50.74 163.78,50.36 163.78,45.62 159.4,41.24 159.4,38.24 157.7,36.55 156.44,36.55 155.93,36.03 155.93,35.8 v2(155.64,35.52)
DMI_CRX_PTX_P2: length 150.7
  TOP w0.076: UH1.B31 144.81,33.96 144.9,33.87 145.18,33.87 145.25,33.95 145.25,34.01 145.21,34.05 145.11,34.05 145.06,34.1 145.06,34.18 145.13,34.25 146.05,34.25 147.39,35.59 148.14,35.59 148.16,35.57 148.18,35.57 ; UC1.D5 234.09,65.87 234,65.78 v2(233.65,65.78)
  TOP w0.102: v2(161.55,39.13) 161.18,39.51 160.33,39.51 157.46,36.63 153.23,36.63 152.18,35.57 148.18,35.57
  IN4 w0.076: 233.69,66.93 233.69,66.91 233.67,66.89 233.67,66.51 233.27,66.11 233.27,65.64 233.49,65.42 233.61,65.42 233.69,65.5 233.69,65.74 v2(233.65,65.78)
  IN4 w0.102: 233.69,66.93 233.69,68.88 233.46,69.1 233.46,78.04 229.7,81.79 222.31,81.79 217.09,87.01 194.72,87.01 193,85.28 185.32,85.28 184.9,84.86 176.11,84.86 174.32,83.07 174.32,70.47 171.98,68.14 171.42,68.14 170.54,67.26 168.78,67.26 168.14,66.62 168.14,65.09 168.67,64.56 168.67,61.22 167.76,60.31 166.75,60.31 166.29,59.85 166.29,54.85 164.96,53.52 164.96,53.28 164.41,52.73 164.41,44.85 160.82,41.26 160.82,39.72 161.11,39.43 161.25,39.43 v2(161.55,39.13)
DMI_CRX_PTX_P3: length 154.6
  TOP w0.076: UH1.B29 144.96,34.86 144.89,34.92 144.89,35.02 144.98,35.11 145.12,35.11 145.47,34.76 145.77,34.76 147.4,36.38 148.87,36.38 148.89,36.4 148.91,36.4 ; UC1.J8 v2(236.06,63.73)
  TOP w0.102: 148.91,36.4 151.89,36.4 152.91,37.42 156.14,37.42 156.47,37.75 156.47,38.03 156.41,38.1 v2(156.08,38.1)
  IN4 w0.076: v2(236.06,63.73) 236.36,64.03 236.36,64.17 236.42,64.23 236.42,64.63 236.01,65.05 236.01,66.02 235.97,66.06 235.97,66.12
  IN4 w0.102: 235.97,66.12 235.97,67.08 235.34,67.71 235.34,70.3 236.27,71.22 236.27,71.68 237.07,72.48 237.07,75.84 230.12,82.79 222.82,82.79 217.6,88.01 194.19,88.01 192.72,86.54 182.62,86.54 181.99,87.17 179.82,87.17 179.19,86.54 175.13,86.54 170.69,82.1 170.69,71.88 167.05,68.24 167.05,63.25 165.29,61.49 165.29,58.65 162.63,55.99 162.63,46.54 158.73,42.64 158.73,38.47 157.47,37.2 156.64,37.2 156.41,37.43 156.41,37.77 v2(156.08,38.1)
DMI_CTX_PRX_N0: length 159.1
  TOP w0.076: v2(234.9,69.6) 235.53,69.6 235.77,69.36 235.77,68.55 235.38,68.16 235.38,67.8 235.52,67.66 235.6,67.66 235.66,67.73 UC1.A8
  TOP w0.094: v2(140.93,31.53) 140.93,31.53 UH1.K34
  IN1 w0.102: v2(234.9,69.6) 234.84,69.54 234.31,69.54 232.33,71.52 232.33,77.89 229.05,81.17 223.05,81.17 220.63,83.58 218.67,83.58 211.57,90.69 195.27,90.69 194.8,90.22 176.07,90.22 171.93,86.08 171.93,81.3 167.25,76.61 167.25,64.93 167.96,64.21 167.96,62.08 166.34,60.46 166.34,58.88 165.44,57.98 165.44,56.9 163.49,54.94 163.49,51.72 161.72,49.95 161.72,42.7 159.63,40.61 159.63,34.58 158.33,33.29 147.07,33.29 146.57,32.79 146.57,32.35 146.43,32.21 145.08,32.21 144.71,32.59 142.12,32.59 141.73,32.2 141.34,32.2 141.11,31.97 141.11,31.71 v2(140.93,31.53)
DMI_CTX_PRX_N1: length 157.5
  TOP w0.094: v2(142.34,32.02) UH1.G33
  TOP w0.102: UC1.B6 234.88,67.21 235.11,66.98 v2(235.27,66.98)
  IN1 w0.102: v2(235.27,66.98) 235.16,66.87 234.8,66.87 234.63,67.03 234.63,67.96 231.53,71.06 231.53,77.68 228.8,80.41 222.72,80.41 220.15,82.99 218.25,82.99 211.14,90.09 197.85,90.09 197.34,89.58 176.48,89.58 172.62,85.71 172.62,79.84 172.28,79.5 171.09,79.5 167.95,76.37 167.95,69.68 168.24,69.4 168.24,65.33 168.72,64.84 168.72,61.91 167,60.19 167,58.52 166.11,57.63 166.11,52.04 162.34,48.27 162.34,42.46 160.26,40.38 160.26,34.33 158.63,32.69 155.12,32.69 153.91,31.49 146.03,31.49 145.77,31.22 144.84,31.22 143.86,32.2 142.77,32.2 142.6,32.02 v2(142.34,32.02)
DMI_CTX_PRX_N2: length 158.5
  TOP w0.076: v2(235.28,71.58) 234.9,71.2 234.73,71.2 234.26,70.73 234.26,68.43 234.43,68.26 234.43,67.9 234.3,67.77 234.16,67.77 234.12,67.81 UC1.A5
  TOP w0.094: v2(140.89,32.93) UH1.K32
  IN1 w0.102: v2(140.89,32.93) 141.45,33.48 141.95,33.48 142.4,33.03 144.38,33.03 145.52,34.18 153.07,34.18 155.29,36.4 157.67,36.4 159,37.73 159,40.96 161.11,43.07 161.11,50.19 162.88,51.95 162.88,56.35 165.62,59.09 165.62,64.64 166.64,65.65 166.64,76.86 171.21,81.44 171.21,86.62 175.67,91.07 177.46,91.07 178.31,91.93 181.22,91.93 181.93,91.22 185.28,91.22 185.69,90.81 194.55,90.81 195.02,91.28 212.13,91.28 219.14,84.28 220.98,84.28 223.4,81.85 229.44,81.85 233.37,77.93 233.37,72.2 234.38,71.2 234.89,71.2 v2(235.28,71.58)
DMI_CTX_PRX_N3: length 159.9
  TOP w0.076: UC1.B4 233.2,66.8 233.2,66.73 233.25,66.68 233.5,66.68 233.72,66.9 233.72,67.05 233.65,67.13 233.65,71.12 234.94,72.42 235.53,72.42 v2(235.85,72.73)
  TOP w0.094: v2(142.37,33.79) UH1.G30
  IN1 w0.102: v2(235.85,72.73) 235.55,72.44 234.79,72.44 234.01,73.22 234.01,78.13 233.95,78.19 229.56,82.58 223.86,82.58 221.57,84.87 219.62,84.87 212.6,91.89 182.11,91.89 181.47,92.54 177.81,92.54 176.98,91.71 174.17,91.71 170.56,88.1 170.56,81.69 165.98,77.11 165.98,65.99 164.99,65.01 164.99,59.31 162.22,56.54 162.22,52.3 160.39,50.47 160.39,43.34 158.41,41.36 158.41,38.19 157.57,37.35 155.4,37.35 153.01,34.96 145.32,34.96 144.72,34.36 142.94,34.36 v2(142.37,33.79)
DMI_CTX_PRX_P0: length 159.1
  TOP w0.076: v2(234.9,69.02) 235.33,69.45 235.47,69.45 235.62,69.3 235.62,68.61 235.23,68.22 235.23,67.74 UC1.B8
  TOP w0.094: v2(141.48,31.33) 141.66,31.52 UH1.J35
  IN1 w0.102: v2(234.9,69.02) 234.57,69.35 234.23,69.35 232.14,71.44 232.14,77.81 228.98,80.98 222.97,80.98 220.56,83.39 218.6,83.39 211.49,90.5 195.35,90.5 194.88,90.03 176.15,90.03 172.12,86 172.12,81.22 167.43,76.53 167.43,65.01 168.15,64.29 168.15,62 166.53,60.38 166.53,58.8 165.63,57.9 165.63,56.82 163.68,54.87 163.68,51.64 161.91,49.87 161.91,42.62 159.81,40.53 159.81,34.5 158.41,33.1 147.15,33.1 146.76,32.71 146.76,32.27 146.51,32.02 145.01,32.02 144.63,32.4 142.2,32.4 141.81,32.01 141.42,32.01 141.29,31.89 141.29,31.51 v2(141.48,31.33)
DMI_CTX_PRX_P1: length 157.5
  TOP w0.094: UH1.F34 v2(143.01,31.64)
  TOP w0.102: v2(234.45,66.33) 234.56,66.33 UC1.C6
  IN1 w0.102: v2(143.01,31.64) 142.66,31.64 142.61,31.69 142.61,31.76 142.71,31.87 142.71,31.87 142.85,32.01 143.78,32.01 144.76,31.03 145.85,31.03 146.11,31.3 153.99,31.3 155.19,32.5 158.71,32.5 160.45,34.25 160.45,40.3 162.53,42.38 162.53,48.19 166.3,51.96 166.3,57.56 167.19,58.44 167.19,60.11 168.91,61.83 168.91,64.92 168.43,65.41 168.43,69.47 168.14,69.76 168.14,76.29 171.17,79.31 172.36,79.31 172.8,79.76 172.8,85.64 176.56,89.39 197.41,89.39 197.92,89.9 211.07,89.9 218.17,82.8 220.07,82.8 222.64,80.22 228.72,80.22 231.34,77.6 231.34,70.99 234.45,67.88 234.45,66.95 234.58,66.82 234.58,66.47 v2(234.45,66.33)
