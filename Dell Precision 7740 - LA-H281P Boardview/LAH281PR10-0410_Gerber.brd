# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3.3V_ALW_PCH on IN2: 136.22,13.86 135.78,14.29 134.36,14.29 134.29,14.36 134.29,15.17 134.3,15.19 134.3,16.12 134.53,16.34 134.53,17.17 133.8,17.9 132.77,17.9 132.09,18.58 132.09,18.82 130.52,20.38 130.52,21.13 131.44,22.05 134.06,22.05 134.56,21.55 134.56,20.36 134.92,20 136.28,20 136.3,20.02 136.41,20.02 136.71,20.32 136.71,20.43 136.72,20.44 136.72,20.79 137.4,21.46 137.57,21.46 137.59,21.43 137.87,21.26 138.15,21.43 138.17,21.46 139.17,21.46 145.45,15.18 145.45,14.11 145.2,13.86 144.72,13.86 144.47,13.98 144.21,13.89 144.2,13.88 144.16,13.87 144.11,13.88 144.1,13.89 143.84,13.98 143.59,13.86 137.44,13.86 137.39,13.87 137.36,13.89 137.36,13.94 137.36,14 137.37,14.08 137.44,14.13 137.66,14.39 137.57,14.72 137.56,14.76 137.57,14.8 137.64,15.2 137.3,15.41 137.17,15.39 137.05,15.32 137.01,15.3 136.97,15.32 136.84,15.39 136.69,15.41 136.33,15.22 136.39,14.81 136.39,14.8 136.41,14.76 136.39,14.72 136.39,14.71 136.31,14.37 136.54,14.13 136.56,14.12 136.61,14.06 136.6,13.98 136.56,13.89 136.47,13.86
+3.3V_ALW_PCH on IN2: 113.59,29.53 113.29,29.22 112.89,28.83 112.89,28.12 112.95,28.06 112.95,28.06 113.46,27.55 113.46,27.19 113.36,27.09 111.98,27.09 111.73,26.84 111.41,26.84 110.5,27.75 110.5,28.21 111.35,28.21 111.92,28.35 111.58,28.83 111.49,28.87 111.45,28.96 111.45,29.83 111.77,30.14 111.78,30.15 112.05,30.4 111.95,30.76 111.95,30.95 112.42,31.42 112.42,31.5 112.54,31.77 112.42,32.04 112.42,34.74 112.6,34.91 113.76,34.91 114.22,35.37 114.52,35.37 115.14,35.99 115.29,36.08 115.38,36.23 116.37,37.22 116.87,37.22 117.11,36.98 117.9,36.98 117.99,36.94 118.02,36.84 118.21,36.5 118.58,36.59 118.67,36.63 118.76,36.59 119.61,35.75 119.61,32.02 118.72,31.13 116.51,31.13 116.15,31.49 116.12,31.62 116.21,31.7 116.49,31.95 116.39,32.31 116.35,32.4 116.38,32.49 116.37,32.97 115.89,33 115.88,32.99 115.84,32.97 115.79,32.99 115.78,33 115.22,32.92 115.46,32.4 115.52,32.39 115.52,31.61 115.6,31.54 115.63,31.41 115.53,31.32 115.29,31.14 115.28,30.83 115.28,30.77 115.22,30.74 115.2,30.74 115.13,30.68 115.06,30.68 113.91,29.53
+3.3V_ALW_PCH on IN4: outline of 146 points within 110.14,13.22 144.79,28.97
+3.3V_ALW_PCH_PWR on TOP: 139.98,14.37 139.89,14.46 139.89,15.23 139.9,15.24 139.9,16.48 140.45,17.03 140.45,17.89 140.94,18.38 141.17,18.38 141.37,18.57 141.37,18.66 141.37,18.67 141.4,18.81 141.37,18.95 141.37,19.66 141.45,19.74 142.23,19.74 142.33,19.64 142.33,18.78 143.07,18.03 143.07,16.83 143.07,16.28 143.08,16.28 143.08,15.57 142.8,15.29 142.8,14.64 142.69,14.52 141.3,14.52 141.15,14.37
+3.3V_ALW_PCHRES on BOTTOM (solid shape): 125.28,38 125.28,37.48 125.13,37.33 124.9,37.33 124.66,37.09 124.66,36.91 124.04,36.91 123.91,37.04 123.91,38.11 124.11,38.32 124.97,38.32
+3.3V_ALW_PCHRES on BOTTOM (solid shape): 134.25,30.61 134.85,30.61 134.9,30.56 134.9,29.53 134.8,29.43 133.53,29.43 133.42,29.53 133.42,30.09 133.42,30.09 133.42,30.72 133.48,30.79 134.07,30.79
+3.3V_ALW_PCHRES on BOTTOM (solid shape): 123,45.34 123,44.22 122.91,44.13 122.37,44.13 122.25,44.26 122.25,44.8 122.18,44.87 122.07,44.87 122.06,44.88 121.93,44.91 121.8,44.88 121.79,44.87 121.28,44.87 121.1,45.05 121.1,45.58 121.27,45.75 122.59,45.75
+3.3V_ALW_PCHRES on BOTTOM (solid shape): 129.03,38.99 129.03,38.31 129.11,38.23 128.96,37.7 129.49,37.85 129.72,37.63 129.72,37.17 129.56,37.02 128.53,37.02 128.07,37.48 128.07,37.88 128.5,38.3 128.5,38.91 128.61,39.03 128.96,39.03
+3.3V_ALW_PCHRES on BOTTOM (solid shape): 121.76,36.23 121.76,35.57 121.82,35.52 121.82,34.03 121.65,33.86 121.36,33.86 121.26,33.91 121.23,34.02 120.94,34.42 120.61,34.05 120.51,33.95 119.6,33.95 119.57,33.97 119.3,33.97 119.26,34.01 119.26,35.66 119.38,35.78 120.53,35.78 121.01,36.27 121.73,36.27
+3.3V_ALW_PCHRES on IN3 (solid shape): 125.24,38.09 125.24,37.46 125.21,37.43 124.87,37.43 123.23,35.79 122.67,35.79 122.58,35.7 122.4,35.61 122.31,35.43 122.21,35.33 122.21,35.06 122.14,34.88 122.2,34.69 122.23,34.65 121.92,34.34 121.13,34.34 120.93,34.42 120.73,34.35 120.55,34.35 120.44,34.46 120.44,35.87 122.76,38.18 125.16,38.18
+3.3V_ALW_PCHRES on IN4: outline of 127 points within 124.04,34.19 136.42,39.54
+3.3V_ALW_R on TOP (solid shape): 340.69,7.76 340.69,5.09 340.43,4.84 336.88,4.84 336.8,4.92 336.8,5.51 336.82,5.53 337.33,5.53 337.35,5.55 337.35,6.25 337.34,6.26 336.8,6.26 336.79,6.27 336.79,6.71 336.81,6.72 337.34,6.72 337.35,6.73 337.35,7.44 337.32,7.47 336.8,7.47 336.79,7.48 336.79,7.91 336.94,8.07 340.38,8.07
+3.3V_ALW_R on TOP (solid shape): 300.59,70.99 300.59,68.4 300.44,68.26 300.37,68.26 300.36,68.27 300.1,68.31 299.88,68.16 299.18,68.16 299.03,68.32 299.03,69.28 298.95,69.37 298.91,69.43 298.87,69.47 298.78,69.56 298.78,70.98 298.95,71.14 299.29,71.14 299.3,71.15 300.43,71.15
+3.3V_ALW_R on TOP (solid shape): 366.99,33.14 367.16,33.14 367.17,33.13 367.75,33.13 367.95,32.93 368.25,32.93 368.35,32.84 368.77,32.84 368.88,32.73 368.88,31.13 368.49,30.74 368.06,30.74 368.04,30.72 366.03,30.72 365.84,30.92 365.84,31.31 365.86,31.31 365.86,32.07 365.84,32.07 365.84,32.22 365.86,32.22 365.86,33.45 365.87,33.53 365.86,33.61 365.86,33.7 366.08,33.92 366.12,33.92 366.13,33.92 366.99,33.92
+3.3V_ALW_R on TOP (solid shape): 338.53,53.23 338.53,52.72 338.44,52.63 338.1,52.63 338.1,52.59 338.02,52.59 337.89,52.47 337.89,51.97 337.82,51.9 336.8,51.9 336.32,51.42 335.28,51.42 335.11,51.59 335.11,52.56 335.27,52.72 336.35,52.72 336.5,52.87 336.5,53.04 336.55,53.13 336.66,53.13 336.83,53.07 337.01,53.1 337.02,53.1 337.06,53.1 337.29,53.34 337.72,53.34 337.72,53.35 338.4,53.35
+3.3V_ALW_R on TOP (solid shape): 350.66,38.53 350.66,38.51 350.76,38.23 351.03,38.13 351.06,38.13 351.23,37.96 351.23,37.71 351.35,37.59 352.02,37.59 353.27,36.34 353.27,31.62 351.11,29.46 351.11,26.96 348.73,24.58 345.09,24.58 343.66,23.14 343.66,23.14 342.77,22.25 342.77,16.88 341.98,16.09 334.34,16.09 333.74,16.69 333.74,19.09 333.76,19.12 334.5,19.12 334.6,19.02 334.84,18.75 335.19,18.83 335.31,18.86 335.4,18.78 336.01,18.66 335.78,19.24 335.72,19.25 335.72,19.38 335.37,19.72 335.34,19.82 335.38,19.91 335.4,20.44 334.88,20.41 334.53,20.41 334.43,20.5 333.78,20.5 333.74,20.54 333.74,21.2 335.49,22.96 335.49,27.61 337.97,30.09 344.11,30.09 347.48,33.46 347.48,37.01 349.51,39.04 350.15,39.04
+3.3V_ALW_R on BOTTOM (solid shape): 352.06,12.46 352.06,11.43 352.12,11.37 352.12,9.82 351.84,9.54 350.34,9.54 350.14,9.74 350.14,12.26 350.37,12.49 351.05,12.49 351.08,12.52 352,12.52
+3.3V_ALW_R on BOTTOM (solid shape): 380.48,48.51 380.48,47.84 380.38,47.74 379.7,47.74 379.67,47.71 379.67,47.19 379.66,47.18 379.49,47.18 379.47,47.2 379.47,47.74 379.46,47.75 377.97,47.75 377.88,47.83 377.88,48.47 377.98,48.57 380.42,48.57
+3.3V_ALW_R on BOTTOM (solid shape): 375.55,59.25 375.55,58.9 375.56,58.89 375.56,58.82 375.6,58.82 375.61,58.8 376.1,58.8 376.11,58.79 376.11,58.61 375.65,58.61 375.63,58.6 375.58,58.6 375.55,58.57 375.55,58.52 375.55,58.51 375.55,58.17 375.44,58.06 374.21,58.06 374.07,58.19 374.07,59.14 374.23,59.3 375.5,59.3
+3.3V_ALW_R on IN2 (solid shape): outline of 1173 points within 330.58,4.36 352.6,18.89
+3.3V_ALW_R on IN3 (solid shape): outline of 3976 points within 344.23,30.25 380.69,59.58
+3.3V_ALW_R on IN4 (solid shape): outline of 923 points within 334.21,4.22 363.38,17.87
+3.3V_ALW_R on IN1: 331.52,46.97 331.52,50.36 332.43,51.27 332.43,52.14 333.45,53.15 337.18,53.15 338.28,52.05 338.32,51.93 338.23,51.84 337.99,51.43 338.36,51.14 338.62,51.28 338.69,51.57 338.65,51.66 338.6,51.74 338.57,51.88 338.69,51.96 339.11,51.96 339.13,51.91 339.47,51.65 339.81,51.91 339.82,51.96 348.78,51.96 350.28,50.45 350.28,40.08 351.3,39.07 351.3,37.97 352.93,36.34 352.93,33.93 351.45,32.45 333.68,32.45 333.36,32.77 333.36,45.12
+3.3V_ALW_R on VCC: 326.53,18.55 326.52,18.55 326.52,32.43 336.44,42.36 349.14,42.36 349.17,42.33 351.23,42.33 352.83,40.74 352.83,33.27 342.63,23.07 342.63,16.99 341.04,15.41 328.95,15.41 326.51,17.85 326.53,17.86
+3.3V_ALW_R on IN3: 311.98,46.29 311.88,46.34 311.85,46.44 311.6,46.84 311.18,46.64 311.08,46.56 310.97,46.6 309.31,48.26 309.31,50.9 309.3,50.91 309.3,54.45 308.23,55.51 308.23,60.15 308.26,60.24 308.35,60.28 308.7,60.63 308.35,60.99 308.26,61.03 308.23,61.11 308.23,61.21 306.69,62.75 303.65,62.75 302.32,64.08 298.49,64.08 297.24,65.33 297.24,69.95 297.87,70.59 306.04,70.59 310.9,65.73 310.93,65.62 310.87,65.53 310.76,65.01 311.28,64.95 311.33,64.99 314.31,62.01 314.32,62.01 314.42,61.95 314.44,61.83 314.77,61.34 315.1,61.83 315.11,61.95 315.22,62.01 315.63,62.01 320.52,57.12 320.52,56.56 321.01,56.07 326.77,56.07 327.03,56.34 332.97,56.34 333.33,55.98 333.36,55.85 333.26,55.76 333.21,55.07 333.57,55.66 333.55,55.8 333.67,55.88 334.42,55.88 334.7,55.6 334.7,54.74 334.68,54.7 334.64,54.68 334.29,54.32 334.64,53.96 334.68,53.95 334.7,53.9 334.7,49.67 334.42,49.4 334.38,49.41 333.89,49.03 334.48,48.83 334.62,48.86 334.7,48.74 334.7,48.39 332.6,46.29 315.03,46.29 314.82,46.36 314.61,46.29 314.24,46.29 314.17,46.3 314.11,46.29
+3.3V_ALW_RP on TOP (solid shape): 338.73,9.79 338.73,9.06 338.22,8.55 337.11,8.55 336.64,8.08 336.65,8.07 336.65,7.3 337.21,7.3 337.21,6.9 337.18,6.87 336.65,6.87 336.65,6.11 337.18,6.11 337.18,5.68 336.65,5.68 336.65,4.56 336.88,4.33 338.27,4.33 338.78,3.82 338.78,3.06 338.66,2.94 332.18,2.94 331.54,3.57 331.54,9.29 332.28,10.02 338.5,10.02
+3.3V_ALW_UE1 on TOP (solid shape): 130.04,68.82 130.77,68.82 130.89,68.7 130.89,68.46 130.86,68.37 130.77,68.33 130.48,68.17 130.45,67.85 130.47,67.81 130.08,67.42 129.64,67.42 129.61,67.45 129.61,67.83 129.6,67.86 129.58,67.86 129.57,67.86 129.05,67.86 129.05,68.07 129.07,68.09 129.52,68.09 129.52,68.08 129.6,68.08 129.62,68.1 129.61,68.12 129.61,68.73 129.73,68.85 130.01,68.85
+3.3V_ALW_UE1 on VCC: 139.09,79.29 136.5,79.29 136.46,79.25 136.46,79.24 131.91,74.69 131.91,70.7 130.31,69.1 130.11,69.1 129.83,68.82 129.83,67.7 130.06,67.47 130.7,67.47 131.05,67.83 139.19,67.83 140.69,69.33 140.69,77.69
+3.3V_ALW_UZ12 on BOTTOM (solid shape): 149.26,24.98 149.26,24.58 148.79,24.58 148.78,24.57 148.71,24.57 148.7,24.56 148.7,24.49 148.7,24.48 148.7,24.19 148.7,24.19 148.7,24.13 148.72,24.11 148.78,24.11 148.8,24.09 149.26,24.09 149.26,23.84 149.25,23.83 148.03,23.83 147.68,23.48 147.68,23.48 147.46,23.25 147.43,23.26 147.19,23.16 147.1,22.93 147.1,22.9 147.07,22.86 147.07,22.22 147.05,22.19 147.05,21.17 147.03,21.16 145.27,21.16 145.02,20.91 144.02,20.91 143.85,20.75 143.82,20.76 143.49,20.69 143.41,20.36 143.42,20.32 143.34,20.23 143.25,20.23 143.25,20.15 142.83,19.73 142.83,18.98 142.68,18.83 141.7,18.83 141.57,18.97 141.57,20.33 143.29,22.05 145.71,22.05 146.14,22.48 146.14,23.7 146.44,24 146.53,24 146.69,24.16 146.97,24.16 148.31,25.49 148.75,25.49
+3.3V_ALWP on TOP (solid shape): 141.93,102.95 141.93,101.46 141.81,101.34 141.81,101.33 138.72,101.33 138.5,101.55 138.5,103.07 138.57,103.14 141.74,103.14
+3.3V_ALWP on BOTTOM (solid shape): outline of 122 points within 135.71,100.7 144.24,106.11
+3.3V_DGFF on TOP (solid shape): 232.85,93.78 232.85,93.75 232.97,93.38 233.27,93.12 233.28,93.11 233.36,93.03 233.36,92.33 233.14,92.12 232.13,92.12 232.03,92.22 232.03,93.08 231.72,93.39 231.72,93.71 232.52,93.71 232.65,93.84 232.79,93.84
+3.3V_DGFF on TOP (solid shape): outline of 615 points within 275.42,69.48 294.92,85.26
+3.3V_DGFF on BOTTOM (solid shape): 231.18,94.54 231.27,94.5 231.3,94.41 231.31,94.34 231.33,94.25 231.35,94.22 231.41,94.15 231.48,94.09 231.49,94.09 231.54,94.03 232.21,94.03 232.31,94.02 232.4,94.03 232.8,94.03 232.87,93.96 232.86,93.93 232.94,93.44 233.3,93.1 233.42,92.98 233.42,92.81 233.32,92.71 231.79,92.71 231.33,93.17 231.32,93.17 230.69,93.79 230.69,94.49 230.74,94.54
+3.3V_DGFF on IN1: outline of 424 points within 231.67,69.66 310.44,94.35
+3.3V_DGFF on IN2: outline of 170 points within 231.13,82.51 284.62,94.5
+3.3V_DGFF_PWR on TOP (solid shape): 297.23,70.91 297.23,69.23 297.76,68.7 297.76,68.24 297.66,68.14 296.75,68.14 296.06,68.82 295.2,68.82 294.51,69.51 294.51,69.81 294.54,69.84 295.04,69.84 295.07,69.86 295.07,70.35 295.04,70.37 294.54,70.37 294.51,70.4 294.51,70.6 294.54,70.63 295.04,70.63 295.07,70.65 295.07,71.16 295.04,71.19 294.56,71.19 294.51,71.24 294.51,71.54 294.79,71.82 296.31,71.82
+3.3V_DSW on TOP (solid shape): 124.21,25.48 124.21,25.2 124.17,25.18 124.01,25.07 123.97,24.88 123.97,24.87 123.97,24.09 123.92,24.03 123.5,24.03 123.38,24.15 123.38,24.53 123.5,24.65 123.5,24.8 123.51,24.81 123.53,24.89 123.52,24.98 123.52,25.01 123.61,25.11 123.61,25.24 123.62,25.25 123.65,25.35 123.66,25.45 123.65,25.48 123.72,25.55 124.14,25.55
+3.3V_LAN on TOP (solid shape): 160.91,136.44 163.31,136.44 163.56,136.2 163.56,133.72 163.06,133.23 160.87,133.23 160.59,133.5 160.59,134.32 160.72,134.45 161.89,134.45 162.17,134.73 162.17,135.03 161.89,135.31 160.75,135.31 160.43,135.64 160.13,135.64 160.03,135.74 160.03,136.7 160.08,136.75 160.6,136.75
+3.3V_LAN on BOTTOM (solid shape): outline of 232 points within 159.33,132.59 167.78,138.89
+3.3V_LAN on IN3 (solid shape): outline of 2613 points within 134.24,132.73 163.9,155.51
+3.3V_LAN_OUT on TOP (solid shape): 156.99,139.17 157.76,139.17 158.25,138.68 158.25,138.29 158.46,138.08 159.25,138.08 159.49,137.84 159.49,136.84 159.33,136.68 159.33,135.78 159.25,135.69 158.33,135.69 157.64,136.39 157.64,138.47 157.43,138.68 156.59,138.68 156.56,138.71 155.78,138.71 155.67,138.82 155.67,139.24 155.76,139.34 156.83,139.34
+3.3V_LAN_OUT on IN2 (solid shape): outline of 614 points within 148.82,136.08 159.08,142.74
+3.3V_M_TPM on BOTTOM (solid shape): 147.97,22.06 147.97,20.32 148.18,20.11 148.18,17.8 147.89,17.52 146.55,17.52 146.04,18.03 145.26,18.03 145.19,17.96 145.19,17.81 145.18,17.8 145.18,17.7 145.1,17.62 144.66,17.62 144.61,17.67 144.61,18.35 144.63,18.37 147.05,18.37 147.43,18.75 147.43,20.72 147.42,20.72 147.42,22.07 147.5,22.16 147.87,22.16
+3.3V_MMI_AUX on BOTTOM (solid shape): 21.67,9.38 21.67,8.47 22.02,8.12 22.02,7.65 21.96,7.59 20.94,7.59 20.86,7.61 20.41,8.06 20.41,8.81 20.55,8.95 20.55,9.31 20.66,9.42 21.63,9.42
+3.3V_MMI_AUX on BOTTOM (solid shape): 20.11,22.98 20.11,21.64 19.9,21.43 19.9,20.87 19.76,20.74 19.32,20.74 18.62,20.04 18.62,18.69 18.56,18.63 18.43,18.63 18.37,18.69 18.37,20.18 18.44,20.32 18.42,20.47 18.41,20.48 18.41,21.28 18.37,21.32 18.37,21.47 18.83,21.92 18.83,22.13 18.97,22.42 18.83,22.7 18.83,22.97 18.95,23.1 20,23.1
+3.3V_MMI_AUX on IN2 (solid shape): outline of 332 points within 15.38,7.91 23.26,23.8
+3.3V_MMI_AUX on IN3 (solid shape): 20.71,23.13 20.71,22.43 20.58,22.3 19.06,22.3 19,22.37 19,23.07 19.12,23.19 20.65,23.19
+3.3V_MV on BOTTOM (solid shape): 22.68,12.55 23.55,12.55 23.76,12.34 23.76,11.95 23.67,11.86 22.05,11.86 20.97,12.95 20.65,12.95 20.65,13 20.55,13.23 20.33,13.33 20.31,13.34 20.1,13.54 20.1,13.88 20.16,13.94 21.28,13.94
+3.3V_MV on BOTTOM (solid shape): 16.24,21.94 16.24,21.08 16.61,20.71 16.61,20.6 16.6,20.58 16.53,20.35 16.61,20.12 16.61,18.68 16.53,18.6 16.05,18.6 15.99,18.66 15.99,19.81 14.67,21.13 14.67,21.17 14.67,22 14.69,22.03 16.16,22.03
+3.3V_MV on BOTTOM (solid shape): 17.81,13.37 17.81,12.14 18.28,11.67 18.28,11.64 18.3,11.53 18.37,11.44 18.37,10.94 18.41,10.89 18.42,10.87 18.6,10.61 18.93,10.61 18.97,10.63 19.1,10.49 19.1,9.02 18.97,8.89 17.89,8.89 17.82,8.96 17.82,10.07 17.81,10.08 17.81,10.51 17.71,10.61 17.71,10.95 17.72,10.96 17.72,11.73 17.6,11.86 17.6,13.37 17.66,13.43 17.75,13.43
+3.3V_MV on BOTTOM (solid shape): 24.84,9.29 24.84,8.41 25.21,8.04 25.21,7.7 25.18,7.67 24.69,7.67 24.65,7.66 24.65,7.17 24.67,7.15 25.19,7.15 25.2,7.14 25.2,6.88 25.19,6.88 24.65,6.88 24.65,6.87 24.65,6.36 24.66,6.35 25.2,6.35 25.2,5.46 24.97,5.22 23.36,5.22 23.36,5.31 22.98,5.68 22.98,6.8 23.04,6.91 23.16,6.92 23.64,7.18 23.31,7.61 23.22,7.65 23.19,7.74 23.19,8.22 23.06,8.35 22.5,8.35 22.39,8.45 22.39,9.36 22.45,9.41 23.11,9.41 23.21,9.51 23.21,10.15 23.3,10.24 23.89,10.24
+3.3V_MV on IN1 (solid shape): outline of 2238 points within 12.88,5.37 27.45,21.25
+3.3V_PGPPBC on BOTTOM (solid shape): 130.59,37.03 130.59,36.49 130.33,36.24 129.69,36.24 129.59,36.14 128.96,36.14 128.9,36.2 128.9,36.59 128.95,36.64 129.63,36.64 130.15,37.17 130.45,37.17
+3.3V_PGPPEF on BOTTOM (solid shape): 134.01,31.83 134.01,31.15 133.43,31.15 133.37,31.09 133.37,30.92 133.17,30.72 133.01,30.72 132.77,30.97 132.77,31.07 132.61,31.07 132.61,31.07 132.29,31.07 132.2,31.16 132.2,31.67 132.38,31.85 133.98,31.85
+3.3V_PGPPHK on BOTTOM (solid shape): 136.23,31.69 136.23,31 136.15,30.91 135.66,30.91 135.5,30.75 135.12,30.75 134.88,30.99 134.22,30.99 134.19,31.03 134.19,31.52 134.38,31.71 134.99,31.71 135.13,31.86 135.6,31.86 135.61,31.86 136.06,31.86
+3.3V_PHVLDO on BOTTOM (solid shape): 121.44,47.38 122.53,47.38 123.12,46.8 123.11,46.76 123.18,46.42 123.52,46.35 123.56,46.36 123.75,46.16 123.76,46.15 123.84,46 123.99,45.92 124,45.92 124.05,45.87 124.55,45.87 124.56,45.82 124.87,45.57 125.18,45.82 125.2,45.87 125.32,45.87 125.5,46.05 125.52,46.05 125.59,46.06 125.65,46.09 125.66,46.1 126.12,46.1 126.23,45.99 126.23,45.07 126.03,44.87 125.42,44.87 125.12,45.18 123.4,45.18 122.71,45.87 122.71,46.38 122.65,46.44 121.42,46.44 120.95,46.55 120.92,46.07 120.87,45.96 120.8,45.96 120.66,45.82 119.71,45.82 119.49,46.03 119.49,47.31 119.82,47.64 121.18,47.64
+3.3V_PRTC on BOTTOM (solid shape): 126.32,25.45 126.32,25.11 126.16,25.11 126.16,24.49 126.14,24.47 125.49,24.47 124.93,24.47 125.25,24.01 125.35,23.98 125.4,23.88 125.4,23.76 125.02,23.38 124.17,23.38 124.17,24.09 124.04,24.22 124.04,25.55 124.13,25.64 124.36,25.64 124.72,25.61 124.87,25.94 124.87,25.99 124.89,26.04 125.74,26.04
+3.3V_RTC_LDO on IN3 (solid shape): outline of 206 points within 255.23,63.84 257.95,66.46
+3.3V_RUN on TOP (solid shape): 276.92,93.45 276.92,92.25 276.76,92.09 275.87,92.09 275.41,92.55 275.41,93.33 275.72,93.64 276.73,93.64
+3.3V_RUN on TOP (solid shape): 280.11,88.15 280.11,86.63 279.6,86.12 277.42,86.12 277.06,86.48 277.06,88.28 277.19,88.41 279.85,88.41
+3.3V_RUN on TOP (solid shape): 84.28,60.47 84.28,59.45 84.05,59.21 80.34,59.21 80.02,59.54 80.02,59.96 80.25,60.19 81.73,60.19 82.38,60.83 83.92,60.83
+3.3V_RUN on TOP (solid shape): 281.22,94.68 281.22,94.24 281.23,94.23 281.23,92.21 281.07,92.05 279.5,92.05 279.35,92.2 279.35,94.62 279.52,94.79 281.11,94.79
+3.3V_RUN on TOP (solid shape): 47.8,46.14 47.8,45.48 47.51,45.19 47.1,45.19 46.96,45.05 46.93,45.05 46.85,44.96 46.37,44.96 46.1,45.23 46.1,46.11 46.32,46.34 47.6,46.34
+3.3V_RUN on TOP (solid shape): 135.59,22.31 135.59,21.65 135.36,21.43 134.93,21.43 134.82,21.47 134.7,21.47 134.3,21.88 133.97,21.88 133.89,21.95 133.89,22.36 133.94,22.41 135.49,22.41
+3.3V_RUN on TOP (solid shape): 38.3,3.48 38.3,2.15 37.94,1.79 36.19,1.79 36.03,1.95 36.03,3.68 36.11,3.76 36.73,3.76 36.74,3.76 36.74,3.22 36.75,3.2 37.19,3.2 37.21,3.22 37.21,3.63 37.21,3.74 37.23,3.76 38.02,3.76
+3.3V_RUN on TOP (solid shape): 374.73,32.53 374.73,30.29 374.58,30.14 372.35,30.14 372,30.49 371.94,30.49 371.88,30.54 371.88,30.96 371.86,30.98 371.35,30.98 371.34,31 371.34,31.23 371.35,31.24 371.88,31.24 371.88,31.77 371.86,31.8 371.37,31.8 371.36,31.81 371.36,32.01 371.4,32.05 371.86,32.05 371.88,32.08 371.88,32.56 372.21,32.89 374.38,32.89
+3.3V_RUN on TOP (solid shape): 124.89,58.31 124.89,56.47 124.55,56.12 124.55,56.09 124.34,55.89 123.83,55.89 123.83,55.89 123.72,55.89 123.72,55.78 123.61,55.67 122.79,55.67 122.73,55.61 122.73,54.51 122.63,54.4 121.98,54.4 121.83,54.54 121.83,56.32 122.12,56.61 123.53,56.61 123.6,56.68 123.62,56.68 123.62,57.1 123.88,57.36 123.88,57.5 123.94,57.56 123.94,58.11 124.24,58.41 124.79,58.41
+3.3V_RUN on TOP (solid shape): 108.97,25.54 109.08,25.48 109.09,25.36 109.09,25.07 109.31,24.87 109.36,24.86 109.36,23.87 109.6,23.62 110.15,23.62 110.2,23.57 111.08,23.57 111.11,23.56 111.22,23.45 111.22,22.98 111.19,22.94 111.16,22.89 111.12,22.85 110.58,22.85 110.58,22.85 110.22,22.85 110.1,22.97 109.93,23.02 109.75,23.02 109.58,22.97 109.46,22.85 108.43,22.85 108.22,23.06 107.83,23.06 107.62,23.27 107.62,23.41 107.77,23.56 108.35,23.56 108.43,23.64 108.43,25.39 108.58,25.54
+3.3V_RUN on TOP (solid shape): outline of 1900 points within 53.95,34.37 72.57,58.84
+3.3V_RUN on BOTTOM (solid shape): 48.08,45.86 48.08,42.43 47.95,42.31 45.79,42.31 45.54,42.56 45.54,45.61 45.79,45.86 47.91,45.86 48,45.95
+3.3V_RUN on BOTTOM (solid shape): 138.78,130.29 138.78,126.21 138.12,125.55 136.37,125.55 136.19,125.73 136.19,126.8 136.55,127.15 136.55,130.31 136.61,130.36 138.71,130.36
+3.3V_RUN on BOTTOM (solid shape): 310.38,24.35 310.38,22.6 310.13,22.35 307.48,22.35 307.36,22.47 307.36,22.66 307.35,22.66 307.35,23.64 307.5,23.79 307.84,23.79 308.5,24.45 310.28,24.45
+3.3V_RUN on BOTTOM (solid shape): 390.08,14 390.08,13.73 390.06,13.72 389.53,13.72 389.52,13.71 389.52,13.27 389.53,13.25 390.07,13.25 390.07,13.25 390.07,12.6 389.94,12.47 388.62,12.47 388.54,12.55 388.54,13.96 388.69,14.11 389.96,14.11
+3.3V_RUN on BOTTOM (solid shape): 123.61,33.89 123.61,32.16 123.47,32.02 122.86,32.02 122.7,32.18 122.66,32.28 122.7,32.37 122.81,32.64 122.64,32.89 122.61,32.91 122.61,32.92 122.61,33.75 122.83,33.97 123.52,33.97
+3.3V_RUN on BOTTOM (solid shape): 170.78,63.63 170.78,62.59 170.77,62.57 170.71,62.5 170.7,62.5 170.36,62.17 170.36,61.91 170.32,61.91 170.32,61.29 170.18,61.14 169.57,61.14 169.39,61.32 169.39,61.69 169.85,62.15 169.85,62.67 169.67,62.85 169.36,62.85 169.19,62.68 169.19,62.57 169.18,62.55 169.15,62.47 169.14,62.39 169.13,62.32 168.66,62.32 168.5,62.49 168.5,63.08 168.5,63.08 168.5,64.27 168.63,64.41 170,64.41
+3.3V_RUN on BOTTOM (solid shape): 28.54,7.55 28.54,6.19 28.18,5.82 25.47,5.82 25.33,5.97 25.33,6.39 25.32,6.4 25.32,6.47 25.28,6.47 25.26,6.48 24.78,6.48 24.77,6.49 24.77,6.75 24.78,6.75 25.25,6.75 25.25,6.76 25.32,6.76 25.32,6.82 25.33,6.83 25.33,7.19 25.32,7.2 25.32,7.27 25.29,7.27 25.28,7.28 25.24,7.28 24.8,7.28 24.78,7.29 24.78,7.53 24.79,7.54 25.31,7.54 25.33,7.56 25.33,7.64 25.35,7.65 25.35,8.08 25.33,8.1 25.33,8.26 25.54,8.47 27.61,8.47
+3.3V_RUN on BOTTOM (solid shape): 128.27,35.31 128.38,35.29 128.5,35.31 128.51,35.31 128.8,35.31 128.89,35.22 129.09,35.22 129.19,35.12 129.2,35.09 129.24,34.98 129.32,34.89 129.32,34.36 129.02,34.07 128.74,34.07 128.59,33.91 128.59,33.38 128.46,33.25 128.43,33.25 128.27,33.3 128.11,33.26 128.1,33.25 127.7,33.25 127.49,33.47 127.49,34.37 127.64,34.53 127.96,34.53 127.97,34.53 128.12,34.53 128.12,34.68 128.12,34.68 128.12,35.22 128.21,35.31 128.26,35.31
+3.3V_RUN on BOTTOM (solid shape): 58.3,58.21 58.49,58.07 58.72,58.08 58.73,58.08 58.77,58.08 58.87,57.98 58.87,57.7 58.67,57.5 58.67,55.72 58.9,55.49 58.9,55.23 58.9,55.22 58.87,55.08 58.9,54.95 58.9,54.93 58.9,54.17 58.78,54.05 58.76,54.02 58.72,53.96 57.96,53.96 57.78,54.14 57.78,54.29 57.79,54.3 57.82,54.36 57.83,54.42 57.83,55.11 57.82,55.17 57.79,55.23 57.78,55.24 57.78,57.14 57.83,57.19 57.83,58.05 57.99,58.21
+3.3V_RUN on BOTTOM (solid shape): 29.32,62.98 29.32,62.18 28.17,61.02 26.95,61.02 26.95,61.03 26.93,61.03 26.91,61.05 26.49,61.05 26.48,61.05 26.48,61.55 26.48,61.56 26.48,61.58 26.41,61.58 26.37,61.63 26.07,61.63 26.03,61.58 25.97,61.58 25.97,61.53 25.92,61.48 25.92,61.05 25.68,61.05 25.68,61.58 25.64,61.58 25.59,61.63 25.25,61.63 25.2,61.58 25.17,61.58 25.17,61.55 25.13,61.51 25.13,61.03 24.62,61.03 24.62,61.82 24.72,61.96 24.74,62.13 24.77,62.23 24.86,62.27 25,62.31 25.11,62.4 25.41,62.4 26.37,63.36 28.94,63.36
+3.3V_RUN on BOTTOM (solid shape): 139.22,23.87 139.22,23.34 138.94,23.05 138.45,23.05 138.35,22.95 138.35,22.82 137.86,22.33 137.86,22.03 137.58,21.75 137.58,21.7 137.57,21.69 137.55,21.58 137.57,21.47 137.58,21.46 137.58,20.32 137.56,20.3 137.53,20.23 137.52,20.15 137.52,19.7 137.42,19.61 137.06,19.61 136.96,19.7 136.96,19.74 136.93,19.77 136.93,20.94 136.3,21.57 136.21,21.57 136.19,21.58 135.93,21.6 135.74,21.42 135.74,21.41 134.97,21.41 134.7,21.67 134.7,21.98 135.2,22.48 137.5,22.48 137.54,22.52 137.54,23.72 137.72,23.89 137.72,23.9 137.89,24.07 139.02,24.07
+3.3V_RUN on BOTTOM (solid shape): 124.69,58.07 125.76,58.07 125.86,57.96 133.01,57.96 133.22,57.76 133.22,57.24 132.99,57.01 127.96,57.01 127.71,56.76 126.16,56.76 123.57,54.17 123.45,54.17 123.45,54.26 123.47,54.28 123.22,54.9 122.98,54.28 123,54.26 123,54.17 122.89,54.17 122.87,54.19 122.59,54.32 122.32,54.17 122.12,54.17 121.52,54.77 121.52,56.31 123.63,58.41 124.34,58.41
+3.3V_RUN on BOTTOM (solid shape): outline of 86 points within 177.7,89.58 183.4,92.6
+3.3V_RUN on BOTTOM (solid shape): outline of 290 points within 152.69,121.63 157.25,127.21
+3.3V_RUN on IN1 (solid shape): outline of 2192 points within 145.82,117.34 162.79,137.02
+3.3V_RUN on IN2 (solid shape): outline of 157 points within 275.38,86.15 280.47,93.46
+3.3V_RUN on IN3 (solid shape): outline of 184 points within 303.76,14.64 309.39,24.31
+3.3V_RUN on IN4 (solid shape): outline of 3882 points within 36.04,1.21 68.53,35.85
+3.3V_RUN on IN1: 54.06,39.04 57.43,42.41 63.35,42.41 70.53,49.6 79.78,49.6 89.18,58.99 89.18,60.09 88.8,60.47 84.73,60.47 83.08,58.82 80.74,58.82 80.01,59.55 80.01,60.08 80.14,60.21 80.14,60.23 80.27,60.36 81.68,60.36 82.35,61.03 83.75,61.03 84.79,62.07 86.61,62.07 88.42,63.87 90.73,63.87 91.34,63.26 91.34,53.81 84.96,47.44 72.62,47.44 70.27,45.09 70.27,44.08 71.96,42.39 71.96,40.78 71.42,40.25 65.43,40.25 65.15,39.97 60.12,39.97 57.15,37 51.52,37 50.18,38.34 48.37,38.34 45.29,41.42 45.29,45.28 45.9,45.89 47.8,45.89 48.16,45.53 48.16,43.98 49.76,42.38 50.07,42.38 53.41,39.04
+3.3V_RUN on VCC: 65.2,44.49 71.93,51.23 85.73,51.23 95.3,60.8 95.3,63.14 111.03,78.87 112.25,78.87 117.48,84.1 117.48,119.47 134.05,136.03 159.07,136.03 162.87,132.23 162.87,125.94 161.06,124.13 135.42,124.13 132.29,121 132.29,99.93 123.53,91.17 123.53,81.35 88.18,46 82.8,46 75.68,38.88 73.56,38.88 72.46,39.97 66.06,39.97 65.2,40.84
+3.3V_RUN on VCC: outline of 177 points within 3.69,1.35 391.74,94.55
+3.3V_RUN on IN3: outline of 125 points within 122.88,30.06 130.98,40.19
+3.3V_RUN on IN3: 3.72,30.22 3.72,37.52 4.87,37.52 4.87,48.62 4.09,49.4 4.09,52.67 5.15,53.74 5.15,64.99 7.47,67.3 7.47,74.64 8.33,75.5 16.7,75.5 22.47,69.88 29.06,65.24 29.66,64.63 29.66,62.27 28.47,61.08 26.13,61.08 21.17,66.04 19.64,66.04 18.79,66.89 14.93,66.89 12.14,64.1 12.14,59.25 12.93,58.46 12.93,48.25 12.42,47.74 12.42,47.19 11.84,46.61 11.84,34.9 7.16,30.22
+3.3V_RUN on IN3: 27.29,1.96 26.99,2.26 26.98,2.28 26.9,2.42 26.75,2.51 26.74,2.52 25.86,3.39 25.86,6.92 27.08,8.14 28.49,8.14 28.79,7.83 28.79,7.43 31.14,5.07 37.63,5.07 38.31,4.39 38.31,2.36 37.91,1.96
+3.3V_RUN on IN4: 289.71,80.22 289.65,80.25 289.61,80.27 289.61,83.05 290.13,83.57 290.23,83.57 291.05,84.39 294.92,84.39 295.73,83.58 295.75,83.54 295.73,83.49 295.75,83.01 296.24,82.99 296.28,83.01 296.32,82.99 297.08,82.23 297.08,74.74 296.34,74 296.24,73.97 296.15,74.01 295.63,74.05 295.62,73.53 295.66,73.45 295.64,73.37 295.6,73.32 295.58,73.24 295.53,73.19 291.49,73.19 289.61,75.07 289.61,79.58 289.65,79.59 289.7,79.62 289.75,79.66 289.84,79.69 289.93,79.65 290.55,79.89 289.95,80.16 289.86,80.13 289.77,80.17
+3.3V_RUN_AUDIO on BOTTOM (solid shape): 392.53,13.96 392.53,12.64 392.25,12.36 390.73,12.36 390.22,12.87 390.22,13.4 389.66,13.4 389.66,13.58 390.22,13.58 390.22,14.21 390.24,14.24 392.25,14.24
+3.3V_RUN_AUDIO_DVDD on TOP (solid shape): 378.61,27.77 378.61,27.05 378.56,27 378.56,26.04 378.45,25.94 378.39,25.8 378.39,25.78 377.81,25.2 377.79,25.2 377.54,24.71 378.07,24.56 379.15,24.56 379.18,24.51 379.19,24.46 379.19,24.35 379.13,24.29 378.25,24.29 378.19,24.22 374.81,24.22 374.71,24.32 374.71,24.94 374.82,25.05 375.27,25.05 375.35,25.14 375.44,25.14 375.44,25.22 375.45,25.24 375.45,25.63 375.63,25.81 377.01,25.81 377.06,25.76 377.06,25.67 377.67,25.67 377.67,25.79 377.76,25.87 377.76,26.32 377.85,26.55 377.77,26.78 377.76,26.8 377.65,26.91 377.65,27.77 377.8,27.92 378.46,27.92
+3.3V_RUN_DIMM1 on BOTTOM (solid shape): 174.72,81.37 174.72,81.11 174.6,80.99 174.51,80.99 174.45,81.01 174.39,81.01 172.95,81.01 172.89,81.01 172.81,80.99 172.75,80.93 172.72,80.9 172.3,80.48 172.27,80.48 172.14,80.34 172.11,80.34 171.92,80.24 171.84,80.04 171.84,80.02 171.79,79.97 171.79,79.67 171.38,79.26 167.85,79.26 167.77,79.34 167.77,80.21 168.11,80.56 170.3,80.56 171.08,81.34 172.81,81.34 172.91,81.43 174.66,81.43
+3.3V_RUN_DIMM2 on TOP (solid shape): 181.98,89.24 181.98,88.13 181.43,87.59 180,87.59 179.2,88.39 179.2,89.22 179.33,89.36 180.1,89.36 180.32,89.36 180.51,89.55 181.66,89.55
+3.3V_RUN_DIMM3 on BOTTOM (solid shape): 185.49,88.88 185.49,87.87 184.9,87.28 182.21,87.28 182.06,87.44 182.06,88.14 182.31,88.4 182.31,88.79 182.37,88.85 184.42,88.85 184.59,89.01 185.36,89.01
+3.3V_RUN_DIMM4 on TOP (solid shape): 200.65,88.34 200.65,87.27 198.52,85.14 198.52,81.39 198.04,80.91 196.91,80.91 196.77,81.06 195.33,81.06 195.32,81.06 194.79,81.06 194.71,81.14 194.71,81.34 194.76,81.39 196.46,81.39 196.89,81.82 196.89,87.21 197.74,88.07 199.64,88.07 199.94,88.37 200.62,88.37
+3.3V_RUN_PWR on TOP (solid shape): 369.11,33.87 369.17,33.84 369.23,33.82 369.25,33.81 369.44,33.62 369.55,33.62 370.32,33.62 370.47,33.62 371.24,33.62 371.77,33.1 371.77,32.62 371.75,32.61 371.75,32.24 371.7,32.19 371.22,32.19 371.17,32.13 371.17,31.75 371.22,31.7 371.22,31.66 371.26,31.66 371.71,31.66 371.75,31.61 371.75,31.42 371.73,31.4 371.22,31.4 371.18,31.36 371.18,30.84 371.72,30.84 371.75,30.8 371.75,30.57 371.68,30.49 371.52,30.49 371.4,30.37 370.15,30.37 370.02,30.49 370.02,31.23 369.64,31.61 369.29,31.61 369.14,31.76 369.14,32.65 368.83,32.96 368.8,32.96 368.79,32.97 368.63,33.01 368.47,32.97 368.45,32.96 368.4,32.96 368.27,33.09 368.25,33.09 368.25,33.85 368.27,33.87
+3.3V_RUN_R_F on BOTTOM: 133.23,129.16 134.24,129.16 134.48,128.92 134.48,127.47 134.62,127.33 135.57,127.33 135.65,127.26 135.65,125.87 135.54,125.77 133.65,125.77 132.99,126.43 132.99,128.92
+3.3V_SPI on TOP (solid shape): 137.66,22.05 137.66,21.82 137.55,21.58 137.66,21.34 137.66,21.11 137.55,21 136.16,21 136.15,21.01 136.05,21.04 135.94,21.04 135.79,21.19 135.79,21.5 136.03,21.73 136.03,22.17 136.22,22.36 137.34,22.36
+3.3V_SSD3 on TOP (solid shape): 329.45,30.78 329.45,30.13 329.47,30.11 329.47,29.98 329.95,29.5 329.95,24.12 329.7,23.87 329.7,22.75 329.69,22.74 329.64,22.56 329.69,22.38 329.7,22.36 329.7,20.88 329.33,20.88 329.22,20.99 328.68,20.99 328.68,20.45 329.05,20.08 329.31,20.08 329.31,19.03 329.88,19.03 329.88,18.67 329.05,17.85 329.05,17.08 329.05,16.96 329.07,16.95 329.08,16.93 329.54,16.93 329.59,16.88 329.59,16.7 329.56,16.68 329.05,16.68 329.03,16.65 329.03,16.14 329.05,16.12 329.56,16.12 329.59,16.09 329.59,15.89 329.56,15.86 329.05,15.86 329.03,15.84 329.03,14.29 329.26,14.06 329.26,13.5 329.17,13.41 327.39,13.41 325.31,15.5 325.31,16.91 325.37,17.02 325.5,17.02 326,17.12 325.9,17.61 325.84,17.68 325.85,17.77 325.77,18.18 325.36,18.24 325.32,18.28 325.31,18.34 325.31,19.05 325.34,19.11 325.41,19.1 325.46,19.05 325.45,19.02 325.9,18.62 326.08,19.19 326.05,19.27 326.08,19.35 325.98,19.88 325.47,19.69 325.46,19.67 325.41,19.62 325.34,19.69 325.34,29.47 327,31.13 329.1,31.13
+3.3V_SSD3 on BOTTOM (solid shape): 330.2,33.62 330.2,30.57 330.09,30.47 328.26,30.47 327.87,30.85 327.87,30.87 327.79,30.99 327.67,31.06 327.65,31.08 326.08,31.08 325.96,31.2 325.96,31.99 325.98,32.01 325.98,32.27 327.44,33.73 330.08,33.73
+3.3V_SSD3 on BOTTOM (solid shape): 328.97,28.86 329,28.86 329.28,28.58 329.29,28.58 329.48,28.39 329.48,26.46 329.67,26.26 329.67,24.05 329.66,24.04 329.66,23.78 329.47,23.58 328.74,23.58 328.62,23.71 328.62,26.94 327.98,27.57 327.66,27.57 327.6,27.57 326.35,27.57 326.29,27.57 326.13,27.57 325.91,27.79 325.91,29.48 328.36,29.48
+3.3V_SSD3 on BOTTOM (solid shape): outline of 158 points within 309.95,7.72 329.69,17.01
+3.3V_SSD3_PWR on TOP (solid shape): 332.41,19.01 332.41,18.4 332.1,18.1 332.1,15.97 330.78,14.65 329.38,14.65 329.18,14.85 329.18,15.64 329.26,15.71 329.69,15.71 329.74,15.76 329.74,16.25 329.72,16.27 329.21,16.27 329.18,16.3 329.18,16.5 329.21,16.52 329.72,16.52 329.74,16.55 329.74,17.06 329.72,17.08 329.23,17.08 329.18,17.13 329.18,17.62 329.49,17.62 330.73,18.86 331.52,18.86 331.8,19.14 332.28,19.14
+3.3V_SSD4 on TOP (solid shape): 385.89,10.94 385.89,10.31 385.92,10.27 385.92,9.65 385.94,9.63 385.94,9.51 385,8.56 385,7.9 384.25,7.15 383.84,7.15 383.51,7.48 383.51,7.63 383.45,7.69 383.45,7.7 383.36,7.82 383.24,7.91 383.23,7.91 383.06,8.09 383.06,8.95 382.8,9.2 382.75,9.26 382.7,9.3 382.24,9.76 382.24,10.66 382.32,10.74 382.67,10.74 382.67,10.27 382.74,10.2 382.74,10.16 382.78,10.16 382.88,10.05 382.95,10.11 384.16,10.11 384.17,10.12 384.24,10.2 384.25,10.2 384.31,10.26 384.31,10.26 384.36,10.31 384.36,10.88 384.47,10.98 385.84,10.98
+3.3V_SSD4 on TOP (solid shape): 376.33,11 376.45,10.97 376.57,11 376.58,11 377.49,11 377.73,10.76 378.7,10.76 378.76,10.82 378.76,10.92 378.81,10.98 379.46,10.98 379.51,10.92 379.51,10.28 379.6,10.19 381.38,10.19 381.54,10.03 381.54,8.8 381.83,8.5 381.83,8.02 381.4,7.58 381.4,7.2 379.49,7.2 379.49,7.33 379.51,7.44 379.5,7.54 379.5,7.58 379.72,7.8 379.73,7.81 379.86,7.9 379.95,8.03 379.97,8.05 379.98,8.09 379.96,8.47 379.69,8.73 379.67,8.74 379.63,8.78 379.29,8.78 379.27,8.81 377.18,8.81 376.18,9.81 376.18,10.89 376.28,11 376.32,11
+3.3V_SSD4 on TOP (solid shape): 364.71,11.05 364.71,11.04 364.71,10.46 364.84,10.33 366.01,10.33 366.15,10.19 366.76,10.19 366.8,10.23 366.94,10.23 366.94,10.37 367.05,10.47 367.05,10.69 367.07,10.71 367.07,10.86 367.18,10.97 367.7,10.97 367.75,10.92 367.75,10.41 368.05,10.1 368.05,9.1 367.69,8.73 367.02,8.42 367.37,7.77 367.37,7.29 367.16,7.08 365.84,7.08 365.18,7.74 365.13,7.75 365.07,7.76 364.98,7.82 364.97,7.94 363.54,9.3 363.73,7.33 363.82,7.26 363.81,7.14 363.69,6.88 363.64,6.61 363.64,6.58 362.09,5.03 360.05,5.03 359.48,5.59 359.48,9.54 360.21,10.26 362.19,10.26 362.53,10.6 362.56,10.6 362.77,10.67 362.87,10.87 362.87,10.94 363.67,10.94 363.93,11.19 364.56,11.19
+3.3V_SSD4 on BOTTOM (solid shape): 385.47,8.99 385.47,8.95 385.22,8.54 385.26,8.05 385.27,8.01 384.31,7.05 383.97,7.05 383.51,7.51 383.5,7.54 383.42,7.75 383.24,7.91 383.23,7.91 383,8.15 383,8.18 382.99,8.39 382.9,8.57 382.9,9.03 383.03,9.16 384.5,9.16 384.61,9.27 385.2,9.27
+3.3V_SSD4 on BOTTOM (solid shape): 364.31,10.1 364.84,10.1 365.47,9.47 365.47,9.45 365.6,9.21 365.88,9.2 365.89,9.21 366.11,9.21 366.12,9.2 366.25,9.17 366.38,9.2 366.39,9.21 366.61,9.21 366.62,9.2 366.75,9.17 366.88,9.2 366.89,9.21 367,9.21 367.32,8.89 367.35,8.8 367.29,8.72 366.99,8.2 367.41,7.76 367.41,7.23 367.21,7.03 365.81,7.03 365.61,7.23 365.61,7.52 365.12,8.01 365.05,8.05 365.03,8.13 363.54,9.3 363.54,7.4 363.59,7.34 363.58,7.26 363.51,7.12 363.46,6.97 362.81,6.97 362.81,4.85 362.2,4.24 361.01,4.24 360.68,3.91 357.99,3.91 357.58,4.32 357.58,5.22 357.66,5.3 357.66,8.13 357.56,8.23 355.74,8.23 355.33,8.64 355.33,9.41 355.52,9.6 356.63,9.6 356.63,9.62 356.79,9.78 358.08,9.78 358.08,9.78 358.08,10.32 358.08,10.33 358.33,10.33 358.34,10.32 358.34,9.8 358.36,9.78 360.64,9.78 361.41,10.56 363.85,10.56
+3.3V_SSD4 on IN1 (solid shape): outline of 550 points within 360.24,5.3 385.27,10.76
+3.3V_SSD4 on IN3 (solid shape): outline of 125 points within 359.99,4.73 369,11.47
+3.3V_SSD4 on IN4 (solid shape): outline of 1121 points within 360.28,5.23 385.22,12.25
+3.3V_SSD4_PWR on BOTTOM (solid shape): 354.78,11.88 357.92,11.88 358.94,10.86 358.94,9.97 358.89,9.92 358.53,9.92 358.51,9.95 358.51,10.45 358.48,10.48 357.97,10.48 357.95,10.45 357.95,9.95 357.92,9.92 357.72,9.92 357.69,9.95 357.69,10.45 357.67,10.48 357.16,10.48 357.13,10.45 357.13,9.95 357.11,9.92 356.8,9.92 356.73,10 356.12,10 355.86,9.74 353.95,9.74 353.36,10.33 353.36,12.41 353.44,12.49 354.18,12.49
+3.3V_SSD5 on TOP (solid shape): 334.55,28.68 334.55,25.45 334.11,25.01 332.61,25.01 332.59,24.98 332.59,24.48 332.56,24.45 332.36,24.45 332.33,24.48 332.33,24.98 332.31,25.01 331.8,25.01 331.77,24.98 331.77,24.48 331.75,24.45 331.54,24.45 331.52,24.47 331.52,24.88 331.52,25.01 331.04,25.01 330.99,25.06 330.99,27.59 332.22,28.83 334.4,28.83
+3.3V_SSD5 on BOTTOM (solid shape): 327.61,39.89 328.88,39.89 329,39.77 329,36.44 328.65,36.08 326.17,36.08 325.69,36.57 325.69,38.88 325.6,38.97 325.6,40.15 325.73,40.27 327.23,40.27
+3.3V_SSD5 on BOTTOM (solid shape): 329.05,54.73 329.14,54.73 329.58,54.28 329.63,54.22 329.71,54.16 329.83,54.12 329.95,54.12 329.99,54.13 330.15,53.97 330.15,50.97 330.07,50.88 328.99,50.88 327.73,52.14 327.73,52.59 327.48,52.85 327.17,52.85 327.15,52.85 327.09,52.88 327.03,52.88 325.78,52.88 325.72,52.88 325.66,52.85 325.64,52.85 325.45,52.85 325.32,52.97 325.32,54.62 325.45,54.75 329.05,54.75
+3.3V_SSD5 on BOTTOM (solid shape): outline of 187 points within 312.84,55.91 329.41,66.31
+3.3V_SSD5 on IN1: 324.69,34.69 322.78,36.59 322.78,41.62 322.79,41.63 322.79,45.67 322.6,45.86 322.6,53.84 324.76,56 324.86,56 325.73,56.87 329.27,56.87 329.54,56.61 329.54,54.56 329.53,54.47 329.54,54.39 329.54,48.5 330.78,47.26 330.78,40.08 329.68,38.98 329.68,35.99 328.37,34.69
+3.3V_SSD5 on IN2: 324.16,27.04 324.16,31.08 324.2,31.09 324.4,31.42 324.2,31.74 324.16,31.76 324.16,31.96 324.22,32.07 324.34,32.08 325.5,32.79 324.34,33.51 324.22,33.52 324.16,33.63 324.16,35.28 327.21,38.33 331.38,38.33 334.44,35.27 334.44,27.1 333.96,26.62 324.59,26.62
+3.3V_SSD5_PWR on TOP (solid shape): 331.39,24.83 331.39,24.32 331.42,24.3 331.9,24.3 331.92,24.32 331.92,24.83 331.95,24.86 332.15,24.86 332.18,24.83 332.18,24.32 332.2,24.3 332.71,24.3 332.74,24.32 332.74,24.81 332.79,24.86 333.14,24.86 333.4,24.6 333.4,23.46 333.39,23.45 333.39,23.03 332.98,22.63 332.98,21.76 332.43,21.21 332.43,20.61 332.36,20.54 331.72,20.54 331.29,20.97 330.96,20.97 330.6,21.33 330.6,22.52 330.62,22.54 330.62,24.54 330.93,24.86 331.37,24.86
+3.3V_SSD6 on TOP (solid shape): 137.1,93.33 137.1,91.2 137.06,91.16 134.54,91.16 134.25,91.45 134.25,92.47 135.18,93.4 137.03,93.4
+3.3V_SSD6 on BOTTOM (solid shape): 124.46,92.86 124.46,92.07 123.65,91.26 123.65,91.12 123.65,91.12 123.65,89.38 123.58,89.31 122.97,89.31 122.82,89.45 122.82,90.7 122.63,90.9 122.48,90.9 122.44,90.86 122.43,90.86 122.3,90.75 122.26,90.6 122.26,89.35 122.28,89.24 122.35,89.14 122.35,87.68 122.26,87.59 122.1,87.59 122.1,87.43 121.86,87.19 121.66,87.19 121.65,87.2 121.46,87.2 121.45,87.19 121.38,87.19 121.38,87.12 121.26,87 118.7,87 118.55,87.16 118.55,88.22 123.39,93.06 124.26,93.06
+3.3V_SSD6 on BOTTOM: 135.44,84.07 135.11,83.74 130.84,83.74 130.84,84.35 130.84,84.36 130.84,84.42 130.83,84.44 130.61,84.44 130.3,84.44 130.29,84.45 130.29,84.7 130.31,84.72 130.82,84.72 130.84,84.74 130.84,85.21 130.83,85.22 130.82,85.24 130.76,85.24 130.75,85.24 130.3,85.24 130.29,85.25 130.29,85.5 130.3,85.51 130.83,85.51 130.84,85.52 130.84,85.61 130.85,85.62 130.85,86.07 130.84,86.08 130.84,86.11 130.9,86.22 131.02,86.23 131.52,86.6 130.94,86.83 130.88,86.83 130.84,86.88 130.84,86.9 130.53,87.21 130.53,88.13 131.3,88.9 134.52,88.9 134.82,89.2 134.82,91.01 134.26,91.58 134.26,92.26 136.02,94.02 143.51,94.02 143.52,94.02 144.04,94.02 144.13,93.98 144.16,93.89 144.38,93.54 144.78,93.63 144.88,93.67 144.97,93.63 145.37,93.54 145.59,93.89 145.63,93.98 145.72,94.02 149.09,94.02 149.36,93.75 149.36,90.07 148.63,89.34 141.49,89.34 141.33,89.19 141.33,87.41 141.31,87.38 139.64,87.38 139.57,87.45 139.02,87.45 138.91,87.33 138.91,87.22 135.76,84.07
+3.3V_SSD6 on IN2: 123.88,91.3 123.74,91.44 123.74,92.45 124.38,93.08 125.39,93.08 125.97,93.66 132.64,93.66 133.08,93.22 133.1,93.22 133.18,93.14 136.52,93.14 136.75,92.91 136.75,91.58 136.54,91.37 126.29,91.37 126.23,91.3
+3.3V_SSD6_PWR on BOTTOM (solid shape): outline of 106 points within 127.49,82.82 130.73,86.04
+3.3V_TBT on BOTTOM (solid shape): 25.55,60.96 25.59,60.92 26.01,60.92 26.02,60.93 26.08,60.93 26.08,61.46 26.1,61.48 26.34,61.48 26.35,61.46 26.35,60.96 26.39,60.92 26.86,60.92 26.9,60.88 26.9,59.58 26.81,59.49 25.87,59.49 25.76,59.38 25.76,58.56 25.71,58.51 24.16,58.51 23.57,59.11 23.57,60.64 23.73,60.81 23.76,60.8 23.92,60.82 24.06,60.9 25.22,60.9 25.25,60.93 25.28,60.93 25.28,61.48 25.55,61.48
+3.3V_TBT_FLASH_R on TOP (solid shape): 48.44,44.65 48.44,42.28 47.8,41.65 47.04,41.65 46.94,41.75 46.94,44.87 46.99,44.92 48.17,44.92
+3.3V_TBT_FLASH_R on TOP (solid shape): 44.49,54.11 47.81,54.11 48,53.91 48,53.2 47.92,53.12 45.46,53.12 45.15,53.3 44.84,53.12 44.21,53.12 44.21,54.11 44.48,54.11
+3.3V_TBT_S0 on TOP (solid shape): outline of 81 points within 32.45,50.19 36.42,55.32
+3.3V_TBT_S0 on BOTTOM (solid shape): 26.83,59.26 26.83,56.19 26.7,56.06 26.7,55.17 26.32,54.79 25.49,54.79 24.67,55.61 24.67,58.19 24.82,58.35 25.74,58.35 25.93,58.53 25.93,59.3 25.97,59.33 26.75,59.33
+3.3V_TBT_S0 on IN4: 24.79,54.96 25.47,54.28 26.67,54.28 28.94,52.01 30.91,52.01 32.13,50.79 32.81,50.79 33.45,50.15 33.45,49.88 33.42,49.85 33.42,49.82 33.7,49.54 37.36,49.54 38.77,50.95 38.77,53.92 35.07,57.62 25.5,57.62 24.79,56.92
+3.3V_TBT_SX on TOP (solid shape): 48.28,57.88 48.28,56.14 48.16,56.01 47.84,56.01 47.83,56.02 47.83,56.57 47.39,56.57 47.39,56.01 46.98,56.01 46.98,56 46.13,56 45.99,55.86 45.99,54.94 45.64,54.59 45.19,54.59 45.18,54.64 45,54.85 44.73,54.81 44.65,54.78 44.57,54.82 44.52,54.86 43.63,54.86 43.28,55.21 43.28,56.18 44.01,56.92 44.05,56.91 44.21,56.9 44.36,56.97 46.59,56.97 46.85,57.24 46.85,57.29 46.88,57.35 47.05,57.57 47.01,57.84 46.98,57.89 47.18,58.08 48.08,58.08
+3.3V_TBT_SX on IN3: 45.62,57.38 44.74,56.5 36.57,56.5 35.89,57.19 33.71,57.19 33.17,57.72 31.21,57.72 30.88,57.39 30.88,56.45 31.06,56.28 34.74,56.28 36.04,54.98 36.04,54.36 36.46,53.94 40.6,53.94 41.44,53.1 41.44,49.62 41.32,49.49 40.25,49.49 39.66,50.09 38.87,50.09 38.68,49.9 38.68,49.6 38.58,49.49 38.38,49.49 38.22,49.65 38.04,49.47 35.58,49.47 34.41,48.3 34.41,45.1 34.82,44.69 35.25,44.69 35.25,44.7 35.4,44.85 35.4,47.26 35.7,47.56 38.37,47.56 39.01,48.2 43.43,48.2 43.91,48.68 43.91,51.68 43.38,52.21 43.38,53.43 43.74,53.79 45.44,53.79 46.57,54.92 46.57,55.73 47.32,56.48 48.05,56.48 48.28,56.71 48.28,57.25 48.15,57.38
+3.3V_TP on TOP (solid shape): 38.27,4.83 38.27,4.3 37.86,3.89 37.18,3.89 37.16,3.87 37.09,3.87 37.09,3.85 37.09,3.8 37.08,3.8 37.08,3.57 37.09,3.57 37.09,3.34 37.08,3.33 36.88,3.33 36.87,3.34 36.87,3.84 36.86,3.84 36.86,3.87 36.8,3.87 36.78,3.89 36.05,3.89 36.02,3.86 35.89,3.86 35.49,3.46 33.82,3.46 33.64,3.64 33.64,4.8 33.85,5.01 38.09,5.01
+3.3V_TP on IN4 (solid shape): outline of 617 points within 16.69,3.11 35.86,10.76
+3.3V_VDD_PIC on BOTTOM (solid shape): 43.25,15.55 43.25,15.13 42.47,14.35 42.47,13.92 42.11,13.55 40,13.55 39.86,13.7 39.86,14.39 39.88,14.39 40.31,14.82 41.3,14.82 41.5,15.03 41.5,15.43 41.7,15.64 43.17,15.64
+3.3V_VDD_PIC on BOTTOM (solid shape): 76.23,29.84 76.38,29.84 76.48,29.79 76.51,29.69 76.83,29.26 77.21,29.64 77.24,29.74 77.34,29.78 78.01,29.78 78.53,29.25 78.53,27.93 78.03,27.42 76.5,27.42 76.17,27.75 76.17,27.86 76.07,27.86 75.94,27.98 75.74,27.98 75.49,28.23 75.49,28.69 75.11,29.07 75.11,29.91 75.28,30.09 75.99,30.09
+3.3V_VDD_PIC on IN1 (solid shape): outline of 249 points within 40.54,10.53 48.36,15.76
+3.3V_VDD_PIC on IN1 (solid shape): outline of 1864 points within 61.72,10.15 97.85,27.65
+3.3V_VDD_PIC on IN2 (solid shape): outline of 403 points within 42.72,8.17 63.09,12.22
+3.3V_WLAN on TOP (solid shape): 115.33,113.97 115.33,110.26 115.31,110.24 111.61,110.24 111.13,110.72 111.13,112.87 110.65,113.36 110.65,114.46 110.9,114.72 114.58,114.72
+3.3V_WLAN on TOP (solid shape): 146.4,110.5 146.4,110.07 146.42,110.05 146.42,108.94 146.25,108.78 146.25,107.87 146.23,107.84 145.76,107.84 145.68,107.77 145.68,107.23 145.68,107.22 145.43,107.22 145.42,107.23 145.42,107.75 145.39,107.78 144.92,107.78 144.89,107.75 144.89,107.24 144.88,107.23 144.62,107.23 144.61,107.24 144.61,107.75 144.6,107.76 143.96,107.76 143.9,107.82 143.9,110.42 144.15,110.67 146.24,110.67
+3.3V_WLAN on BOTTOM (solid shape): 112.57,115.24 112.57,113.78 112.21,113.43 111.96,113.43 111.71,113.17 111.71,111.52 111.45,111.27 110.42,111.27 110.3,111.39 110.3,112.86 109.86,113.31 109.86,115.14 110.05,115.33 110.05,115.33 110.08,115.36 112.45,115.36
+3.3V_WLAN on BOTTOM (solid shape): 129.93,115.35 129.93,112.97 129.39,112.43 129.39,111.55 129.36,111.52 128.45,111.52 128.32,111.64 128.32,113.22 128.25,113.29 127.88,113.29 127.46,113.71 127.46,114.31 127.45,114.32 127.45,115.15 127.48,115.17 127.91,115.17 128.22,115.48 129.8,115.48
+3.3V_WLAN on IN3 (solid shape): outline of 1695 points within 110.56,104.79 146.42,114.76
+3.3V_WLAN_PWR on TOP (solid shape): 147.06,107.46 147.06,105.41 147.37,105.1 147.37,104.28 147.25,104.15 146.33,104.15 146.19,104.3 146.19,104.82 145.83,105.18 145.72,105.18 145.66,105.24 145.42,105.24 145.33,105.25 145.24,105.24 145.11,105.24 145.05,105.18 145.03,105.18 144.91,105.07 144.91,105.06 144.86,105 144.86,104.21 144.81,104.16 144.75,104.14 144.22,104.14 143.92,104.44 143.92,105.12 143.95,105.14 144.14,105.45 143.95,105.77 143.92,105.78 143.92,107.59 143.96,107.63 144.47,107.63 144.48,107.62 144.48,107.1 144.49,107.1 145.01,107.1 145.02,107.11 145.02,107.63 145.03,107.64 145.28,107.64 145.29,107.63 145.29,107.1 145.29,107.09 145.78,107.09 145.79,107.1 145.8,107.1 145.8,107.11 145.82,107.13 145.82,107.63 145.83,107.64 146.88,107.64
+3.3V_WWAN on TOP (solid shape): 169.96,118.75 170.45,118.75 170.6,118.6 170.6,116.26 170.45,116.1 167.09,116.1 166.44,115.46 164.16,115.46 164.03,115.58 164.03,116.85 164.16,116.98 165.55,116.98 165.57,116.97 165.59,116.98 166.34,116.98 166.95,117.59 166.95,118.41 167.29,118.76 169.95,118.76
+3.3V_WWAN on TOP (solid shape): 152.22,109.09 152.22,108.99 152.23,108.98 152.23,107.68 151.59,107.68 151.57,107.66 151.53,107.66 151.53,107.11 151.51,107.1 151.27,107.1 151.25,107.11 151.25,107.64 150.73,107.64 150.73,107.12 150.71,107.1 150.47,107.1 150.46,107.1 150.46,107.63 149.83,107.63 149.82,107.63 149.24,107.63 149.2,107.66 149.2,107.7 149.07,107.83 149.07,108.95 149.26,109.15 152.16,109.15
+3.3V_WWAN on BOTTOM (solid shape): 166.2,116.41 166.2,114.84 165.91,114.55 165.91,114.54 164.87,113.5 162.51,113.5 162.28,113.73 162.28,115.95 163.16,116.83 165.78,116.83
+3.3V_WWAN on BOTTOM (solid shape): outline of 192 points within 141.57,113.43 146.16,117.06
+3.3V_WWAN on IN4 (solid shape): outline of 865 points within 142.36,107.74 166.47,116.45
+3.3V_WWAN_PWR on TOP (solid shape): 152.19,107.45 152.19,105.99 152.13,105.88 151.99,105.89 151.44,105.59 151.99,105.29 152.13,105.3 152.19,105.19 152.19,104.07 151.77,103.65 150.97,103.65 150.42,104.19 149.35,104.19 149.3,104.14 148.77,104.14 148.71,104.2 148.71,105.27 148.72,105.28 148.72,105.69 148.96,105.94 148.96,106.58 149.88,107.5 150.32,107.5 150.32,107.05 150.32,106.98 150.34,106.96 150.77,106.96 150.81,106.96 150.82,106.98 150.84,106.98 150.84,107.04 150.87,107.06 150.87,107.51 151.12,107.51 151.12,107.06 151.13,107.05 151.13,107 151.14,106.99 151.14,106.98 151.15,106.97 151.2,106.97 151.21,106.96 151.56,106.96 151.57,106.97 151.61,106.97 151.61,106.98 151.64,106.98 151.64,107.04 151.66,107.06 151.66,107.53 152.12,107.53
+3.3VB_1.8V on TOP (solid shape): 99.41,19.31 99.41,19.12 99.31,19.01 98.49,19.01 98.35,18.87 98.35,18.68 98.34,18.68 98.34,18.45 98.74,18.05 98.96,18.05 99.04,17.97 99.04,15.74 98.92,15.63 97.39,15.63 97.21,15.81 97.21,16.38 97.24,16.4 97.42,16.71 97.24,17.02 97.21,17.04 97.21,19.05 97.52,19.36 99.36,19.36
+3.3VB_2.5V on TOP (solid shape): 156.5,93.01 156.5,92.82 156.36,92.67 155.62,92.67 155.5,92.55 155.5,92.06 155.6,91.96 155.6,91.84 155.65,91.8 156.06,91.8 156.38,91.47 156.38,89.4 156.15,89.17 154.66,89.17 153.34,90.48 153.34,90.81 153.36,90.83 153.78,90.83 153.78,90.83 153.87,90.83 153.89,90.85 153.89,91.31 153.88,91.32 153.88,91.34 153.36,91.34 153.34,91.36 153.34,91.62 153.36,91.64 153.88,91.64 153.88,91.64 153.9,91.66 153.9,92.12 153.87,92.15 153.36,92.15 153.34,92.17 153.34,92.52 153.92,93.11 156.4,93.11
+5V_ALW on TOP (solid shape): 120.42,152.24 120.42,151.13 120.02,150.73 118.48,150.73 118.38,150.83 117.44,150.83 117.29,150.97 117.29,151.93 117.3,151.97 117.31,152.03 117.75,152.47 120.19,152.47
+5V_ALW on BOTTOM (solid shape): 19.5,45.02 19.5,44.34 19.86,43.98 19.86,43 19.78,42.93 19.26,42.93 19.19,43 19.19,45.05 19.25,45.11 19.42,45.11
+5V_ALW on IN2 (solid shape): outline of 325 points within 113.91,147.12 120.93,152.18
+5V_ALW on IN4 (solid shape): outline of 3754 points within 32.23,6.87 52.4,26.76
+5V_ALW on TOP: outline of 150 points within 28.83,5.85 43.69,23.81
+5V_ALW on VCC: 124.47,153.24 112.85,153.24 109.68,150.07 109.68,85.82 105.18,81.31 105.18,80.43 104.09,79.34 104.09,77.89 100.66,74.46 100.66,73.52 99.62,72.48 92.92,65.78 90.76,65.78 87.91,62.93 87.91,62.45 87.92,62.45 87.92,61.23 89,60.15 89,59.46 88.62,59.08 87.94,59.08 85.08,56.23 69.94,56.23 69.04,55.32 46.9,55.32 45.2,53.63 45.2,45.62 46.61,44.21 64.13,44.21 71.53,51.6 85.8,51.6 95.1,60.9 95.1,63.29 111.24,79.43 112.23,79.43 117.1,84.31 117.1,120.96 127.38,131.24 127.38,150.32
+5V_ALW on IN3: 34.14,31.59 32.31,31.59 30.86,30.14 30.86,19.88 32.79,17.95 39.62,17.95 40.49,18.81 40.49,20.06 41.34,20.91 41.34,22.3 40.49,23.15 40.49,24.27 51.59,35.37 51.59,43.45 52.09,43.96 52.09,45.96 51.59,46.47 51.59,49.11 50.82,49.88 46.23,49.88 43.76,47.41 43.76,41.21
+5V_ALW_R on TOP (solid shape): 292.5,56.05 292.5,55.46 292.73,55.23 292.73,54.37 292.58,54.22 291.41,54.22 291.13,54.5 291.13,56.12 291.26,56.25 292.3,56.25
+5V_ALW_R on TOP (solid shape): 290.38,65.94 290.38,65.39 290.68,65.1 290.68,64.13 290.55,64.01 289.38,64.01 289.34,64.05 289.34,66 289.38,66.04 290.28,66.04
+5V_ALW_R on TOP (solid shape): 367.2,37.03 367.2,37.03 367.34,36.88 367.34,36.42 366.98,36.06 366.98,35.32 366.85,35.19 366.32,35.19 366.14,35.37 364.04,35.37 363.59,35.82 363.59,36.5 364.36,37.28 366.94,37.28
+5V_ALW_R on TOP (solid shape): 380.79,39.33 380.79,37.78 381.14,37.44 381.14,36.81 381.11,36.79 380.01,36.79 379.97,36.83 379.95,36.83 379.26,37.52 378.94,37.52 378.88,37.56 378.82,37.58 378.8,37.59 378.65,37.74 378.65,39.21 379.02,39.58 380.54,39.58
