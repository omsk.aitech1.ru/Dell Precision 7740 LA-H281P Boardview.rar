# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_BG1: length 77.7
  TOP w0.076: UC1.AU2 231.74,40.63 231.46,40.91 230.93,40.91 230.54,41.3 228.35,41.3 225.13,38.07 225.13,36.2 v2(225.09,36.17)
  TOP w0.211: JDIMM2.113 181.16,43.73 180.37,42.95 179.35,42.95 177.99,41.6 176.67,41.6 v2(176.13,42.14)
  IN1 w0.188: v2(225.09,36.17) 222.91,36.17 222.5,35.76 220.78,35.76 219.37,34.36 217.95,34.36 217.08,33.49 212.62,33.49 211.43,34.68 203.73,34.68 200.74,37.67 188.56,37.67 186.55,39.68 182.89,39.68 182.7,39.87 180.82,39.87 180.18,40.51 178.71,40.51 177.55,41.67 176.56,41.67 176.13,42.09 v2(176.13,42.14)
  BOTTOM w0.211: JDIMM1.113 174.42,43.73 174.89,43.26 175.97,43.26 176.18,43.05 176.18,42.77 175.97,42.55 174.95,42.55 174.75,42.36 174.75,41.92 175.02,41.65 175.64,41.65 v2(176.13,42.14)
DDR_A_CB0: length 77.3
  TOP w0.076: v2(226.58,35.63) 227.46,35.63 228.35,36.52 229.6,36.52 230.97,37.89 231.17,37.89 231.23,37.83 231.23,37.83 231.25,37.82 231.45,37.82 231.75,38.11 UC1.BA2
  TOP w0.152: v2(178.59,36.31) 178.72,36.31 179.31,36.91 180.1,36.91 180.44,36.56 180.66,36.56 180.81,36.71 180.81,36.96 180.34,37.43 180.34,37.64 180.48,37.79 180.64,37.79 181.19,37.23 JDIMM2.87
  IN2 w0.114: v2(178.59,36.31) 179.26,35.65 180.43,35.65 183.57,32.51 186.26,32.51 188.98,29.78 193.27,29.78 193.89,29.16 198.21,29.16 198.63,29.58 205.28,29.58 205.42,29.72 205.42,29.98 205.28,30.12 203.14,30.12 203,30.26 203,30.53 203.14,30.67 219.92,30.67 222.15,32.9 225.11,32.9 226.58,34.36 v2(226.58,35.63)
  BOTTOM w0.152: JDIMM1.87 174.79,37.23 176.11,35.92 178.2,35.92 v2(178.59,36.31)
DDR_A_CB1: length 75.8
  TOP w0.076: v2(226.98,36.07) 227.61,36.07 228.28,36.75 229.53,36.75 230.89,38.11 UC1.BA1
  TOP w0.152: v2(177.32,36.34) 177.32,35.82 177.13,35.62 176.48,35.62 174.62,37.48 JDIMM2.88
  IN2 w0.114: v2(226.98,36.07) 226.98,34.09 225.41,32.52 222.29,32.52 220.03,30.25 206.69,30.25 205.51,29.07 198.8,29.07 198.27,28.53 189.38,28.53 186.66,31.25 183.34,31.25 182.64,31.96 182.64,32.74 180.52,34.85 180.32,34.85 180.13,34.66 180.13,34.47 180.86,33.75 180.86,33.55 180.67,33.36 180.47,33.36 178.94,34.89 178.78,34.89 v2(177.32,36.34)
  BOTTOM w0.152: v2(177.32,36.34) 177.83,36.84 179.6,36.84 180.24,37.48 JDIMM1.88
DDR_A_CB2: length 79
  TOP w0.076: UC1.AY4 233.3,38.97 v2(232.97,39.29)
  TOP w0.152: JDIMM2.105 181.12,41.73 180.71,41.33 180.71,40.94 180.56,40.79 180.34,40.79 180.19,40.94 180.19,41.4 180.06,41.53 179.73,41.53 179.6,41.41 179.6,40.93 179.45,40.78 179.24,40.78 178.95,41.06 178.74,41.06 178.47,40.79 178.47,40.58 v2(179.01,40.03)
  IN2 w0.076: 225.43,37.96 226.03,37.96 226.25,38.17 227.24,38.17 227.43,37.98 231.65,37.98 v2(232.97,39.29)
  IN2 w0.114: v2(179.01,40.03) 179.76,40.77 180.43,40.77 180.57,40.63 180.57,40.11 180.71,39.97 180.98,39.97 181.11,40.11 181.11,40.63 181.25,40.77 181.52,40.77 181.66,40.63 181.66,40.11 181.8,39.97 182.07,39.97 182.21,40.11 182.21,40.63 182.35,40.77 184,40.77 184.55,40.22 184.55,40.02 184.03,39.5 184.03,39.3 184.22,39.11 184.42,39.11 184.75,39.45 186.07,39.45 187.5,38.02 187.5,35.6 189.22,33.88 192.73,33.88 193.38,33.24 218.52,33.24 223.24,37.96 225.43,37.96
  BOTTOM w0.152: JDIMM1.105 174.46,41.73 176.6,39.59 178.58,39.59 v2(179.01,40.03)
DDR_A_CB3: length 80.3
  TOP w0.076: v2(233.62,39.29) 233.95,38.97 UC1.AY5
  TOP w0.152: JDIMM2.101 180.96,40.73 179.82,39.6 177.44,39.6 177.15,39.31 176.82,39.31 v2(175.85,38.34)
  IN2 w0.076: 225.43,37.51 225.87,37.51 226.34,37.99 227.07,37.99 227.41,37.65 231.97,37.65 v2(233.62,39.29)
  IN2 w0.114: 225.43,37.51 223.55,37.51 218.84,32.81 193.13,32.81 192.57,33.37 188.94,33.37 186.95,35.36 186.95,37.16 186.2,37.91 184.82,37.91 183.16,39.56 176.11,39.56 175.85,39.3 v2(175.85,38.34)
  BOTTOM w0.152: v2(175.85,38.34) 176.24,38.73 177.55,38.73 177.7,38.89 177.7,39.14 177.55,39.29 176.01,39.29 174.56,40.73 JDIMM1.101
DDR_A_CB4: length 79.4
  TOP w0.076: v2(225.35,34.35) 225.4,34.3 226.94,34.3 228.75,36.11 229.82,36.11 231.23,37.52 231.73,37.52 231.81,37.59 233.42,37.59 UC1.BA5
  TOP w0.152: v2(179.14,38.32) 178.71,37.89 175.43,37.89 174.84,38.48 JDIMM2.92
  IN2 w0.114: v2(225.35,34.35) 225.35,33.8 224.78,33.23 221.91,33.23 219.73,31.04 200.51,31.04 200.37,30.9 200.37,30.63 200.51,30.49 202.46,30.49 202.6,30.35 202.6,30.09 202.46,29.95 198.48,29.95 198.06,29.53 194.04,29.53 193.35,30.22 189.07,30.22 186.28,33.01 183.61,33.01 180.54,36.08 180.54,36.91 v2(179.14,38.32)
  BOTTOM w0.152: v2(179.14,38.32) 178.85,38.6 178.85,39.29 178.97,39.4 179.27,39.4 179.41,39.26 179.41,39.05 179.56,38.9 179.84,38.9 179.99,39.06 179.99,39.44 180.15,39.59 180.41,39.59 180.55,39.45 180.55,38.67 180.74,38.48 JDIMM1.92
DDR_A_CB5: length 79.8
  TOP w0.076: UC1.BA4 233,37.82 231.76,37.82 231.61,37.67 231.1,37.67 229.76,36.32 228.53,36.32 v1(228.01,35.8) 226.99,34.78 v2(225.77,34.78)
  TOP w0.152: v2(179.88,38.35) 179.4,37.87 179.1,37.87 178.73,37.5 178.21,37.5 178.09,37.38 178.09,37.08 178.24,36.93 178.92,36.93 179.34,37.35 179.48,37.35 180.51,38.37 180.85,38.37 180.99,38.23 JDIMM2.91
  IN2 w0.114: v2(225.77,34.78) 224.59,34.78 223.69,33.88 221.84,33.88 219.43,31.47 200.42,31.47 199.58,30.63 198.57,30.63 197.84,29.9 194.25,29.9 194.11,30.04 194.11,30.3 194.25,30.44 196.23,30.44 196.37,30.58 196.37,30.85 196.23,30.99 193.56,30.99 193.15,30.58 189.22,30.58 186.33,33.48 185.13,33.48 184.02,34.58 183.15,34.58 180.98,36.76 180.98,37.25 v2(179.88,38.35)
  BOTTOM w0.152: v2(179.88,38.35) 178.8,37.26 175.47,37.26 174.5,38.23 JDIMM1.91
DDR_A_CB6: length 76.7
  TOP w0.076: UC1.AY1 231.26,38.94 231.26,39.06 v2(231.02,39.29)
  TOP w0.152: v2(176.43,40.37) 176.34,40.28 176.34,40.16 176.19,40.01 175.97,40.01 175.77,40.21 175.77,40.36 175.95,40.53 175.95,40.73 175.77,40.91 175.56,40.91 175.22,40.57 174.98,40.57 174.82,40.73 174.82,40.95 175.3,41.43 175.3,41.63 175.12,41.81 174.9,41.81 174.57,41.48 JDIMM2.104
  IN2 w0.076: v2(231.02,39.29) 230.3,38.58 227.6,38.58 227.34,38.84 225.56,38.84
  IN2 w0.114: v2(176.43,40.37) 176.66,40.6 177.7,40.6 178.33,41.24 178.33,41.44 179.66,42.77 184.2,42.77 184.79,42.18 184.79,41.55 185.84,40.5 186.41,40.5 188.53,38.38 188.53,37.26 189.1,36.69 189.1,36.25 188.66,35.82 188.66,35.62 188.85,35.43 189.05,35.43 189.45,35.82 189.64,35.82 190.11,35.36 192.55,35.36 193.92,33.98 217.96,33.98 222.81,38.84 225.56,38.84
  BOTTOM w0.152: v2(176.43,40.37) 176.59,40.53 177.58,40.53 178.53,41.48 JDIMM1.104
DDR_A_CB7: length 76
  TOP w0.076: UC1.AY2 231.97,38.88 231.97,39 v2(231.67,39.29)
  TOP w0.152: JDIMM2.100 174.44,40.48 175.28,39.65 177.12,39.65 177.49,40.02 v2(177.81,40.02)
  IN2 w0.076: 225.43,38.41 227.46,38.41 227.53,38.34 230.72,38.34 v2(231.67,39.29)
  IN2 w0.114: 225.43,38.41 223.06,38.41 218.27,33.62 193.67,33.62 193.04,34.25 189.51,34.25 188.09,35.67 188.09,38.14 186.27,39.96 185.56,39.96 184.14,41.38 183.54,41.38 182.83,42.09 182.83,42.09 182.69,42.23 181.17,42.23 181.03,42.09 181.03,41.83 181.17,41.69 182.42,41.69 182.56,41.55 182.56,41.28 182.42,41.14 179.69,41.14 179.59,41.25 179.59,41.42 179.45,41.56 179.18,41.56 179.04,41.42 179.04,41.26 v2(177.81,40.02)
  BOTTOM w0.152: JDIMM1.100 180.72,40.48 180.26,40.94 178.73,40.94 v2(177.81,40.02)
DDR_A_CKE0: length 72.5
  TOP w0.076: UC1.AT1 231.35,41.48 v2(231.02,41.81)
  TOP w0.168: v2(176.17,41.08) 176.31,41.08 176.76,40.63 177.65,40.63 179.58,42.56 180.68,42.56 180.86,42.73 JDIMM2.109
  IN1 w0.076: v2(231.02,41.81) 231.02,41.08 228.26,38.32 228.11,38.32 225,35.2 223.7,35.2
  IN1 w0.152: 223.7,35.2 223.49,35.2 222.86,34.58 221.15,34.58 219.72,33.15 218.5,33.15 217.69,32.34 209.25,32.34 209.1,32.49 209.1,32.75 209.25,32.9 209.58,32.9 209.74,33.06 209.74,33.32 209.6,33.46 203.34,33.46 200.95,35.85 188.7,35.85 186.36,38.19 182.34,38.19 182.09,38.45 180.34,38.45 179.68,39.11 177.42,39.11 177.19,39.33 176.88,39.33 175.99,40.22 175.99,40.91 v2(176.17,41.08)
DDR_A_CKE1: length 69.8
  TOP w0.076: v2(231.67,41.81) 232,41.48 UC1.AT2
  TOP w0.168: v2(172.24,42.32) 172.91,42.98 JDIMM2.110
  IN1 w0.076: v2(231.67,41.81) 231.31,41.12 228.22,38.03 228.09,38.03 225.06,35 224.24,34.6 223.7,34.3 222.7,33.98
  IN1 w0.152: v2(172.24,42.32) 176.34,38.98 177.19,38.75 177.4,38.53 177.49,38.17 177.71,37.95 178.31,37.78 186.13,37.78 188.51,35.4 200.76,35.4 203.15,33 207.94,33 209.15,31.8 217.82,31.8 220.2,32.86 221.32,33.98 222.7,33.98
DDR_A_CKE2: length 74.2
  TOP w0.168: UC1.AT3 v2(232.32,41.81)
  IN1 w0.076: v2(232.32,41.81) 231.51,40.99 231.43,40.99 228.24,37.81 228.18,37.81 224.85,34.48 224.62,34.48 223.37,33.23
  IN1 w0.152: 223.37,33.23 221.4,33.23 219.51,31.34 208.96,31.34 207.75,32.55 207.3,32.55 207.15,32.39 207.15,31.98 207,31.83 206.74,31.83 206.59,31.98 206.59,32.39 206.44,32.55 202.96,32.55 201.17,34.34 188.79,34.34 186.25,36.88 183.07,36.88 182.65,37.3 175.52,37.3 171.48,41.34 v2(171.48,42.23)
  BOTTOM w0.168: JDIMM1.109 171.98,42.73 v2(171.48,42.23)
DDR_A_CKE3: length 72.3
  TOP w0.076: v2(230.4,41.78) 231.11,41.08 231.56,41.08 231.61,41.03 233.66,41.03 233.95,41.32 UC1.AT5
  IN1 w0.076: 223.31,35.54 224.11,35.54 224.23,35.42 224.98,35.42 228.11,38.55 228.25,38.55 230.4,40.7 v2(230.4,41.78)
  IN1 w0.152: v2(177.5,41.14) 177.1,40.74 177.1,40.54 177.36,40.28 177.36,39.83 177.58,39.61 180.11,39.61 180.59,39.13 182.4,39.13 182.54,38.98 186.43,38.98 188.62,36.79 193.87,36.79 194.35,36.31 201.14,36.31 203.45,34 210.04,34 210.19,33.85 210.19,33.42 210.34,33.27 210.6,33.27 210.75,33.42 210.75,33.85 210.9,34 211.15,34 212.33,32.81 217.42,32.81 218.29,33.68 219.52,33.68 221,35.15 222.71,35.15 223.1,35.54 223.31,35.54
  BOTTOM w0.168: JDIMM1.110 180.99,42.98 180.61,42.61 178.97,42.61 v2(177.5,41.14)
DDR_A_CLK0: length 76.9
  TOP w0.076: 230.32,49.1 230.34,49.1 230.38,49.15 230.94,49.15 231.02,49.23 231.46,49.23 231.7,48.98 231.7,48.83 231.65,48.78 231.47,48.78 UC1.AG1
  TOP w0.109: JDIMM2.137 180.92,49.73 180.75,49.9 180.75,50.12 180.17,50.7 178.97,50.7 178.82,50.55 178.82,50.31 178.94,50.2 v2(179.1,50.2) ; 230.32,49.1 227.75,49.1 226.89,48.24 225.91,48.24 224.06,46.39 224.06,45.22 224.29,44.99 224.29,44.93 v2(224.45,44.77)
  IN1 w0.102: v2(224.45,44.77) 224.24,44.97 224.24,45.19 224.05,45.38 221.26,45.38 221.01,45.62 218.41,45.62 217.98,46.06 210.88,46.06 209.34,47.6 209.03,47.6 208.69,47.26 208.69,46.95 209.19,46.45 209.19,46.31 208.95,46.06 208.8,46.06 204.51,50.35 204.2,50.35 203.87,50.02 203.87,49.7 206.13,47.44 206.13,47.3 205.91,47.08 205.77,47.08 203.24,49.61 203.24,50.07 203.03,50.28 201.77,50.28 201.67,50.38 201.67,50.58 201.45,50.8 200.98,50.8 200.75,50.58 200.75,50.38 200.65,50.28 200.2,50.28 200.1,50.38 200.1,50.47 199.88,50.69 199.41,50.69 199.19,50.47 199.19,50.38 199.08,50.28 198.78,50.28 198.68,50.38 198.68,50.52 198.47,50.73 197.99,50.73 197.76,50.5 197.76,50.38 197.66,50.28 194.67,50.28 194.09,50.86 188.69,50.86 188.36,50.54 188.36,50.22 188.22,50.08 180.25,50.08 179.87,49.69 178.96,49.69 178.85,49.81 178.85,49.95 v2(179.1,50.2)
DDR_A_CLK1: length 75.5
  TOP w0.076: UC1.AK2 231.51,46.88 230.02,46.88 229.98,46.92 229.96,46.92
  TOP w0.109: 229.96,46.92 227.14,46.92 225.72,45.5 v2(225.72,44.77) ; v2(176.27,51.44) 176.59,51.44 176.66,51.51 176.66,51.75 176.53,51.88 175.45,51.88 175.14,51.57 175.14,50.75 174.38,49.98 JDIMM2.138
  IN1 w0.102: v2(225.72,44.77) 226.02,45.07 226.02,45.38 225.71,45.7 221.5,45.7 221.17,46.03 218.75,46.03 218.22,46.56 211.12,46.56 209.52,48.16 207.49,48.16 204.71,50.93 202.18,50.93 201.19,51.92 200.89,51.92 200.78,51.82 200.78,51.35 200.58,51.15 200.11,51.15 199.87,51.39 199.87,51.82 199.77,51.92 197.57,51.92 197.47,51.82 197.47,51.04 197.25,50.81 196.78,50.81 196.56,51.04 196.56,51.82 196.46,51.92 196.15,51.92 196.05,51.82 196.05,51.03 195.83,50.8 195.36,50.8 195.14,51.03 195.14,51.82 195.03,51.92 194.73,51.92 194.63,51.82 194.63,51.44 194.41,51.22 193.93,51.22 193.71,51.44 193.71,51.82 193.61,51.92 193.38,51.92 192.86,51.4 188.44,51.4 187.65,50.61 185.32,50.61 185.11,50.82 184.9,50.82 184.64,51.09 184.43,51.09 183.94,50.6 180.07,50.6 179.84,50.82 179.57,50.82 179.44,50.7 177.58,50.7 177.36,50.47 177.36,49.87 177.11,49.63 176.65,49.63 176.39,49.89 176.39,50.88 176.54,51.03 176.54,51.17 v2(176.27,51.44)
DDR_A_CLK2: length 75.2
  TOP w0.076: UC1.AL3 232.58,45.72 232.5,45.72 232.43,45.65 232.43,45.47 232.16,45.2 230.04,45.2 229.89,45.05 229.89,44.64 229.96,44.56 230.06,44.56 v2(230.26,44.76)
  IN1 w0.076: 229.14,44.15 229.15,44.15 229.18,44.17 229.84,44.17 230.05,44.38 230.05,44.55 v2(230.26,44.76)
  IN1 w0.102: v2(171.25,50) 171.26,50 171.52,49.73 171.52,49.58 171.75,49.35 172.77,49.35 172.99,49.57 172.99,52.65 173.1,52.76 173.42,52.76 173.5,52.68 173.5,50.26 173.79,49.97 175.36,49.97 176.33,48.99 180.89,48.99 181.19,49.29 188.62,49.29 188.69,49.37 202.16,49.37 205.36,46.16 207.36,46.16 208.38,45.14 217.58,45.14 218.06,44.66 220.69,44.66 221.2,44.15 229.14,44.15
  BOTTOM w0.109: v2(171.25,50) 171.44,49.81 171.44,49.63 171.72,49.35 172.37,49.35 172.75,49.73 JDIMM1.137
DDR_A_CLK3: length 74.1
  TOP w0.076: UC1.AL2 231.86,45.79 231.86,45.9 231.67,46.09 229.98,46.09 229.94,46.14 229.92,46.14
  TOP w0.109: 229.92,46.14 228.43,46.14 227.62,45.33 v2(227.62,44.77)
  IN1 w0.102: v2(227.62,44.77) 227.78,44.77 227.91,44.9 227.91,44.95 228,45.04 228,45.51 227.24,46.27 222.13,46.27 221.63,46.76 219.01,46.76 218.5,47.27 211.42,47.27 207.07,51.62 206.93,51.62 206.71,51.41 206.71,51.27 208.46,49.52 208.46,49.21 208.12,48.87 207.81,48.87 205,51.68 202.45,51.68 201.47,52.66 192.94,52.66 192.84,52.56 192.84,52.24 192.62,52.02 192.15,52.02 191.93,52.24 191.93,52.56 191.82,52.66 188.7,52.66 187.4,51.35 185.59,51.35 185.38,51.56 185.2,51.56 184.85,51.91 184.2,51.91 183.6,51.31 183.11,51.31 182.88,51.54 182.52,51.54 182.29,51.31 181.9,51.31 181.68,51.53 181.68,51.82 181.58,51.92 181.28,51.92 181.18,51.82 181.18,51.53 180.96,51.31 180.54,51.31 179.92,51.93 178.88,51.93 178.69,51.73 178.69,51.5 178.84,51.35 179.01,51.35 v2(179.1,51.44)
  BOTTOM w0.109: JDIMM1.138 181.14,49.98 180.26,50.87 180.26,51.59 179.89,51.96 178.87,51.96 178.68,51.77 178.68,51.53 178.77,51.44 v2(179.1,51.44)
DDR_A_CLK#0: length 76.9
  TOP w0.076: UC1.AG2 231.52,49.38 230.96,49.38 230.88,49.3 230.38,49.3 230.34,49.34 230.32,49.34
  TOP w0.109: v2(178.47,50.2) 178.58,50.32 178.58,50.65 178.87,50.94 180.27,50.94 180.98,50.23 JDIMM2.139 ; v2(223.81,44.77) 223.81,46.49 225.81,48.48 226.79,48.48 227.65,49.34 230.32,49.34
  IN1 w0.102: v2(178.47,50.2) 178.65,50.02 178.65,49.72 178.88,49.49 179.95,49.49 180.34,49.88 188.31,49.88 188.56,50.14 188.56,50.45 188.77,50.66 194,50.66 194.58,50.08 197.75,50.08 197.97,50.3 197.97,50.41 198.08,50.53 198.38,50.53 198.47,50.43 198.47,50.3 198.69,50.08 199.17,50.08 199.39,50.3 199.39,50.39 199.49,50.49 199.79,50.49 199.9,50.39 199.9,50.3 200.12,50.08 200.74,50.08 200.96,50.3 200.96,50.49 201.06,50.6 201.36,50.6 201.47,50.49 201.47,50.3 201.69,50.08 202.94,50.08 203.04,49.98 203.04,49.52 205.68,46.88 206,46.88 206.33,47.21 206.33,47.53 204.07,49.79 204.07,49.93 204.29,50.15 204.43,50.15 208.72,45.86 209.03,45.86 209.39,46.22 209.39,46.53 208.89,47.03 208.89,47.18 209.11,47.39 209.25,47.39 210.8,45.85 217.89,45.85 218.32,45.42 220.93,45.42 221.17,45.18 223.97,45.18 224.04,45.1 224.04,44.99 v2(223.81,44.77)
DDR_A_CLK#1: length 75.5
  TOP w0.076: UC1.AK1 231.48,46.26 231.67,46.26 231.72,46.3 231.72,46.46 231.45,46.72 230.02,46.72 229.98,46.68 229.96,46.68
  TOP w0.109: JDIMM2.140 174.54,50.48 174.9,50.85 174.9,51.67 175.35,52.12 176.63,52.12 176.9,51.85 176.9,51.56 v2(177.03,51.43) ; v2(226.35,44.77) 226.17,44.95 226.17,45 225.96,45.21 225.96,45.4 227.24,46.68 229.96,46.68
  IN1 w0.102: v2(226.35,44.77) 226.23,44.89 226.23,45.46 225.79,45.9 221.59,45.9 221.25,46.23 218.84,46.23 218.3,46.77 211.2,46.77 209.61,48.36 207.57,48.36 204.8,51.14 202.26,51.14 201.27,52.13 200.8,52.13 200.58,51.91 200.58,51.43 200.5,51.35 200.2,51.35 200.07,51.47 200.07,51.91 199.85,52.13 197.49,52.13 197.27,51.91 197.27,51.12 197.17,51.02 196.86,51.02 196.76,51.12 196.76,51.91 196.54,52.13 196.07,52.13 195.85,51.91 195.85,51.11 195.75,51.01 195.44,51.01 195.34,51.11 195.34,51.91 195.12,52.13 194.65,52.13 194.43,51.91 194.43,51.52 194.32,51.42 194.02,51.42 193.92,51.52 193.92,51.91 193.7,52.13 193.29,52.13 192.77,51.61 188.36,51.61 187.57,50.81 185.41,50.81 185.19,51.03 184.99,51.03 184.72,51.3 184.35,51.3 183.85,50.8 180.15,50.8 179.93,51.03 179.48,51.03 179.36,50.9 177.5,50.9 177.16,50.56 177.16,49.96 177.03,49.83 176.74,49.83 176.59,49.98 176.59,50.79 176.74,50.95 176.74,51.33 176.85,51.43 v2(177.03,51.43)
DDR_A_CLK#2: length 75.3
  TOP w0.076: v2(229.53,44.77) 229.73,44.97 229.73,45.11 229.97,45.35 232.1,45.35 232.28,45.53 232.28,45.71 UC1.AK3
  IN1 w0.076: 229.14,44.35 229.17,44.33 229.77,44.33 229.89,44.45 229.89,44.82 229.82,44.89 229.66,44.89 v2(229.53,44.77)
  IN1 w0.102: 229.14,44.35 221.28,44.35 220.77,44.86 218.15,44.86 217.66,45.34 208.47,45.34 207.45,46.36 205.45,46.36 202.24,49.57 188.61,49.57 188.54,49.5 181.1,49.5 180.8,49.2 176.42,49.2 175.44,50.17 173.87,50.17 173.7,50.34 173.7,52.76 173.51,52.96 173.02,52.96 172.79,52.73 172.79,49.66 172.69,49.56 171.83,49.56 171.72,49.66 171.72,49.9 171.81,49.99 v2(172.06,49.99)
  BOTTOM w0.109: JDIMM1.139 172.79,50.23 172.65,50.1 172.65,49.98 172.27,49.59 171.82,49.59 171.68,49.73 171.68,49.87 171.8,49.99 v2(172.06,49.99)
DDR_A_CLK#3: length 74.2
  TOP w0.076: UC1.AL1 231.48,45.52 231.63,45.52 231.71,45.61 231.71,45.83 231.6,45.94 229.98,45.94 229.94,45.89 229.92,45.89
  TOP w0.109: 229.92,45.89 228.53,45.89 227.87,45.23 227.87,45.07 227.98,44.96 228.07,44.96 v2(228.26,44.77)
  IN1 w0.102: v2(228.26,44.77) 228.2,44.82 228.2,45.6 227.33,46.47 222.21,46.47 221.71,46.97 219.1,46.97 218.58,47.48 211.5,47.48 207.15,51.83 206.84,51.83 206.51,51.49 206.51,51.18 208.25,49.43 208.25,49.29 208.04,49.07 207.89,49.07 205.09,51.88 202.53,51.88 201.55,52.86 192.86,52.86 192.64,52.64 192.64,52.32 192.54,52.22 192.23,52.22 192.13,52.32 192.13,52.64 191.91,52.86 188.62,52.86 187.31,51.55 185.67,51.55 185.46,51.76 185.28,51.76 184.93,52.11 184.12,52.11 183.52,51.51 183.19,51.51 182.96,51.74 182.43,51.74 182.2,51.51 181.99,51.51 181.89,51.61 181.89,51.9 181.67,52.12 181.19,52.12 180.97,51.9 180.97,51.61 180.87,51.51 180.62,51.51 180,52.13 178.8,52.13 178.48,51.82 178.48,51.64 v2(178.28,51.44)
  BOTTOM w0.109: JDIMM1.140 180.99,50.48 180.5,50.97 180.5,51.69 179.99,52.2 178.77,52.2 178.44,51.87 178.44,51.59 v2(178.28,51.44)
DDR_A_CS#0: length 72.1
  TOP w0.076: UC1.AD5 233.95,51.54 v2(233.62,51.87)
  TOP w0.168: v2(178.72,55.44) 179.43,54.73 JDIMM2.149
  IN1 w0.076: 221.53,51.68 222.07,51.68 223.72,50.03 223.72,49.69 223.95,49.47 223.95,48.96 224.25,48.66 228.52,48.66 228.98,48.2 232.97,48.2 233.4,48.63 234.82,48.63 235.25,49.06 235.25,49.52 235.02,49.75 234.8,49.75 233.62,50.92 v2(233.62,51.87)
  IN1 w0.152: 221.53,51.68 218.59,51.68 218,52.27 215.51,52.27 213.35,54.42 211.77,54.42 209.3,56.9 201.84,56.9 201.36,57.38 200.38,57.38 199.04,58.71 194.03,58.71 193.94,58.62 189.12,58.62 187.15,56.66 183.53,56.66 182.92,56.04 179.38,56.04 179.01,56.41 178.46,56.41 178.25,56.2 178.25,55.91 v2(178.72,55.44)
DDR_A_CS#1: length 75.1
  TOP w0.076: UC1.AE2 231.76,50.68 231.47,50.39 231.22,50.39 231.06,50.56 230.16,50.56 229.99,50.39 229.24,50.39 v2(228.68,49.83)
  TOP w0.168: JDIMM2.157 181.01,56.73 179.06,58.68 v2(179.06,59.41)
  IN1 w0.076: v2(228.68,49.83) 228.04,50.46 227.86,50.46 227.4,50.92 226.21,50.92 226.01,51.12 225.02,51.12 219.92,56.22 219.91,56.22
  IN1 w0.152: 219.91,56.22 218.07,56.22 215.33,58.95 214.45,58.95 213.84,59.56 210.83,62.58 201.66,62.58 201.51,62.73 201.51,62.98 201.66,63.14 206.09,63.14 206.24,63.29 206.24,63.54 206.09,63.7 188.49,63.7 186.82,62.02 183.21,62.02 181.37,60.18 181.08,60.18 180.78,59.88 179.53,59.88 v2(179.06,59.41)
DDR_A_CS#2: length 76.4
  TOP w0.076: UC1.AD2 231.59,51.83 226.1,51.83 225.3,51.02 224.51,51.02 v2(223.31,49.82)
  IN1 w0.152: v2(180.02,55.45) 180.15,55.59 183.11,55.59 183.67,56.15 187.29,56.15 189.3,58.17 194.13,58.17 194.22,58.26 198.75,58.26 198.9,58.1 198.9,57.85 198.75,57.7 196.25,57.7 196.1,57.55 196.1,57.29 196.25,57.14 199.86,57.14 200.56,56.44 209.11,56.44 214.62,50.93 214.83,50.93 215.01,51.11 215.01,51.33 213.26,53.08 213.26,53.29 213.44,53.47 213.66,53.47 215.32,51.81 217.82,51.81 218.63,51 221.63,51 222.8,49.82 v2(223.31,49.82)
  BOTTOM w0.168: v2(180.02,55.45) 179.62,55.85 175.83,55.85 174.71,54.73 JDIMM1.149
DDR_A_CS#3: length 76.5
  TOP w0.076: UC1.AE5 233.73,50.68 233.2,50.16 231.91,50.16 231.81,50.07 231.02,50.07 230.91,50.18 230.64,50.18 230.26,49.79 v2(230.16,49.79)
  IN1 w0.076: v2(230.16,49.79) 229.72,49.35 229.34,49.35 229.06,49.64 229.06,50.22 228.58,50.7 227.98,50.7 227.56,51.11 226.43,51.11 226.22,51.32 225.19,51.32 219.84,56.67 219.68,56.67
  IN1 w0.152: v2(172.21,56.77) 175.5,60.06 179.09,60.06 179.4,60.37 180.61,60.37 180.89,60.64 181.19,60.64 183.76,63.21 187.32,63.21 188.67,64.56 192.94,64.56 193.34,64.15 207.8,64.15 207.95,64 207.95,63.75 207.8,63.59 206.85,63.59 206.7,63.44 206.7,63.19 206.85,63.03 211.02,63.03 214.64,59.41 215.52,59.41 218.26,56.67 219.68,56.67
  BOTTOM w0.168: v2(172.21,56.77) 172.24,56.73 JDIMM1.157
DDR_A_D0: length 94.8
  TOP w0.076: UC1.BR6 234.54,27.68 234.47,27.61 234.47,27.02 234.62,26.86 234.62,26.51 v2(234.16,26.05)
  TOP w0.152: JDIMM2.8 174.63,17.48 175.43,16.69 175.74,16.69 176.43,16 177.14,16 177.61,16.47 179.29,16.47 v2(179.38,16.39)
  IN1 w0.14: v2(234.16,26.05) 234.16,24.66 236.39,22.42 236.39,14.58 232.51,10.7 223.91,10.7 222.93,11.68 219.91,11.68 218.82,12.78 217.07,12.78 216.93,12.64 216.93,12.37 217.07,12.23 217.93,12.23 218.07,12.09 218.07,11.82 217.93,11.68 199.88,11.68 197.53,9.33 185.79,9.33 179.38,15.74 v2(179.38,16.39)
  BOTTOM w0.152: JDIMM1.7 174.37,17.23 175.37,16.23 175.45,16.23 176.12,15.56 177.02,15.56 177.94,16.47 179.29,16.47 v2(179.38,16.39)
DDR_A_D1: length 91.1
  TOP w0.076: UC1.BT6 235.01,27.25 235.01,26.11 234.15,25.24 233.99,25.24 233.4,24.65 v2(232.83,24.65)
  TOP w0.152: v2(178.85,15.92) 179.28,15.5 180.16,15.5 180.9,16.23 JDIMM2.3
  IN1 w0.14: v2(178.85,15.92) 178.85,16.7 179.09,16.94 180.38,16.94 180.68,16.65 180.68,16.07 186.65,10.09 197.21,10.09 199.54,12.42 211.38,12.42 211.52,12.56 211.52,12.83 211.38,12.97 209.46,12.97 209.32,13.11 209.32,13.46 209.45,13.59 219.06,13.59 220.23,12.42 223.41,12.42 224.23,11.6 232.26,11.6 235.54,14.88 235.54,21.94 v2(232.83,24.65)
  BOTTOM w0.152: v2(178.85,15.92) 179.23,15.55 180.2,15.55 181.14,16.48 JDIMM1.4
DDR_A_D2: length 88.2
  TOP w0.076: v2(232.01,26.26) 232.55,26.26 232.86,26.58 232.86,26.9 232.97,27.01 232.97,27.77 233.05,27.84 233.05,28.4 UC1.BP3
  TOP w0.152: JDIMM2.21 180.82,20.73 v2(180.63,20.54)
  IN1 w0.076: v2(232.01,26.26) 232,26.27 231.44,26.27 229.44,24.27 229.44,23.68 229.65,23.47
  IN1 w0.14: 229.65,23.47 232.35,20.77 232.35,17.26 229.7,14.62 225.42,14.62 224.84,15.2 221.41,15.2 221.27,15.34 221.27,15.61 221.41,15.75 224.34,15.75 224.48,15.88 224.48,16.15 224.34,16.29 199.61,16.29 198.98,15.66 198.63,15.66 195.91,12.94 195.71,12.94 195.52,13.13 195.52,13.33 197.19,15 197.19,15.19 197,15.38 196.8,15.38 194.13,12.71 189.89,12.71 186.08,16.52 186.08,16.82 184.21,18.69 182.48,18.69 v2(180.63,20.54)
  BOTTOM w0.152: v2(180.63,20.54) 180.76,20.41 180.92,20.41 181,20.48 JDIMM1.20
DDR_A_D3: length 92.5
  TOP w0.076: UC1.BR3 232.26,27.5 232.26,27.09 231.56,26.39 v2(231.56,25.81)
  TOP w0.152: v2(178.78,18.5) 178.78,18.79 177.81,19.76 175.34,19.76 174.62,20.48 JDIMM2.20
  IN1 w0.14: v2(231.56,25.81) 231.56,23.53 233.83,21.26 233.83,16.57 230.41,13.16 224.98,13.16 224.07,14.06 220.84,14.06 219.77,15.14 200.02,15.14 196.49,11.61 189.14,11.61 186.65,14.09 186.45,14.09 186.16,13.8 186.16,13.6 187.76,11.99 187.76,11.8 187.58,11.61 187.38,11.61 182.17,16.81 182.17,17.36 181.03,18.5 v2(178.78,18.5)
  BOTTOM w0.152: JDIMM1.21 175.33,20.73 176.02,20.04 177.36,20.04 178.78,18.62 v2(178.78,18.5)
DDR_A_D4: length 90.5
  TOP w0.076: v2(232.94,23.84) 233.04,23.84 235.24,26.05 235.24,27.6 235.14,27.7 235.14,28.58 234.76,28.96 234.3,28.96 UC1.BN5
  TOP w0.152: v2(175.3,15.82) 174.64,16.48 JDIMM2.4
  IN1 w0.14: v2(175.3,15.82) 175.89,16.4 178.03,16.4 178.94,17.31 180.53,17.31 181.04,16.8 181.04,16.32 186.89,10.48 197.05,10.48 200.53,13.96 206.44,13.96 207.53,12.86 208.71,12.86 208.85,13 208.85,13.27 208.71,13.41 207.85,13.41 207.71,13.55 207.71,13.82 207.85,13.96 219.22,13.96 220.28,12.89 223.54,12.89 224.4,12.03 230.93,12.03 235.12,16.23 235.12,21.66 v2(232.94,23.84)
  BOTTOM w0.152: JDIMM1.3 174.43,16.23 174.96,15.7 175.18,15.7 v2(175.3,15.82)
DDR_A_D5: length 90.5
  TOP w0.076: v2(233.71,25.6) 234.2,25.6 234.82,26.22 234.82,26.96 234.66,27.13 234.66,27.53 234.83,27.7 234.83,28.12 234.64,28.31 UC1.BP6
  TOP w0.152: JDIMM2.7 180.69,17.23 180.17,16.71 v2(180.17,16.44)
  IN1 w0.14: v2(233.71,25.6) 233.71,24.37 235.94,22.14 235.94,14.71 232.37,11.15 224,11.15 223.1,12.05 220.08,12.05 218.91,13.22 212.39,13.22 212.23,13.06 212.23,12.74 212.37,12.6 215.75,12.6 215.89,12.46 215.89,12.19 215.75,12.05 199.73,12.05 197.41,9.73 186.41,9.73 180.29,15.84 180.29,16.32 v2(180.17,16.44)
  BOTTOM w0.152: v2(180.17,16.44) 180.17,16.54 181.12,17.48 JDIMM1.8
DDR_A_D6: length 93.3
  TOP w0.076: UC1.BP2 232.06,28.67 231.77,28.97 231.23,28.97 229.83,27.57 229.83,26.78 229.51,26.46 229.51,25.16 v2(230.24,24.44)
  TOP w0.152: JDIMM2.17 180.59,19.73 178.96,18.11 176.69,18.11 v2(176.36,18.44)
  IN1 w0.14: v2(176.36,18.44) 176.36,19.17 176.53,19.33 177.01,19.33 177.18,19.51 177.18,19.9 177.32,20.04 177.59,20.04 177.73,19.9 177.73,19.54 177.87,19.4 178.13,19.4 178.27,19.54 178.27,19.89 178.41,20.03 178.68,20.03 178.82,19.89 178.82,19.54 178.96,19.4 181.18,19.4 183.35,17.23 184.64,17.23 189.52,12.34 196.19,12.34 199.72,15.87 220.14,15.87 221.19,14.83 224.54,14.83 225.3,14.07 229.88,14.07 232.83,17.01 232.83,20.98 230.24,23.57 v2(230.24,24.44)
  BOTTOM w0.152: v2(176.36,18.44) 176.82,17.98 179.18,17.98 180.68,19.48 JDIMM1.16
DDR_A_D7: length 91.9
  TOP w0.076: UC1.BN3 232.39,27.99 232.39,27.88 232.2,27.69 232.17,27.67 231.82,27.67 231.69,27.67 231.13,27.12 231.13,26.66 231.28,26.52 231.28,26.11 231.26,26.09 231.26,26.09 230.65,25.48 230.65,24.93 v2(230.72,24.86)
  TOP w0.152: v2(177.61,18.52) 177.61,18.71 177.16,19.16 175.02,19.16 174.7,19.48 JDIMM2.16
  IN1 w0.14: v2(230.72,24.86) 230.89,24.69 230.89,23.57 233.33,21.13 233.33,16.78 230.14,13.59 225.12,13.59 224.27,14.43 221.05,14.43 219.97,15.51 199.87,15.51 196.34,11.98 189.29,11.98 184.91,16.36 184.69,16.36 184.4,16.08 184.4,15.88 185.96,14.32 185.96,14.13 185.77,13.94 185.57,13.94 182.54,16.97 182.54,17.51 181.02,19.03 177.89,19.03 177.61,18.75 v2(177.61,18.52)
  BOTTOM w0.152: v2(177.61,18.52) 176.89,19.25 175.87,19.25 175.38,19.73 JDIMM1.17
DDR_A_D8: length 84.8
  TOP w0.076: v2(232.97,30.96) 233.3,30.64 UC1.BL4
  TOP w0.152: v2(178.74,20.53) 180.94,22.73 JDIMM2.29
  IN1 w0.076: 229.13,22.65 228.71,23.07 228.71,25.19 231.38,27.87 232.76,30.75 v2(232.97,30.96)
  IN1 w0.14: v2(178.74,20.53) 178.74,20.61 179.54,21.41 181,21.41 182.91,19.51 185.36,19.51 187.06,17.81 187.06,16.84 190.32,13.58 193.84,13.58 196.91,16.65 198.75,16.65 199.21,17.1 211.59,17.1 212.35,17.87 214.65,17.87 215.36,17.16 224.8,17.16 226.32,15.63 229.27,15.63 231.29,17.64 231.29,20.49 229.13,22.65
  BOTTOM w0.152: v2(178.74,20.53) 178.74,20.73 180.5,22.48 JDIMM1.28
DDR_A_D9: length 84.1
  TOP w0.076: v2(233.62,30.96) 233.95,30.64 UC1.BL5
  TOP w0.152: JDIMM2.25 180.63,21.73 v2(179.39,20.49)
  IN1 w0.076: v2(233.62,30.96) 233.01,30.35 232.96,30.14 231.67,27.77 229.05,25.15 229.05,23.39 229.37,23.06
  IN1 w0.14: v2(179.39,20.49) 179.95,21.05 180.85,21.05 182.75,19.14 185.21,19.14 186.69,17.66 186.69,16.69 190.22,13.16 193.95,13.16 197.07,16.28 198.97,16.28 199.43,16.74 212.73,16.74 212.87,16.88 212.87,17.13 213.01,17.27 213.27,17.27 213.41,17.13 213.41,16.89 213.55,16.75 213.82,16.75 213.96,16.89 213.96,17.26 214.1,17.4 214.36,17.4 214.5,17.26 214.5,16.88 214.64,16.74 224.67,16.74 226.25,15.15 229.52,15.15 231.75,17.38 231.75,20.69 229.37,23.06
  BOTTOM w0.152: v2(179.39,20.49) 179.39,20.67 180.2,21.48 JDIMM1.24
DDR_A_D10: length 83.5
  TOP w0.076: v2(229.87,28.5) 229.87,29.11 231.27,30.52 UC1.BL2
  TOP w0.152: JDIMM2.37 178.67,24.73 178.33,24.4 v2(178.33,24.2)
  IN1 w0.076: v2(229.87,28.5) 228.94,28.5 226.17,25.73 226.17,25.05 224.98,23.86
  IN1 w0.14: v2(178.33,24.2) 178.79,24.67 179.89,24.67 180.15,24.41 181.69,24.41 182.33,23.76 186.19,23.76 188.29,21.66 189.04,21.66 189.74,20.97 193.5,20.97 193.64,20.83 193.64,20.51 193.77,20.37 194.04,20.37 194.18,20.51 194.18,20.83 194.32,20.97 194.59,20.97 194.73,20.83 194.73,20.02 194.87,19.88 195.13,19.88 195.27,20.02 195.27,20.83 195.41,20.97 195.68,20.97 195.82,20.83 195.82,20.02 195.96,19.88 196.23,19.88 196.37,20.02 196.37,20.83 196.51,20.97 201.81,20.97 202.5,21.66 205.61,21.66 206.1,21.18 211.36,21.18 211.5,21.32 211.5,21.58 211.36,21.72 206.45,21.72 206.31,21.86 206.31,22.13 206.45,22.27 223.38,22.27 224.98,23.86
  BOTTOM w0.152: JDIMM1.38 180.38,24.98 180.02,24.62 178.75,24.62 v2(178.33,24.2)
DDR_A_D11: length 84.1
  TOP w0.076: UC1.BM1 230.76,29.56 v2(230.76,29.4)
  TOP w0.152: JDIMM2.41 180.79,25.73 180.11,25.05 177.74,25.05 177.04,24.35 v2(177.04,24.18)
  IN1 w0.076: v2(230.76,29.4) 230.07,29.4 229.58,28.91 229.04,28.91 225.86,25.73 225.86,25.31 225.5,24.95
  IN1 w0.14: v2(177.04,24.18) 176.25,23.39 173.74,23.39 173.6,23.53 173.6,23.79 173.74,23.93 175.92,23.93 176.06,24.07 176.06,24.34 175.92,24.48 173.81,24.48 173.7,24.59 173.7,24.9 173.83,25.03 180.07,25.03 180.32,24.78 185.69,24.78 188.44,22.03 189.2,22.03 189.89,21.34 201.65,21.34 202.35,22.03 205.6,22.03 206.2,22.64 223.19,22.64 225.5,24.95
  BOTTOM w0.152: JDIMM1.42 180.84,25.98 179.87,25.01 177.88,25.01 v2(177.04,24.18)
DDR_A_D12: length 86.1
  TOP w0.076: UC1.BK4 v2(232.97,31.75)
  TOP w0.152: JDIMM2.28 174.44,22.48 175.05,21.88 175.05,21.72 175.66,21.11 176.98,21.11 v2(177.55,20.54)
  IN1 w0.076: 224.44,20.28 224.76,20.6 224.76,20.88 228.12,24.24 228.12,25.01 231.03,27.92 231.03,28.58 231.44,28.99 231.44,29.99 232.97,31.53 v2(232.97,31.75)
  IN1 w0.14: v2(177.55,20.54) 178.49,21.48 178.82,21.48 179.24,21.9 181.04,21.9 182.21,20.72 186.06,20.72 187.41,19.38 187.89,19.38 189.45,17.81 189.45,17.13 189.77,16.81 193.5,16.81 193.58,16.73 194.06,16.73 194.34,17.01 198.57,17.01 199.08,17.53 211.49,17.53 212.31,18.34 214.85,18.34 215.67,17.53 221.74,17.53 221.88,17.67 221.88,17.93 221.74,18.07 217.72,18.07 217.58,18.21 217.58,18.48 217.72,18.62 221.86,18.62 222.94,19.69 223.86,19.69 224.44,20.28
  BOTTOM w0.152: JDIMM1.29 175.35,22.73 v2(177.55,20.54)
DDR_A_D13: length 84.6
  TOP w0.076: UC1.BK5 v2(233.62,31.75)
  TOP w0.152: JDIMM2.24 174.39,21.48 175.44,20.43 176.11,20.43 v2(176.22,20.54)
  IN1 w0.076: v2(233.62,31.75) 233.25,32.12 232.1,32.12 231.17,31.19 231.17,29.18 230.77,28.77 230.77,28.09 227.82,25.15 227.82,24.28 224.06,20.52
  IN1 w0.14: v2(176.22,20.54) 177.52,21.85 178.67,21.85 179.21,22.39 181.07,22.39 182.36,21.09 186.22,21.09 187.54,19.77 188.02,19.77 189.94,17.84 196.84,17.84 197.3,17.38 198.41,17.38 198.93,17.9 211.28,17.9 212.09,18.71 215.93,18.71 216.07,18.57 216.07,18.07 216.21,17.93 216.48,17.93 216.62,18.07 216.62,18.57 216.76,18.71 217.23,18.71 217.69,19.17 221.65,19.17 221.79,19.31 221.79,19.58 221.65,19.72 217.97,19.72 217.83,19.86 217.83,20.12 217.97,20.26 223.81,20.26 224.06,20.52
  BOTTOM w0.152: v2(176.22,20.54) 176.15,20.54 174.96,21.73 JDIMM1.25
DDR_A_D14: length 86.7
  TOP w0.076: v2(229.42,28.05) 229.42,28.99 UC1.BK1
  TOP w0.152: v2(179.59,24.16) 179.19,23.76 176.84,23.76 174.62,25.98 JDIMM2.42
  IN1 w0.076: 225.21,23.53 226.47,24.79 226.47,25.73 228.8,28.05 v2(229.42,28.05)
  IN1 w0.14: 225.21,23.53 223.47,21.79 213.03,21.79 211.84,20.6 205.63,20.6 205.48,20.75 205.48,21.15 205.34,21.29 205.08,21.29 204.94,21.16 204.94,20.74 204.8,20.6 204.54,20.6 204.4,20.74 204.4,21.15 204.26,21.29 203.99,21.29 203.85,21.15 203.85,20.74 203.71,20.6 203.44,20.6 203.3,20.74 203.3,21.15 203.16,21.29 202.9,21.29 202.76,21.15 202.76,20.74 202.62,20.6 200.36,20.6 200.22,20.46 200.22,20.2 200.36,20.06 204.94,20.06 205.07,19.92 205.07,19.65 204.94,19.51 194.58,19.51 194.09,20 189.9,20 188.64,21.26 188.16,21.26 186.06,23.37 182.21,23.37 181.57,24.01 179.75,24.01 v2(179.59,24.16)
  BOTTOM w0.152: v2(179.59,24.16) 179.21,23.78 176.88,23.78 176.46,24.2 176.46,24.37 175.1,25.73 JDIMM1.41
DDR_A_D15: length 84.4
  TOP w0.076: UC1.BK2 231.71,31.64 230.76,31.64 227.17,28.05 v2(227.17,25.81)
  TOP w0.152: v2(176.27,22.51) 176.27,23.13 174.42,24.98 JDIMM2.38
  IN1 w0.076: v2(227.17,25.81) 226.84,25.48 226.84,24.58 225.45,23.19
  IN1 w0.14: v2(176.27,22.51) 176.27,22.89 176.67,23.28 177.62,23.28 177.98,23.64 181.41,23.64 182.05,23 185.91,23 188.01,20.9 188.49,20.9 189.75,19.63 193.81,19.63 194.3,19.14 210.69,19.14 210.83,19.28 210.83,19.55 210.69,19.69 205.63,19.69 205.49,19.83 205.49,20.09 205.63,20.23 212,20.23 213.18,21.42 223.67,21.42 225.45,23.19
  BOTTOM w0.152: v2(176.27,22.51) 176.27,23.3 174.84,24.73 JDIMM1.37
DDR_A_D16: length 75.5
  TOP w0.076: UC1.BG4 233.3,32.88 233.21,32.79 231.86,32.79 231.64,32.57 231.17,32.57 230.75,32.99 230.4,32.99 229.72,32.31 v2(229.72,31.49)
  TOP w0.152: v2(178.82,25.77) 179.23,25.35 179.78,25.35 180.04,25.61 180.04,25.81 180.26,26.03 180.49,26.03 180.7,26.24 180.7,26.43 181,26.73 JDIMM2.45
  IN1 w0.076: v2(229.72,31.49) 229.72,30.62 229.12,30.02 229.12,29.61 225.06,25.56 224.92,25.56 224.65,25.3
  IN1 w0.14: 224.65,25.3 222.89,23.53 205.55,23.53 205.41,23.39 205.41,22.99 205.27,22.85 205,22.85 204.86,22.99 204.86,23.39 204.72,23.53 204.45,23.53 204.32,23.39 204.32,22.98 204.18,22.84 203.91,22.84 203.77,22.98 203.77,23.39 203.63,23.53 203.36,23.53 203.22,23.39 203.22,22.98 203.08,22.84 202.82,22.84 202.68,22.98 202.68,23.39 202.54,23.53 202.27,23.53 202.13,23.39 202.13,22.98 201.99,22.84 201.72,22.84 201.58,22.98 201.58,23.39 201.44,23.53 201.18,23.53 201.04,23.39 201.04,22.98 200.9,22.84 200.63,22.84 200.49,22.98 200.49,23.39 200.35,23.53 200.03,23.53 199.34,22.84 188.86,22.84 186.03,25.67 182.12,25.67 181.94,25.85 180.13,25.85 179.68,26.3 179.1,26.3 178.82,26.02 v2(178.82,25.77)
  BOTTOM w0.152: v2(178.82,25.77) 179.22,25.36 179.66,25.36 180.33,26.04 180.33,26.25 181.07,26.98 JDIMM1.46
DDR_A_D17: length 75.4
  TOP w0.076: UC1.BG5 233.35,32.48 231.85,32.48 231.75,32.39 231.12,32.39 230.73,32.78 230.5,32.78 230.16,32.44 v2(230.16,31.94)
  TOP w0.152: JDIMM2.49 181.1,27.73 180.58,27.22 180.58,26.74 180.3,26.46 179.98,26.46 179.5,25.98 v2(179.5,25.77)
  IN1 w0.076: v2(230.16,31.94) 230.16,30.36 225.52,25.71 225.52,25.64 225.12,25.24
  IN1 w0.14: 225.12,25.24 223.04,23.16 206.1,23.16 205.41,22.48 201.72,22.48 201.58,22.34 201.58,21.93 201.44,21.79 201.17,21.79 201.03,21.93 201.03,22.34 200.89,22.48 200.63,22.48 200.49,22.34 200.49,21.93 200.35,21.79 200.08,21.79 199.94,21.93 199.94,22.39 199.8,22.53 199.54,22.53 199.4,22.39 199.4,21.94 199.26,21.8 198.99,21.8 198.85,21.94 198.85,22.34 198.71,22.48 196.94,22.48 196.8,22.34 196.8,21.92 196.66,21.78 196.39,21.78 196.25,21.92 196.25,22.34 196.11,22.48 195.85,22.48 195.71,22.34 195.71,21.92 195.57,21.78 195.3,21.78 195.16,21.92 195.16,22.34 195.02,22.48 194.75,22.48 194.61,22.34 194.61,21.92 194.47,21.78 194.21,21.78 194.07,21.92 194.07,22.34 193.93,22.48 188.67,22.48 185.87,25.28 181.97,25.28 181.77,25.48 179.79,25.48 v2(179.5,25.77)
  BOTTOM w0.152: v2(179.5,25.77) 179.5,26.31 181.18,27.98 JDIMM1.50
DDR_A_D18: length 78.2
  TOP w0.076: v2(232.97,34.26) 233.3,33.94 UC1.BF4
  TOP w0.152: JDIMM2.62 175.61,30.98 176.15,30.44 177.07,30.44 177.7,29.81 179.14,29.81 179.58,29.36 v2(179.58,29.21)
  IN1 w0.076: v2(232.97,34.26) 231.79,33.08 230.09,33.08 226.98,29.97 226.64,29.97 225.33,28.66 225.33,28.41 224.97,28.05
  IN1 w0.14: 224.97,28.05 224.51,27.6 223.62,27.6 221.79,25.77 200.08,25.77 199.94,25.91 199.94,26.22 199.8,26.36 199.53,26.36 199.39,26.22 199.39,25.91 199.25,25.77 195.66,25.77 195.52,25.91 195.52,26.17 195.66,26.31 196.21,26.31 196.35,26.45 196.35,26.74 196.14,26.94 195.5,26.94 194.81,26.25 188.85,26.25 187.46,27.64 187.46,28.13 186.38,29.21 182.44,29.21 182.3,29.07 182.3,28.71 182.16,28.57 181.89,28.57 181.75,28.71 181.75,29.09 181.61,29.23 181.35,29.23 181.21,29.09 181.21,28.71 181.07,28.57 180.8,28.57 180.66,28.71 180.66,29.07 180.52,29.21 v2(179.58,29.21)
  BOTTOM w0.152: JDIMM1.63 175.49,31.23 176.81,29.92 178.88,29.92 v2(179.58,29.21)
DDR_A_D19: length 79.4
  TOP w0.076: UC1.BF5 233.95,33.89 v2(233.57,34.26)
  TOP w0.152: JDIMM2.59 180.92,30.23 180.38,29.7 180.38,29.01 179.43,28.06 178.16,28.06 177.8,28.42 176.98,28.42 176.59,28.03 v2(176.59,27.51)
  IN1 w0.076: 225.24,27.78 225.6,28.13 225.6,28.61 226.63,29.64 227.11,29.64 230.28,32.81 232.49,32.81 233.57,33.89 v2(233.57,34.26)
  IN1 w0.14: 225.24,27.78 224.66,27.2 223.77,27.2 221.98,25.4 195.49,25.4 195,25.89 188.7,25.89 187.09,27.49 187.09,27.98 186.25,28.82 183.14,28.82 182.51,28.19 180.49,28.19 179.97,28.72 177.71,28.72 176.59,27.59 v2(176.59,27.51)
  BOTTOM w0.152: v2(176.59,27.51) 177.04,27.06 179.52,27.06 180.74,28.28 180.74,29.58 181.15,29.98 JDIMM1.58
DDR_A_D20: length 74.9
  TOP w0.076: UC1.BG2 231.76,33.08 231.47,32.79 231.21,32.79 230.76,33.24 230.35,33.24 228.82,31.7 v2(228.82,30.59)
  TOP w0.152: JDIMM2.50 175.23,27.98 v2(177.45,25.77)
  IN1 w0.076: 224.46,25.63 224.66,25.82 224.97,25.82 228.82,29.67 v2(228.82,30.59)
  IN1 w0.14: 224.46,25.63 222.74,23.9 199.87,23.9 199.18,23.21 189.21,23.21 189.04,23.38 189.04,23.6 189.42,23.98 189.42,24.18 189.23,24.37 189.03,24.37 188.61,23.94 188.28,23.94 185.53,26.69 182.94,26.69 182.8,26.55 182.8,26.18 182.66,26.04 182.39,26.04 182.25,26.18 182.25,26.55 182.11,26.69 181.84,26.69 181.7,26.55 181.7,26.36 181.56,26.22 181.3,26.22 181.16,26.36 181.16,26.55 181.02,26.69 180.75,26.69 180.61,26.55 180.61,26.44 180.47,26.3 180.21,26.3 180.07,26.44 180.07,26.55 179.93,26.69 178.82,26.69 178.48,26.35 178.03,26.35 v2(177.45,25.77)
  BOTTOM w0.152: v2(177.45,25.77) 177.45,25.96 175.67,27.73 JDIMM1.49
DDR_A_D21: length 72.1
  TOP w0.076: UC1.BG1 231.18,33.08 230.82,33.44 230.26,33.44 228.37,31.55 v1(228.37,31.17) v2(228.37,30.14)
  TOP w0.152: v2(176.05,25.77) 174.83,26.98 JDIMM2.46
  IN1 w0.076: v2(228.37,30.14) 228.37,29.54 224.99,26.16 224.48,26.16 224.29,25.98
  IN1 w0.14: v2(176.05,25.77) 176.05,26.07 175.87,26.25 174.57,26.25 174.42,26.4 174.42,26.78 174.6,26.96 178.33,26.96 178.43,27.06 185.92,27.06 188.24,24.74 189.4,24.74 190.05,24.09 193.17,24.09 193.68,23.58 199.03,23.58 199.72,24.27 222.59,24.27 224.29,25.98
  BOTTOM w0.152: v2(176.05,25.77) 176.05,25.96 175.28,26.73 JDIMM1.45
DDR_A_D22: length 73.5
  TOP w0.076: UC1.BF1 231.35,33.95 v2(231.03,34.26)
  TOP w0.152: v2(176.96,29.21) 176.96,29.4 176.37,29.98 JDIMM2.58
  IN1 w0.076: 224.02,28.42 224.5,28.42 229.86,33.78 230.55,33.78 v2(231.03,34.26)
  IN1 w0.14: 224.02,28.42 223.36,28.42 221.57,26.63 202.95,26.63 201.86,27.73 199.93,27.73 199.3,27.1 197.03,27.1 196.45,27.68 193.75,27.68 193.06,26.99 189.19,26.99 188.36,27.82 188.36,28.28 186.15,30.49 183.15,30.49 182.62,29.97 177.68,29.97 177.28,30.36 175.11,30.36 174.95,30.2 174.95,29.89 175.1,29.74 176.78,29.74 176.96,29.56 v2(176.96,29.21)
  BOTTOM w0.152: JDIMM1.59 175.94,30.23 v2(176.96,29.21)
DDR_A_D23: length 75.5
  TOP w0.076: UC1.BF2 232,33.94 v2(231.67,34.26)
  TOP w0.152: JDIMM2.63 181.19,31.23 180.01,30.05 180.01,29.07 179.73,28.79 178.74,28.79 v2(178.31,29.22)
  IN1 w0.076: 223.86,28.03 224.41,28.03 226.68,30.3 226.85,30.3 230,33.45 230.85,33.45 v2(231.67,34.26)
  IN1 w0.14: 223.86,28.03 223.53,28.03 221.68,26.18 200.51,26.18 200.37,26.32 200.37,26.59 200.51,26.73 201.79,26.73 201.93,26.87 201.93,27.14 201.79,27.28 200,27.28 199.45,26.73 196.88,26.73 196.3,27.31 194.97,27.31 194.8,27.14 194.8,26.76 194.66,26.62 194.39,26.62 194.28,26.73 194.28,27.14 194.14,27.28 193.87,27.28 193.74,27.14 193.74,26.79 193.57,26.62 189,26.62 187.96,27.66 187.96,28.16 186.52,29.6 178.69,29.6 v2(178.31,29.22)
  BOTTOM w0.152: JDIMM1.62 180.84,30.98 180.21,30.36 180.21,29.23 179.77,28.78 178.82,28.78 178.38,29.22 v2(178.31,29.22)
DDR_A_D24: length 73.6
  TOP w0.076: v2(228.24,32.75) 228.24,33.31 229.18,34.26 229.18,34.47 229.42,34.71 229.42,34.82 229.78,35.17 230.13,35.17 230.28,35.32 231.46,35.32 231.74,35.6 UC1.BD2
  TOP w0.152: v2(177.73,30.86) 178.15,30.44 179.28,30.44 181.08,32.23 JDIMM2.67
  IN1 w0.076: v2(228.24,32.75) 228.21,32.73 227.67,32.73 227.53,32.59 227.13,32.59 226.54,32 226.54,31.54 226.26,31.26
  IN1 w0.14: v2(177.73,30.86) 177.73,31.3 178.02,31.59 178.99,31.59 179.71,30.87 180.44,30.87 180.58,31.01 180.58,31.27 180.44,31.41 179.95,31.41 179.81,31.55 179.81,31.82 179.95,31.96 182.77,31.96 183.37,31.36 186.42,31.36 189.22,28.57 202.16,28.57 203.24,27.5 221.35,27.5 223.18,29.32 224.32,29.32 226.26,31.26
  BOTTOM w0.152: JDIMM1.66 181.1,31.98 179.41,30.3 178.29,30.3 v2(177.73,30.86)
DDR_A_D25: length 71.5
  TOP w0.076: UC1.BD1 230.22,35.6 230.04,35.41 229.68,35.41 229.17,34.9 229.17,34.75 228.92,34.5 228.92,34.37 227.8,33.26 v2(227.8,32.32)
  TOP w0.152: v2(179.01,30.86) 179.01,31.1 181.14,33.23 JDIMM2.71
  IN1 w0.076: v2(227.8,32.32) 227.3,32.32 226.9,31.92 226.9,31.37 226.43,30.9
  IN1 w0.14: v2(179.01,30.86) 179.01,30.61 179.2,30.41 182.44,30.41 182.58,30.55 182.58,30.82 182.44,30.96 181.1,30.96 180.96,31.1 180.96,31.36 181.1,31.5 182.71,31.5 183.28,30.93 186.33,30.93 189.1,28.17 196.59,28.17 197.22,27.54 199.11,27.54 199.77,28.2 202.01,28.2 203.08,27.13 221.53,27.13 223.3,28.9 224.44,28.9 226.43,30.9
  BOTTOM w0.152: v2(179.01,30.86) 179.21,30.86 180.49,32.14 180.49,32.53 180.95,32.98 JDIMM1.70
DDR_A_D26: length 74.7
  TOP w0.076: UC1.BC4 233.3,36.45 v2(232.97,36.78)
  TOP w0.152: v2(177.83,34.15) 177.83,34.32 178.74,35.23 JDIMM2.79
  IN1 w0.076: 224.31,32.32 224.68,32.69 224.98,32.69 227.9,35.61 231.8,35.61 v2(232.97,36.78)
  IN1 w0.14: v2(177.83,34.15) 178.33,34.65 179.61,34.65 180.72,35.77 182.14,35.77 183.07,34.83 186.33,34.83 189.23,31.93 194.05,31.93 194.58,31.41 200.64,31.41 200.78,31.55 200.78,31.81 200.64,31.95 199.59,31.95 199.45,32.09 199.45,32.36 199.59,32.5 201.04,32.5 202.65,30.89 205.69,30.89 206.14,30.44 207.77,30.44 208.26,29.95 220.39,29.95 222.24,31.81 223.79,31.81 224.31,32.32
  BOTTOM w0.152: JDIMM1.80 179.16,35.48 v2(177.83,34.15)
DDR_A_D27: length 76.7
  TOP w0.076: UC1.BC5 233.95,36.45 v2(233.62,36.78)
  TOP w0.152: v2(179.02,34.1) 178.66,33.74 177.69,33.74 177.62,33.81 176.32,33.81 174.65,35.48 JDIMM2.80
  IN1 w0.076: 224.56,31.94 227.84,35.23 232.07,35.23 v2(233.62,36.78)
  IN1 w0.14: 224.56,31.94 223.98,31.36 222.48,31.36 220.71,29.58 208.01,29.58 207.52,30.07 205.98,30.07 205.57,30.48 202.46,30.48 201.9,31.04 194.32,31.04 193.79,31.56 188.86,31.56 185.96,34.46 182.92,34.46 182.19,35.19 180.68,35.19 180.54,35.05 180.54,34.79 180.68,34.65 181.93,34.65 182.06,34.51 182.06,34.24 181.93,34.1 v2(179.02,34.1)
  BOTTOM w0.152: JDIMM1.79 174.91,35.23 176.54,33.6 178.52,33.6 v2(179.02,34.1)
DDR_A_D28: length 76.7
  TOP w0.076: UC1.BD5 233.43,35.08 231.83,35.08 231.74,34.99 230.68,34.99 230.33,34.64 230.13,34.64 v2(229.75,34.26)
  TOP w0.152: JDIMM2.70 174.48,32.98 175.27,32.19 178.69,32.19 179.18,32.69 v2(179.18,32.75)
  IN1 w0.076: 225.64,31.8 226.91,33.07 227.47,33.07 228.67,34.26 v2(229.75,34.26)
  IN1 w0.14: v2(179.18,32.75) 182.55,32.75 182.61,32.7 186.13,32.7 188.82,30.01 193.53,30.01 194.19,29.35 204.6,29.35 204.7,29.26 204.7,28.99 204.56,28.85 203.56,28.85 203.38,28.67 203.38,28.4 203.52,28.26 205.09,28.26 205.23,28.4 205.23,28.74 205.37,28.88 205.63,28.88 205.77,28.74 205.77,28.37 205.91,28.23 206.18,28.23 206.32,28.37 206.32,28.73 206.46,28.87 206.73,28.87 206.87,28.73 206.87,28.4 207.01,28.26 207.3,28.26 207.5,28.45 221.22,28.45 222.85,30.09 223.93,30.09 225.64,31.8
  BOTTOM w0.152: JDIMM1.71 174.39,33.23 174.87,33.72 175.63,33.72 176.25,33.11 178.82,33.11 v2(179.18,32.75)
DDR_A_D29: length 73.1
  TOP w0.076: UC1.BD4 233,35.3 231.79,35.3 231.64,35.15 230.46,35.15 230.2,34.89 229.89,34.89 229.38,34.38 229.38,33.9 v2(229.3,33.82)
  TOP w0.152: v2(176.46,30.87) 176.46,31.03 175.85,31.64 174.96,31.64 174.61,31.98 JDIMM2.66
  IN1 w0.076: v2(229.3,33.82) 228.67,33.82 227.84,32.98 227.65,32.98 227.54,32.87 227.07,32.87 226.24,32.05 226.24,31.78 226.07,31.61
  IN1 w0.14: 226.07,31.61 224.15,29.68 223,29.68 221.18,27.87 203.39,27.87 202.32,28.94 194.09,28.94 193.45,29.58 188.73,29.58 185.98,32.33 179.44,32.33 179.22,32.1 175.07,32.1 174.84,31.88 174.84,31.4 175,31.25 176.08,31.25 v2(176.46,30.87)
  BOTTOM w0.152: v2(176.46,30.87) 175.09,32.23 JDIMM1.67
DDR_A_D30: length 72.3
  TOP w0.076: v2(231.02,36.78) 231.35,36.45 UC1.BC1
  TOP w0.152: JDIMM2.84 174.49,36.48 176.48,34.49 v2(176.48,34.25)
  IN1 w0.076: 224.16,32.71 224.47,33.02 224.96,33.02 227.92,35.99 230.26,35.99 231.02,36.75 v2(231.02,36.78)
  IN1 w0.14: v2(176.48,34.25) 177.15,34.92 177.15,35.61 177.28,35.73 177.58,35.73 177.72,35.59 177.72,35.15 177.86,35.01 178.13,35.01 178.27,35.15 178.27,35.63 178.41,35.77 178.67,35.77 178.81,35.63 178.81,35.18 178.95,35.04 179.22,35.04 179.36,35.18 179.36,35.69 179.5,35.83 180.23,35.83 180.66,36.26 182.16,36.26 182.6,35.83 184.17,35.83 184.78,35.22 186.46,35.22 188.51,33.17 192.33,33.17 193.14,32.35 194.15,32.35 194.56,31.95 196.81,31.95 197.46,32.6 198.5,32.6 198.81,32.91 201.15,32.91 202.79,31.27 205.83,31.27 206.29,30.81 208.02,30.81 208.5,30.32 220.05,30.32 222.01,32.29 223.73,32.29 224.16,32.71
  BOTTOM w0.152: v2(176.48,34.25) 176.48,34.64 174.89,36.23 JDIMM1.83
DDR_A_D31: length 70.6
  TOP w0.076: UC1.BC2 232,36.45 v2(231.67,36.78)
  TOP w0.152: v2(179.99,36.34) 180.1,36.23 JDIMM2.83
  IN1 w0.076: v2(231.67,36.78) 231.27,37.18 230.6,37.18 229.77,36.34 227.95,36.34 225.01,33.41 224.31,33.41 224.03,33.14
  IN1 w0.14: v2(179.99,36.34) 180.29,36.64 182.36,36.64 182.78,36.22 184.66,36.22 184.8,36.08 184.8,35.74 184.94,35.6 185.21,35.6 185.35,35.74 185.35,36.08 185.49,36.22 185.98,36.22 188.51,33.69 193.44,33.69 193.6,33.52 193.6,32.86 193.74,32.72 194.01,32.72 194.15,32.86 194.15,33.55 194.29,33.69 194.55,33.69 194.69,33.55 194.69,32.46 194.83,32.32 195.1,32.32 195.24,32.46 195.24,33.55 195.38,33.69 195.65,33.69 195.78,33.55 195.78,32.46 195.92,32.32 196.19,32.32 196.33,32.46 196.33,33.55 196.47,33.69 196.74,33.69 196.88,33.55 196.88,33.07 197.02,32.93 197.28,32.93 197.42,33.07 197.42,33.55 197.56,33.69 197.87,33.69 198.01,33.55 198.01,33.37 198.15,33.23 198.42,33.23 198.56,33.37 198.56,33.49 198.75,33.69 200.9,33.69 202.9,31.69 205.96,31.69 206.47,31.18 208.17,31.18 208.66,30.69 219.7,30.69 221.77,32.76 223.66,32.76 224.03,33.14
  BOTTOM w0.152: JDIMM1.84 180.13,36.48 v2(179.99,36.34)
DDR_A_D32: length 79.3
  TOP w0.076: v2(227.81,52.76) 228.36,53.31 231.01,53.31 231.06,53.26 231.28,53.26 UC1.AB1
  TOP w0.152: JDIMM2.173 180.5,60.73 179.25,61.99 178.15,61.99 177.1,63.04 176.77,63.04 v2(176.23,63.59)
  IN1 w0.076: v2(227.81,52.76) 226.09,52.76 219.16,59.69 219.02,59.69 218.77,59.94
  IN1 w0.14: v2(176.23,63.59) 176.96,62.85 177.8,62.85 177.93,62.73 179.34,62.73 181.17,64.55 181.17,64.85 182.3,65.98 185.92,65.98 188.19,68.24 189.5,68.24 190.02,68.76 194.6,68.76 194.9,68.45 196.05,68.45 196.7,67.8 198.38,67.8 199.16,68.58 202.68,68.58 204.4,66.86 210.98,66.86 215.75,62.09 216.62,62.09 218.77,59.94
  BOTTOM w0.152: JDIMM1.174 180.19,60.98 178.31,62.87 176.77,62.87 176.23,63.41 v2(176.23,63.59)
DDR_A_D33: length 76.3
  TOP w0.076: v2(228.26,52.31) 229.06,53.11 231.04,53.11 231.22,52.93 231.73,52.93 UC1.AB2
  TOP w0.152: v2(176.23,61.87) 175.73,61.38 175.73,60.96 174.75,59.98 JDIMM2.170
  IN1 w0.076: v2(228.26,52.31) 227.43,52.31 227.25,52.49 226.06,52.49 219.15,59.4 218.79,59.4 218.67,59.51
  IN1 w0.14: v2(176.23,61.87) 176.7,62.35 179.48,62.35 181.61,64.48 181.61,64.77 182.45,65.61 186.07,65.61 188.3,67.83 196.15,67.83 196.55,67.43 198.53,67.43 199.31,68.21 200.96,68.21 202.7,66.46 202.9,66.46 203.09,66.65 203.09,66.85 202.31,67.63 202.31,67.83 202.5,68.02 202.69,68.02 204.22,66.49 210.83,66.49 215.6,61.72 216.47,61.72 218.67,59.51
  BOTTOM w0.152: v2(176.23,61.87) 176.23,61.61 174.35,59.73 JDIMM1.169
DDR_A_D34: length 78.2
  TOP w0.076: v2(232.97,54.38) 233.3,54.05 UC1.AA4
  TOP w0.152: JDIMM2.187 180.98,64.23 180.54,64.67 178.24,64.67 177.9,65.02 v2(177.9,65.22)
  IN1 w0.076: v2(232.97,54.38) 232.97,54.11 232.12,53.26 228.3,53.26 227.62,53.94 227.29,53.94 225.51,55.72 225.11,55.72 224.98,55.85
  IN1 w0.14: v2(177.9,65.22) 177.9,65.08 178.11,64.87 179.3,64.87 179.57,65.13 179.57,65.37 183.07,68.87 185.88,68.87 187.77,70.76 194.86,70.76 195.43,70.18 203.29,70.18 205.11,68.36 205.31,68.36 205.5,68.55 205.5,68.75 204.78,69.46 204.78,69.66 204.97,69.85 205.17,69.85 206.66,68.35 212.48,68.35 224.98,55.85
  BOTTOM w0.152: JDIMM1.186 180.82,63.98 180.1,64.71 178.54,64.71 178.03,65.22 v2(177.9,65.22)
DDR_A_D35: length 80.6
  TOP w0.076: v2(233.62,54.38) 233.95,54.06 UC1.AA5
  TOP w0.152: v2(176.58,65.11) 177.38,64.3 180.14,64.3 180.8,63.64 180.8,63.48 181.04,63.23 JDIMM2.183
  IN1 w0.076: 224.65,55.66 224.82,55.49 225.45,55.49 227.27,53.67 227.56,53.67 228.23,53.01 233.1,53.01 233.62,53.52 v2(233.62,54.38)
  IN1 w0.14: v2(176.58,65.11) 177.19,64.5 179.43,64.5 179.91,64.98 179.91,65.19 183.21,68.49 186.03,68.49 187.42,69.89 195.21,69.89 195.34,69.75 203.11,69.75 204.88,67.99 212.32,67.99 224.65,55.66
  BOTTOM w0.152: v2(176.58,65.11) 176.86,64.82 177.94,64.82 178.45,64.3 179.25,64.3 180.57,62.98 JDIMM1.182
DDR_A_D36: length 79.1
  TOP w0.076: v2(230.16,52.31) 230.51,52.65 230.96,52.65 231.04,52.58 233.33,52.58 UC1.AB5
  TOP w0.152: v2(177.58,60.95) 177.98,61.35 179.33,61.35 180.94,59.73 JDIMM2.169
  IN1 w0.076: 219.07,58.68 219.23,58.68 225.89,52.02 226.82,52.02 227.03,51.81 227.85,51.81 227.97,51.7 229.55,51.7 v2(230.16,52.31)
  IN1 w0.14: v2(177.58,60.95) 177.58,61.17 177.97,61.56 179.74,61.56 182.56,64.39 182.56,64.51 182.92,64.86 186.54,64.86 188.75,67.07 195.87,67.07 196.24,66.69 198.84,66.69 199.62,67.47 200.43,67.47 200.57,67.34 200.57,67.07 200.42,66.93 199.84,66.93 199.7,66.79 199.7,66.52 199.84,66.38 201.06,66.38 201.72,65.72 208.45,65.72 209.57,64.6 211.67,64.6 212.34,63.93 215.29,60.98 216.17,60.98 218.47,58.68 219.07,58.68
  BOTTOM w0.152: v2(177.58,60.95) 178.1,61.47 178.85,61.47 180.33,59.98 JDIMM1.170
