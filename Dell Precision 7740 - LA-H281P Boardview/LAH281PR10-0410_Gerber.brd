# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBTA_SBU1: length 44.6
  TOP w0.102: v2(6.71,55.85) 6.58,55.73 JUSBC1.B8
  IN2 w0.094: v2(14.3,55.49) 14.65,55.14 14.75,55.14 14.98,54.91 14.98,52.74 14.43,52.19 14.43,46.53 15.61,45.35 15.61,42.22 13.84,40.45 13.84,39.53 12.73,38.41 12.73,37.28 13.15,36.86 13.15,36.07 14.01,35.21 14.01,34.21 14.53,33.69 14.53,33.38 15.17,32.74 15.17,31.16 15.18,31.15 15.18,31.05 15.18,30.96 15.17,30.95 15.17,30.07 16.36,28.88 16.36,28.73 16.47,28.62 16.61,28.62 v2(16.87,28.88)
  BOTTOM w0.102: DT2002.1 14.58,55.77 v2(14.3,55.49) 13.88,55.49 13.58,55.19 DT7.6 DT7.5 11.94,55.19 11.76,55.01 10.25,55.01 9.73,55.53 7.02,55.53 v2(6.71,55.85) ; UT5.A3 18.85,30.36 18.85,30 18.32,29.47 18.26,29.47 17.81,29.01 17.81,28.96 17.43,28.58 16.96,28.58 16.87,28.67 v2(16.87,28.88)
TBTA_SBU2: length 44.9
  TOP w0.102: v2(14.32,52.93) 13.71,52.93 13.46,53.19 DT8.1 DT8.9 11.01,53.19 10.22,53.98 JUSBC1.A8
  IN2 w0.094: v2(14.32,52.93) 14.32,52.94 14.32,54.73 14.54,54.94 14.67,54.94 14.78,54.82 14.78,52.82 14.23,52.27 14.23,46.45 15.41,45.27 15.41,42.3 13.65,40.53 13.65,39.61 12.53,38.49 12.53,37.2 12.96,36.77 12.96,35.99 13.81,35.13 13.81,34.13 14.33,33.61 14.33,33.3 14.98,32.66 14.98,31.14 14.98,31.13 14.98,31.05 14.98,30.98 14.98,30.97 14.98,29.99 16.17,28.8 16.17,28.65 16.39,28.43 16.63,28.43 v2(16.88,28.18)
  BOTTOM w0.102: v2(16.88,28.18) 17.09,28.39 17.51,28.39 v3(18.19,29.07) 19.04,29.92 UT5.A4 ; v2(14.32,52.93) 14.66,52.59 DT2004.1
TBTA_USB2_RBIAS: length 4.5
  TOP w0.109: v1(33.17,41.96) RT41.2 33.7,42.92 33.73,42.94 34.79,42.94 v2(35.79,43.94)
  BOTTOM w0.102: v2(35.79,43.94) UT1.H19
TBTB_CC1: length 54.6
  TOP w0.254: v2(6.69,70.3) 6.55,70.3 6.41,70.43 JUSBC1.1B5
  TOP w0.508: v2(15.07,46.62) 15.07,46.08 16.13,45.02 20.14,45.02 20.43,45.32 v1(21.17,45.32) 22.85,43.64 22.85,42.46 23.31,41.99 23.31,40.84 24.49,39.66 24.49,38.48 v2(23.98,37.96)
  IN1 w0.508: v2(23.98,37.96) 23.79,37.96 20.98,35.15 20.98,34.71 v2(20.98,34.71)
  IN3 w0.508: v2(15.07,46.62) 14.93,46.76 14.93,50.37 15.82,51.26 15.82,57.42 14.11,59.13 14.11,63.54 v2(13.39,64.26)
  BOTTOM w0.254: v2(20.98,34.71) 21.07,34.71 UT5.K9 ; 13.82,65.05 14.04,65.28 DT11.9 DT11.1 14.09,66.72
  BOTTOM w0.457: v2(13.39,64.26) 13.47,64.34 13.47,64.78 13.74,65.05 13.82,65.05 ; v2(6.69,70.3) 7.15,70.3
  BOTTOM w0.508: CT351.2 24.33,38.19 24.1,37.96 v2(23.98,37.96) ; v2(13.39,64.26) 13.6,64.05 DT2005.1 ; 7.15,70.3 9.93,70.3 12.76,67.47 13.34,67.47 14.09,66.72
TBTB_CC2: length 60
  TOP w0.203: v2(17.03,65.26) 16.55,65.26 16.33,65.04 16.2,65.04 16.09,65.15 DT12.5
  TOP w0.254: JUSBC1.1A5 7.97,71.68 8.32,71.33 8.55,71.33 ; 16.09,66.74 DT12.6 DT12.5
  TOP w0.508: v2(17.03,65.26) 17.16,65.13 DT2007.1 ; 8.55,71.33 10.38,71.33 12.72,69 14.77,69 v1(16.09,67.67) 16.09,66.74
  IN1 w0.508: v2(21.59,34.48) 21.82,34.71 21.82,35.09 23.45,36.72 24.55,36.72 v2(25.04,37.21)
  IN3 w0.508: v2(21.59,34.48) 21.63,34.52 21.63,35.13 21.19,35.56 17.93,35.56 16.79,36.71 16.79,38 16.3,38.48 16.3,39.37 17.02,40.08 17.02,42.08 18.44,43.5 18.44,46.61 19.1,47.27 19.1,49.2 17.98,50.32 17.98,52.65 16.61,54.02 16.61,55.67 18.42,57.48 18.42,63.2 17.03,64.59 v2(17.03,65.26)
  BOTTOM w0.254: UT5.K10 21.59,34.73 v2(21.59,34.48)
  BOTTOM w0.356: CT353.2 25.43,37.43 25.21,37.21 v2(25.04,37.21)
TBTB_DPSRC_AUX_N_C: length 6.3
  BOTTOM w0.102: UT5.E11 22.54,32.53 22.6,32.46 22.84,32.46 23.04,32.26 23.04,31.94 23.59,31.38 23.98,31.38 RT386.2 24.37,31.78 25.75,31.78 26.05,31.49 26.05,30.62 26.2,30.47 26.73,30.47 RT518.1
TBTB_DPSRC_AUX_P_C: length 5.4
  BOTTOM w0.102: UT5.D11 22.64,32.27 22.76,32.27 22.85,32.19 22.85,31.86 23.51,31.19 23.65,31.19 RT385.2 24.34,30.5 24.68,30.5 24.9,30.28 v1(25.83,30.28) 26.45,30.28 RT524.1
TBTB_HPD: length 49.1
  IN3 w0.081: v2(23.39,32.33) 23.25,32.33 22.79,32.8 22.79,33.23 23.02,33.45 23.84,33.45 23.99,33.61 23.99,36.11 24.52,36.64 25.23,36.64 25.52,36.93 25.52,38.11 23.47,40.17 23.47,56.98 25.04,58.55 28.69,58.55 29.77,59.63 37.84,59.63 v2(38.05,59.83)
  BOTTOM w0.076: 22.76,32.91 22.73,32.93 22.3,32.93 UT5.E10
  BOTTOM w0.102: 22.76,32.91 22.82,32.91 v2(23.39,32.33)
  BOTTOM w0.109: RT33.1 38.47,57.75 RT620.2 38.05,58.71 v2(38.05,59.83) ; RT528.2 23.6,32.12 v2(23.39,32.33)
TBTB_HPD_R: length 8
  BOTTOM w0.109: UT1.T1 39.25,54.05 40.27,55.07 40.27,57.83 39.91,58.18 39.16,58.18 RT620.1 39.05,58.45 38.62,58.88 RT624.2
TBTB_I2C_INT#: length 78.1
  TOP w0.109: v2(37.73,51.08) 37.73,51.31 37.06,51.98 RT17.1
  IN3 w0.081: v2(12.81,33.91) 12.81,33.84 11.91,32.93 11.91,29.44 15.5,25.85 19.26,25.85 21.38,27.97 24.69,27.97 25.87,26.79 26.67,26.79 27.53,27.65 27.53,31.22 28.01,31.7 28.01,38.22 28.76,38.96 30.39,38.96 32.6,41.17 32.6,50.93 31.75,51.78 31.75,53.15 31.02,53.89 31.02,55.7 31.45,56.14 34.71,56.14 35.1,55.74 35.1,55.29 34.52,54.7 34.52,53.96 34.87,53.61 36.57,53.61 37.73,52.46 v2(37.73,51.08)
  BOTTOM w0.076: 16.3,35.65 16.49,35.65 17.22,34.92 17.64,34.92 17.79,34.77 17.79,33.91 18.02,33.68 UT5.G2
  BOTTOM w0.109: 16.3,35.65 14.94,35.65 14.39,35.11 13.39,35.11 v1(13.23,34.95) 13.23,34.33 v2(12.81,33.91) 12.7,33.8 RT515.1 ; v2(37.73,51.08) UT1.M5
TBTB_SBU1: length 59.6
  TOP w0.102: JUSBC1.1B8 6.56,71.93 v2(6.69,72.06)
  IN2 w0.094: v2(13.54,31.96) 13.54,32.29 13.59,32.34 13.83,32.34 13.97,32.47 14.15,32.65 14.15,33.17 13.41,33.9 13.41,35.19 12.69,35.92 12.69,36.64 11.73,37.6 11.73,38.94 10.64,40.03 10.64,45.22 11.45,46.03 13.67,46.03 14.01,46.38 14.01,52.64 13.35,53.3 13.35,54.45 13.84,54.95 13.84,58.58 13.35,59.07 13.35,61.78 14.55,62.98 14.75,62.98 15.55,63.78 15.55,64.04 v2(16.09,64.58)
  BOTTOM w0.102: v2(13.54,31.96) 13.93,32.35 15.06,32.35 15.54,32.83 17.38,32.83 UT5.E1 ; DT2006.1 16.31,64.36 v2(16.09,64.58) DT11.6 DT11.5 16.09,67.41 14.15,69.36 13.09,69.36 10.92,71.53 7.22,71.53 v2(6.69,72.06)
TBTB_SBU2: length 59.9
  TOP w0.102: DT2008.1 13.6,63.6 13.98,63.98 13.98,64.4 v2(14.17,64.58) 14.09,64.66 DT12.1 DT12.9 14.09,67.33 13.84,67.59 13.53,67.59 13.39,67.45 13.39,65.96 13.28,65.86 v1(13.03,65.86) 12.95,65.94 12.95,67.43 12.79,67.59 12.15,67.59 9.49,70.25 8.07,70.25 8,70.18 JUSBC1.1A8
  IN2 w0.094: v2(14.17,64.58) 14.17,63.92 14.3,63.78 14.52,63.78 14.89,64.16 15.26,64.16 15.35,64.06 15.35,63.86 14.67,63.18 14.47,63.18 13.15,61.86 13.15,58.99 13.65,58.5 13.65,55.03 13.15,54.54 13.15,53.22 13.82,52.56 13.82,46.46 13.58,46.23 11.37,46.23 10.45,45.3 10.45,39.95 11.53,38.86 11.53,37.52 12.49,36.56 12.49,35.84 13.22,35.11 13.22,33.82 13.95,33.09 13.95,32.73 13.83,32.61 13.75,32.53 13.63,32.53 13.46,32.7 v2(13.46,32.99)
  BOTTOM w0.102: v2(13.46,32.99) 13.91,32.54 14.98,32.54 15.46,33.02 17.38,33.02 UT5.F1
TBTB_USB2_RBIAS: length 2.7
  TOP w0.109: RT42.2 33.45,43.45 34.65,43.45 v2(35.14,43.94)
  BOTTOM w0.102: UT1.F19 v2(35.14,43.94)
TDOCK_BATLOW#: length 4.6
  BOTTOM w0.076: 39.95,52.77 39.95,52.35 UT1.U2
  BOTTOM w0.109: 39.95,52.77 39.95,53.61 v1(40.54,54.2) 40.85,54.2 41.97,55.32 RT20.1
TEST_PWRGD: length 12
  IN2 w0.081: v2(43.53,45.94) 43.53,46.42 43.15,46.8 40.16,46.8 39.72,47.23 39.72,49.14 39.85,49.27 39.85,49.95 v2(40.34,50.44)
  BOTTOM w0.109: v2(43.53,45.94) 43.53,44.81 43.69,44.66 RT36.1 44.82,44.08 44.82,43.88 v1(45.21,43.49) ; v2(40.34,50.44) UT1.W5
THERMTRIP1#: length 174.1
  TOP w0.109: v2(144.09,79.34) 144.08,79.33 143.72,79.33 143.34,78.95 142.82,78.95 142.69,78.82 142.07,78.82 141.71,78.45 UE1.B12
  VCC w0.086: v2(272.69,83.78) 272.35,83.78 271.64,84.49 255.15,84.49 254.12,83.46 243.32,83.46 242.71,84.07 235.68,84.07 234.03,85.72 230.68,85.72 228.37,88.02 228.37,88.41 226.6,90.18 226.6,90.63 226.3,90.93 224.04,90.93 222.49,92.48 184.01,92.48 179.22,97.27 158.43,97.27 154.96,93.8 154.96,87.06 v2(155.01,87.01)
  IN3 w0.081: v2(281.66,83.81) 279.73,81.88 274.04,81.88 272.69,83.23 v2(272.69,83.78)
  IN4 w0.102: v2(157.38,81.63) 156.55,82.45 156.55,84.81 155.11,86.25 155.11,86.96 155.05,87.01 v2(155.01,87.01)
  BOTTOM w0.109: v2(144.09,79.34) 145.16,78.26 146.16,78.26 146.56,77.87 v1(148.21,77.87) 149.9,77.87 150.54,78.51 154.6,78.51 155.48,77.63 156.26,77.63 156.77,78.14 156.77,80 157.38,80.61 v2(157.38,81.63) ; RV817.2 283.36,84.54 283.16,84.74 QV40.1 282.15,84.3 v2(281.66,83.81)
THERMTRIP2#: length 52.4
  TOP w0.109: UE1.H3 134.08,73.29 v2(134.08,73.25) ; v2(132.38,61.76) 132.38,61.91 132.47,62 CE36.1 132.5,62.46 RE69.2 ; v2(162.54,60.14) 161.99,60.14 161.51,60.62 160.17,60.62 157.41,57.86 151.46,57.86 150.37,58.95 149.67,58.95 148.94,59.68 147.91,59.68 146.44,61.15 144.55,61.15 143.27,62.44 v1(142.06,62.44) 140.45,62.44 v2(140.08,62.07)
  IN1 w0.102: v2(134.08,73.25) 134.08,73.07 134.44,72.71 134.44,70.68 134.21,70.45 134.21,69.47 133.92,69.17 133.92,68.58 134.15,68.35 134.15,67.93 134.73,67.35 135.41,67.35 136.04,66.72 136.04,65.67 136.34,65.37 137.33,65.37 138.61,64.1 138.61,63.54 v2(140.08,62.07)
  IN4 w0.102: v2(132.38,61.76) 132.69,62.07 v2(140.08,62.07)
  BOTTOM w0.109: QE4.1 162.89,59.28 162.89,59.8 v2(162.54,60.14)
TOUCHPAD_INTR#: length 191.1
  TOP w0.102: UH1.BF32 123.27,33.09 122.45,33.09 121.3,31.93
  TOP w0.109: JKBTP1.16 v2(20.84,7.25) ; RE318.1 129.63,74.5 128.94,74.5 128.69,74.75 v2(128.44,74.75) ; v2(116.08,30.62) 116.1,30.65 117.18,30.65 117.67,31.13 RH402.2 117.98,31.13 118.19,30.92 120.21,30.92 120.38,31.09 120.38,31.56 120.75,31.93 121.3,31.93
  IN1 w0.102: v2(116.08,30.62) 116.08,31.26 115.12,32.22 115.12,35.04 115.67,35.59 115.67,37.5 115.14,38.03 115.14,38.51 114.83,38.81 114.83,40.85 114.56,41.13 114.56,43.62 115.37,44.44 115.37,46.81 114.07,48.1 114.07,51.01 112.75,52.33 112.75,60.63 112.29,61.09 112.29,62.44 111.26,63.46 111.26,66.63 112.4,67.77 112.4,68.32 112.35,68.37 112.35,70.26 113.08,70.99 113.08,74.09 v2(113.54,74.54)
  IN2 w0.081: v2(20.84,7.25) 21.04,7.25 24.47,10.68 28.78,10.68 29.44,11.34 31.42,11.34 33.53,9.24 34.69,9.24 35.06,9.6 35.06,11.05 37.23,13.22 38.11,13.22 40.91,16.02 47.66,16.02 47.87,16.24 50.98,16.24 52.51,14.71 54.38,14.71 55.73,16.06 56.23,16.06 56.49,15.8 56.49,15.38 57.15,14.71 58.8,14.71 60.59,12.92 76.29,12.92 82.32,18.95 84.68,18.95 85.37,19.64 87.83,19.64 88.78,20.59 88.78,21.28 89.09,21.59 90.94,23.43 95.73,23.43 99.15,26.86 99.15,27.57 99.47,27.89 100.31,27.89 100.53,28.11 109.89,28.11 111.34,26.66 111.8,26.66 112.05,26.91 113.48,26.91 113.64,27.07 113.64,27.63 113.07,28.19 113.07,28.75 113.66,29.35 113.98,29.35 115.13,30.5 115.95,30.5 v2(116.08,30.62)
  IN4 w0.102: v2(128.44,74.75) 128.33,74.86 121.09,74.86 121,74.77 118.25,74.77 118.01,75.01 114.97,75.01 114.5,74.54 v2(113.54,74.54)
  BOTTOM w0.109: v1(20.24,7.52) 20.51,7.25 v2(20.84,7.25)
TP_LAN_JTAG_TCK: length 3.9
  TOP w0.109: UL1.35 149.04,138.03 RL2.2 148.64,137.67 148.13,138.18 v1(146.73,138.18)
TP_LAN_JTAG_TDI: length 1.4
  TOP w0.109: v2(151,139.2) 150.91,139.2 150.88,139.23 UL1.32
  BOTTOM w0.109: v2(151,139.2) 150.68,139.2 T73.1
TP_LAN_JTAG_TDO: length 4.6
  TOP w0.109: UL1.34 151.05,138.43 v2(151.09,138.4)
  BOTTOM w0.109: T74.1 149.88,140.4 149.88,138.77 150.33,138.32 151,138.32 v2(151.09,138.4)
TP_LAN_JTAG_TMS: length 1.6
  TOP w0.109: RL1.2 148.7,138.83 v2(149.3,138.83) UL1.33
TP_SKL_E30: length 5.6
  TOP w0.109: UC1.E30 252.92,65.35 v2(252.59,65.68)
  BOTTOM w0.109: v2(252.59,65.68) 252.59,66.5 252.42,66.67 252.42,69.26 252.02,69.66 T281.1
TP_SKL_F30: length 6.2
  TOP w0.109: UC1.F30 252.92,64.7 v2(252.59,65.03)
  BOTTOM w0.102: v2(252.59,65.03) 252.99,65.43 252.99,66.07 252.92,66.14 252.92,66.78 252.77,66.94 252.77,68.79
  BOTTOM w0.109: T285.1 253.41,69.44 252.77,68.79
TPM_GPIO0: length 2.8
  BOTTOM w0.109: UZ12.29 139.8,20.46 139.77,20.49 139.77,21.25 139.77,21.26 RZ112.2 v1(140.76,21.66)
TPM_GPIO4: length 1.7
  BOTTOM w0.109: T284.1 139.3,13.15 UZ12.13
TPM_LPM#: length 2.8
  BOTTOM w0.109: UZ12.3 142.73,18.04 143.07,18.38 143.07,19.26 RZ363.2
TPM_PIRQ#: length 18.3
  IN1 w0.102: v2(136.05,23.75) 135.62,23.32 135.62,20.7 134.95,20.03 134.95,15.15 v2(135.23,14.87)
  BOTTOM w0.109: RC560.2 135.13,26.04 135.1,26.06 RC561.2 134.4,25.94 v1(134.4,25.11) 134.4,23.62 134.77,23.26 135.56,23.26 v2(136.05,23.75) ; RZ69.2 135.23,14.54 v2(135.23,14.87) 135.48,14.87 136.65,16.04 UZ12.18
TPM_PIRQ#_R: length 27.9
  TOP w0.084: UH1.BD29 124.21,34.91 124.02,35.1 123.29,35.1 123.12,34.94 123.12,34.93 122.62,34.43 121.9,34.43 121.57,34.1 v2(120.93,34.1)
  IN1 w0.102: v2(134.95,23.75) 134.53,24.17 134.53,25.23 133.96,25.8 127.98,25.8 127.26,26.52 127.26,27.8 127.43,27.97 127.43,28.4 126.71,29.12 125.68,29.12 125.52,28.97 125.07,28.97 124.37,29.67 122.51,29.67 121.51,30.67 121.51,33.79 121.2,34.1 v2(120.93,34.1)
  BOTTOM w0.109: RC560.1 135.43,24.78 135.43,24.23 v2(134.95,23.75)
TPM_TYPE: length 2.7
  TOP w0.109: v2(126.29,33.31) 126.37,33.24 UH1.AW32
  BOTTOM w0.109: v1(125.37,32.54) 126.53,32.54 RH379.1 126.66,32.94 v2(126.29,33.31)
TRIP_+1VSP: length 3.4
  TOP w0.109: v1(104.53,26.63) 105.2,26.63 PR801.2
  TOP w0.254: PR801.2 105.46,27.17 105.74,27.45 106.5,27.45 106.67,27.61 PU800.2
TSENSE_2PH: length 3.5
  TOP w0.203: PR1166.1 PC1129.1 298.09,40.15 v1(298.89,40.15) 299.24,40.15 299.64,40.55 PU1100.25
TSENSE_4PH: length 5
  TOP w0.203: PU1100.14 299.93,44.95 v1(298.57,46.3) 298.38,46.5 298.14,46.5 v2(297.89,46.75)
  BOTTOM w0.203: PR1165.1 PC1127.1 297.63,46.5 v2(297.89,46.75)
TYPEC_CON_SEL1: length 8.3
  TOP w0.109: v2(126.86,36.63) 126.86,36.82 126.37,37.31 UH1.BA24
  BOTTOM w0.109: v1(131.88,36.02) 131.88,36.55 131.68,36.74 131.15,36.74 130.16,35.75 RH556.1 128.93,35.75 128.45,36.24 127.34,36.24 RH555.1 126.95,36.54 v2(126.86,36.63)
TYPEC_CON_SEL2: length 16.9
  TOP w0.109: v2(129.18,37.92) 129.15,37.89 UH1.AP24
  BOTTOM w0.109: RH554.1 RH553.1 120.11,38.9 120.51,38.51 122.7,38.51 123.78,39.6 123.78,40.5 124.13,40.85 v1(124.37,40.85) 124.49,40.85 124.67,40.67 125.16,40.67 126.65,40.05 126.98,39.72 127.48,39.72 127.58,39.82 129.38,39.82 129.71,40.15 130.07,40.15 130.31,39.91 130.31,38.46 130.07,38.22 129.47,38.22 v2(129.18,37.92)
TYPEC_ID: length 29.8
  TOP w0.109: v2(147.93,62.35) v1(148.45,62.35) ; UE1.F2 v2(133.27,75.62)
  IN1 w0.102: v2(147.93,62.35) 147.87,62.35 147.22,61.7 146.61,61.7 145.71,62.6 139.87,62.6 138.83,63.64 138.83,64.19 138.38,64.65 138.38,66.08 138.17,66.28 137.77,66.28 137.33,66.72 136.36,66.72 135.36,67.72 135.36,68.31 135.01,68.66 135.01,69.3 134.46,69.85 134.46,70.29 134.67,70.5 135.1,70.5 135.25,70.65 135.25,72.66 135.02,72.89 134.66,72.89 134.5,73.05 134.5,73.41 134.23,73.67 133.9,73.67 133.68,73.89 133.68,75.21 v2(133.27,75.62)
  BOTTOM w0.109: CE62.1 149.38,62.09 RE343.2 148.21,62.63 v2(147.93,62.35)
UART2_RXD: length 143.5
  TOP w0.102: UH1.BD20 124.47,38.86 123.77,38.86 123.6,39.03 123.06,39.03 122.84,39.25 122.45,39.25 122.15,39.55 121.55,39.55 121.55,39.55 121.17,39.55 120.94,39.32 120.94,38.45 120.39,37.9 118.62,37.9 118.47,37.75 117.4,37.75 116.86,38.28 RH361.2
  TOP w0.109: v2(117.72,39.27) 117.72,39.25 RH361.2
  IN3 w0.081: v2(118.42,45.5) 117.56,44.63 117.56,39.43 v2(117.72,39.27)
  IN4 w0.102: v2(118.42,45.5) 118.07,45.5 117.44,46.13 116.12,46.13 115.92,45.93 115.43,45.93 115.01,45.51 114.01,45.51 113.49,46.03 113.49,50.32 109.65,54.17 107.81,54.17 104.54,57.44 96.78,57.44 95.31,55.97 93.26,55.97 90.39,53.1 85.44,53.1 84.76,52.42 82.73,52.42 82.04,51.73 81.4,51.73 81.02,51.35 68.75,51.35 67.89,50.48 64.08,50.48 63.78,50.19 59.24,50.19 57.53,48.48 53.54,48.48 52.98,49.04 49.96,49.04 42.24,41.32 38.76,41.32 38.63,41.44 37.54,41.44 37.41,41.32 36.69,41.32 36.15,41.86 33.31,41.86 31.33,39.88 27.92,39.88 26.8,41 26.19,41 24.81,42.38 23.06,42.38 22.42,41.74 19.74,41.74 18.26,43.22 18.26,46.92 17.61,47.57 v2(17.61,47.75)
  BOTTOM w0.109: v1(117.82,46.38) 117.82,45.86 118.18,45.5 v2(118.42,45.5) ; v2(17.61,47.75) 17.57,47.72 RT552.2 17.13,47.11 RH376.2
UART2_TXD: length 160.6
  TOP w0.102: v2(121.93,40.12) 121.96,40.13 122.28,39.97 122.61,39.64 123.31,39.64 123.37,39.69 123.74,39.69 123.89,39.55 123.89,39.3 UH1.BE20
  TOP w0.109: RH360.2 117.35,39.68 118.03,39.68 118.59,39.12 118.59,38.39 118.68,38.29 120.22,38.29 120.51,38.58 120.51,39.45 121.01,39.95 121.58,39.95 121.75,40.11 121.93,40.11 v2(121.93,40.12) ; v2(87.32,53.55) 89.09,51.78 89.09,43.39 88.21,42.51 88.21,40.34 89.04,39.51 93.62,39.51 93.8,39.33 93.8,36.59 94.31,36.08 94.31,33.84 94.56,33.58 94.56,28.27 94.93,27.9 v1(94.93,27.76) v2(94.93,26.78)
  IN2 w0.081: v2(121.93,40.12) 121.93,40.11 121.86,40.11 121.47,39.72 120.85,39.72 120.79,39.67 118.19,39.67 117.66,40.19 114.36,40.19 113.74,39.58 112.99,39.58 107.91,34.49 103.94,34.49 102.39,32.94 102.39,31.95 102.06,31.61 101.61,31.61 101.19,31.19 101.02,31.19 99.64,29.81 98.17,29.81 95.97,27.61 95.52,27.61 94.93,27.03 v2(94.93,26.78)
  IN4 w0.102: v2(18.21,47.75) 18.49,47.47 18.49,43.32 19.84,41.97 22.32,41.97 22.96,42.61 24.9,42.61 25.74,41.77 26.31,41.77 27.05,42.51 29.14,42.51 30.16,41.48 30.16,41.41 30.81,40.76 31.78,40.76 33.07,42.05 36.29,42.05 36.8,41.54 37.31,41.54 37.49,41.72 38.73,41.72 38.91,41.54 41.17,41.54 42.9,43.27 43.66,43.27 49.96,49.57 52.16,49.57 52.39,49.8 58.05,49.8 58.69,50.43 59.77,50.43 61.07,51.73 63.74,51.73 64.13,51.34 65.86,51.34 66.1,51.58 80.56,51.58 81.12,52.14 81.84,52.14 82.95,53.25 84.22,53.25 84.52,53.55 v2(87.32,53.55)
  BOTTOM w0.109: v2(18.21,47.75) RT551.2 18.68,47.11 RH330.2
UART2RXD: length 3.4
  BOTTOM w0.109: JCCG1.9 18.33,45.66 17.83,46.16 17.83,46.27 RT552.1 17.31,46.26 17.31,46.04 v1(16.84,45.57)
UART2TXD: length 2.1
  BOTTOM w0.109: RT551.1 18.21,46.12 18.83,45.5 JCCG1.8
UG_1.2V: length 13.1
  IN1 w0.762: 117.02,12.16 117.29,12.16 123.34,6.11 123.34,2.38
  BOTTOM w0.109: v1(116.09,12.04) 115.84,12.29 v2(115.63,12.29)
  vias: v2(115.97,12.79) v2(123.95,1.32) v2(124.64,1.35)
UG_+1VSP: length 11.6
  TOP w0.254: v2(106.42,31.93) 106.47,31.93 106.67,31.73 PU800.9
  IN3 w0.762: 105.44,32.74 105.44,33.59 103.14,35.89 103.14,39.54 101.01,41.67
  vias: v1(99.95,42.5) v2(100.85,42.79) v2(100.84,42.2) v2(106.04,32.4)
UGATE_CHG: length 28.5
  TOP w0.203: v2(73,23.54) 72.9,23.63 PU700.26
  IN4 w0.508: v2(73,23.54) 73,23.28 73.4,22.87 76.02,22.87 89.02,9.87 v2(93.42,9.87) v2(94.12,9.87)
  BOTTOM w0.109: v2(73,23.54) v1(73,24.2)
UIM_CLK: length 77
  IN3 w0.081: v2(155.22,128.89) 153.76,130.35 150.57,130.35 146.29,134.64 145.21,134.64 143.82,136.03 143.22,136.03 138.53,140.72 132.81,140.72 129.18,144.35 129.18,155.18 130.63,156.63 130.63,161.39 129.86,162.17 128.86,162.17 v2(128.41,162.63)
  BOTTOM w0.109: v2(128.41,162.63) 128.41,162.43 CZ38.1 127.59,161.61 127.01,161.61 v1(126.76,161.36) 124.9,159.5 JSIM1.4 ; JNGFF2.24 152.99,116.43 152.85,116.57 151.88,116.57 151.17,117.28 151.17,121.59 151.88,122.3 151.88,127.7 152.83,128.65 154.98,128.65 v2(155.22,128.89)
UIM_DATA: length 74.9
  IN3 w0.081: v2(128.48,161.32) 128.89,161.72 129.73,161.72 130.22,161.23 130.22,156.8 128.77,155.34 128.77,144.18 132.64,140.31 138.39,140.31 144.99,133.72 146.67,133.72 150.41,129.97 153.43,129.97 v2(155.22,128.17)
  BOTTOM w0.109: v2(155.22,128.17) 155.16,128.23 153,128.23 152.3,127.53 152.3,122.13 151.59,121.42 151.59,117.45 152.05,116.99 153.02,116.99 153.49,116.52 JNGFF2.26 ; v2(128.48,161.32) 128.48,161.22 CZ39.1 127.02,160.7 125.6,159.27 JSIM1.3
UIM_RESET: length 66.6
  IN3 w0.081: v2(150.5,128.18) 149.97,128.18 138.23,139.93 132.45,139.93 128.36,144.01 128.36,154.06 126.92,155.5 126.92,159.36 v2(124.94,161.34)
  BOTTOM w0.109: v2(150.5,128.18) 150.73,128.18 151.43,127.48 151.43,122.44 150.76,121.76 150.76,117.11 151.84,116.03 151.84,115.84 152.49,115.19 JNGFF2.22 ; JSIM1.6 123.5,159.36 124.14,160 124.14,160.81 CZ40.1 124.56,160.96 v2(124.94,161.34) 125.32,160.96 v1(125.32,160.75)
USB2_A_DE0: length 2.3
  BOTTOM w0.109: UI4.16 v1(380.72,51.45) 380.08,50.81 RI63.2
USB2_A_DE1: length 3.7
  BOTTOM w0.109: UI4.18 379.72,52.19 379.44,51.91 379.17,51.91 378.56,51.3 RI65.2 v1(377.56,50.52)
USB2_A_EQ0: length 2.6
  BOTTOM w0.109: RI64.2 379.24,50.6 379.24,51.33 v1(379.38,51.48) 379.49,51.48 380.22,52.21 UI4.17
USB2_A_EQ1: length 2.2
  BOTTOM w0.109: UI4.15 381.22,51.27 380.84,50.89 RI62.2
USB2_B_DE0: length 1.7
  BOTTOM w0.109: RI72.2 380.72,57.99 UI4.3
USB2_B_DE1: length 2.9
  BOTTOM w0.109: UI4.6 382.22,57.2 382.13,57.29 382.13,57.57 382.75,58.19 RI74.2 v1(383.75,58.24)
USB2_B_EQ0: length 1.8
  BOTTOM w0.109: RI73.2 379.7,57.74 v2(379.84,57.6) 380.22,57.22 UI4.2
USB2_B_EQ1: length 1.6
  BOTTOM w0.109: UI4.4 381.22,57.2 381.14,57.28 v2(381.14,57.48) 381.22,57.57 RI69.2
USB2_COMP: length 4.8
  TOP w0.109: UH1.F4 143.21,47.68 143.21,48.24 143.18,48.28 143.18,48.74 143.18,48.74 143.49,49.05 143.61,49.05 144.42,49.87 144.42,50.92 144.27,51.07 RH193.1
USB2_ID: length 6.2
  TOP w0.109: UH1.G3 143.01,47.75 143.01,48.16 142.98,48.19 142.98,49.08 v2(143.08,49.18)
  BOTTOM w0.109: v1(142.67,48.52) 143.08,48.92 v2(143.08,49.18) 142.87,49.38 142.87,52.52 RH365.1
USB2_TEST: length 2.4
  BOTTOM w0.109: UI4.14 381.72,51.83 v1(382.04,51.51) 382.04,50.96 RI66.2
USB2_VBUSSENSE: length 5.5
  TOP w0.109: UH1.F3 143.52,48.25 143.38,48.39 143.38,48.66 143.56,48.83 143.67,48.83 145.01,50.17 v2(145.01,50.84)
  BOTTOM w0.109: RH364.1 145.01,51.26 v2(145.01,50.84) 145.01,50.1 v1(145.16,49.95)
USB3_A_DE0: length 2.3
  TOP w0.109: v2(384.28,41.04) 384.28,41.58 v1(384.25,41.61)
  BOTTOM w0.254: RI81.2 384.28,40.24 v2(384.28,41.04) UI5.16
USB3_A_DE1: length 3.1
  BOTTOM w0.109: RI83.2 v1(381.44,40.24)
  BOTTOM w0.254: UI5.18 383.28,41.17 382.49,40.39 RI83.2
USB3_A_EQ0: length 2.7
  TOP w0.109: v1(383,41.26) 383.39,40.88 v2(383.68,40.88)
  BOTTOM w0.254: RI80.2 383.38,40.59 v2(383.68,40.88) 383.78,40.98 UI5.17
USB3_A_EQ1: length 2.6
  TOP w0.109: v2(385.01,41.07) 385.3,41.07 v1(385.63,41.4)
  BOTTOM w0.254: UI5.15 384.78,41.31 v2(385.01,41.07) 385.16,40.92 RI78.2
USB3_B_DE0: length 4.2
  BOTTOM w0.109: v1(384.83,49.91) 384.71,49.79 384.71,48.21 384.24,47.75 RI88.2 384.24,46.99 384.28,46.95 UI5.3
USB3_B_DE1: length 3.5
  BOTTOM w0.109: v1(388.1,48.11) 387.63,47.64 RI90.2 386.94,47.64 385.78,46.48 UI5.6
USB3_B_EQ0: length 4.1
  BOTTOM w0.109: v1(383.56,49.56) 382.98,48.97 382.98,48.1 RI89.2 383.78,47.31 UI5.2
USB3_B_EQ1: length 4.5
  BOTTOM w0.109: v1(386.15,49.9) 385.63,49.37 385.63,48.1 RI86.2 384.78,47.25 UI5.4
USB3_PRX_C_RD_DTX_N1: length 3.9
  BOTTOM w0.102: UI4.23 378.52,55.39 378.36,55.23 377.95,55.23 377.86,55.15 377.8,55.15 377.38,54.73 377.38,54.66 377.2,54.48 377.2,53.94 377.04,53.78 376.49,53.78 CI67.2
USB3_PRX_C_RD_DTX_N3: length 2.6
  BOTTOM w0.102: CI75.2 380.43,44.51 380.93,44.51 380.97,44.55 381.5,44.55 381.51,44.57 381.94,44.57 382.1,44.72 UI5.23
USB3_PRX_C_RD_DTX_P1: length 3.9
  BOTTOM w0.102: CI66.2 376.49,53.59 377.12,53.59 377.39,53.87 377.39,54.4 v3(377.76,54.77) 378.03,55.04 378.43,55.04 378.59,54.89 UI4.22
USB3_PRX_C_RD_DTX_P3: length 2.6
  BOTTOM w0.102: CI74.2 380.43,44.32 v3(381.26,44.32) 381.52,44.32 381.57,44.37 381.98,44.37 382.13,44.22 UI5.22
USB3_PRX_DTX_N1: length 287.3
  TOP w0.076: 148.4,43.93 148.39,43.92 148.36,43.92 148.05,43.6 145.25,43.6 145.06,43.41 144.59,43.41 144.58,43.41 144.58,43.4 144.46,43.28 144.15,43.28 144.02,43.4 UH1.D11
  TOP w0.102: v2(150.21,45.15) 150.04,44.97 150.04,44.63 149.67,44.26 148.73,44.26 148.4,43.93
  IN2 w0.094: v2(374.59,54.12) 374.59,54 374.3,53.71 373.51,53.71 369.99,50.19 369.99,41.86 366.79,38.66 357.12,38.66 352.2,33.74 346.09,33.74 336.83,24.48 322.06,24.48 316.75,19.16 316.47,19.16 307.78,10.47 295.97,10.47 292.88,7.38 256.4,7.38 254.74,9.04 246.53,9.04 243.8,6.31 171.53,6.31 158.87,18.97 158.87,28.19 158.05,29.01 157.07,29.01 156.24,29.84 156.24,33.03 154.07,35.2 154.07,41.9 151.46,44.52 150.09,44.52 149.95,44.66 149.95,45.13 150.03,45.21 150.15,45.21 v2(150.21,45.15)
  BOTTOM w0.102: v2(374.59,54.12) 374.6,54.12 374.88,53.84 375.27,53.84 CI67.1
USB3_PRX_DTX_N2: length 72.5
  TOP w0.076: UH1.B9 144.97,44.59 145.59,44.59 145.6,44.6 146.37,44.6 147.44,45.66 147.88,45.66 147.9,45.64 147.92,45.64
  TOP w0.102: v2(149.37,46.32) 149.17,46.32 149.02,46.17 149.02,45.93 148.73,45.64 147.92,45.64
  IN1 w0.102: v2(149.37,46.32) 149.25,46.44 149.17,46.44 149.02,46.3 149.02,46 149.21,45.81 150.21,45.81 151.04,46.64 151.04,56.09 154.35,59.4 154.35,61.5 156.21,63.35 156.21,64.21 153.66,66.76 153.66,67.81 154.05,68.2 154.05,70.78 153.11,71.72 153.11,71.75 153.1,71.77 153.1,74.7 151.55,76.25 151.55,93.39 154.88,96.71 154.88,98.56 154.19,99.25 152.39,99.25 152.14,99.49 152.14,100.02 151.94,100.23 151.83,100.23 v2(151.74,100.14)
  BOTTOM w0.102: v2(151.74,100.14) 152.11,100.5 152.11,100.96 151.82,101.25 LI16.3 151.82,101.89 RI28.1
USB3_PRX_DTX_N3: length 283
  TOP w0.076: 147.09,44.04 147.07,44.04 147.04,44.07 144.66,44.07 144.55,43.97 144.55,43.9 144.6,43.85 UH1.B10
  TOP w0.102: v2(148.56,45.13) 148.38,44.94 148.38,44.76 147.95,44.32 147.83,44.21 147.66,44.04 147.09,44.04
  IN2 w0.094: v2(148.56,45.13) 148.49,45.19 148.32,45.19 148.23,45.1 148.23,43.88 149.19,42.93 150.58,42.93 150.86,42.65 151.87,42.65 153.42,41.1 153.42,35.01 154.9,33.53 154.9,26.94 158.16,23.68 158.16,18.84 171.28,5.72 244.07,5.72 246.77,8.42 254.42,8.42 256.75,6.09 268.01,6.09 268.35,6.43 292.77,6.43 296.22,9.88 309.07,9.88 321.27,22.07 333.39,22.07 334.15,22.83 336.02,22.83 346.32,33.13 352.51,33.13 355.73,36.35 357.94,36.35 359.66,38.07 366.85,38.07 367.71,37.21 370.84,37.21 378.12,44.49 378.26,44.49 v2(378.54,44.77)
  BOTTOM w0.102: CI75.1 379.15,44.51 378.81,44.51 v2(378.54,44.77)
USB3_PRX_DTX_N4: length 159.6
  TOP w0.102: JUSB3.5 116.42,163 116.52,162.9 116.52,162.31 116.05,161.84 115.14,161.84 114.61,161.3 112.83,161.3 112.03,160.5 112.03,158.64 111.87,158.48 DI4.9 DI4.1 111.87,157.09 112.03,156.94 112.03,156.79 111.56,156.32 111.56,155.88 v2(111.3,155.62) ; v2(140.92,41.95) 140.93,41.95 UH1.K16
  IN4 w0.102: v2(111.3,155.62) 111.54,155.38 111.54,155.02 111.7,154.87 111.7,150.58 114.76,147.52 114.76,144.75 114.54,144.53 114.54,140.13 113.97,139.57 113.97,135.31 121.23,128.05 121.23,120.4 121.68,119.95 121.68,117.82 125.76,113.74 125.76,112.67 125.08,111.99 125.08,107.95 125.65,107.37 125.65,105.76 125.99,105.42 125.99,100.38 127.39,98.99 127.39,95.01 135.14,87.26 139.44,87.26 140.29,86.41 143.53,86.41 144.4,85.55 146.7,85.55 148.27,83.98 148.27,83.37 148.77,82.87 148.77,81.19 150.23,79.73 150.23,66.63 149.68,66.08 149.68,62.77 150.97,61.48 150.97,61.15 150.04,60.22 148.74,60.22 144.17,55.65 143.16,55.65 141.11,53.6 139.88,53.6 139.37,53.09 139.37,48.83 140.22,47.98 140.22,46.83 139.36,45.98 139.36,45.41 138.7,44.74 138.7,43.79 139.91,42.58 140.84,42.58 141.08,42.34 141.08,42.1 v2(140.92,41.95)
USB3_PRX_DTX_P1: length 287.3
  TOP w0.076: UH1.C11 144.15,43.49 144.09,43.56 144.09,43.62 144.19,43.72 144.44,43.72 144.45,43.71 144.46,43.71 144.58,43.58 144.58,43.58 144.59,43.56 145,43.56 145.19,43.76 147.99,43.76 148.25,44.03 148.25,44.05 148.27,44.07
  TOP w0.102: 148.27,44.07 148.65,44.45 149.59,44.45 149.85,44.71 149.85,45.15 149.78,45.21 149.64,45.21 v2(149.58,45.15)
  IN2 w0.094: v2(374.7,53.36) 374.55,53.52 373.59,53.52 370.18,50.11 370.18,41.78 366.87,38.47 357.2,38.47 352.28,33.54 346.17,33.54 336.91,24.28 322.14,24.28 316.83,18.97 316.55,18.97 307.86,10.28 296.06,10.28 292.96,7.19 256.32,7.19 254.66,8.85 246.61,8.85 243.88,6.12 171.45,6.12 158.68,18.89 158.68,28.1 157.97,28.81 156.99,28.81 156.05,29.76 156.05,32.95 153.88,35.12 153.88,41.82 151.38,44.32 150.01,44.32 149.75,44.57 149.75,44.98 v2(149.58,45.15)
  BOTTOM w0.102: v2(374.7,53.36) 374.7,53.5 374.85,53.65 375.16,53.65 CI66.1
USB3_PRX_DTX_P2: length 72.5
  TOP w0.076: 147.92,45.83 147.9,45.83 147.88,45.81 147.38,45.81 146.31,44.75 145.53,44.75 145.53,44.74 144.79,44.74 UH1.C9
  TOP w0.102: v2(148.66,46.32) 148.83,46.15 148.83,46 148.66,45.83 147.92,45.83
  IN1 w0.102: v2(148.66,46.32) 148.84,46.14 148.84,45.92 149.13,45.62 150.29,45.62 151.23,46.56 151.23,56.01 154.54,59.32 154.54,61.42 156.4,63.27 156.4,64.29 153.85,66.84 153.85,67.73 154.24,68.12 154.24,70.86 153.3,71.8 153.3,71.83 153.29,71.85 153.29,74.78 151.74,76.32 151.74,93.31 155.06,96.64 155.06,98.64 154.27,99.44 152.47,99.44 152.33,99.57 152.33,99.91 v2(152.6,100.18)
  BOTTOM w0.102: RI27.1 152.67,101.89 LI16.2 152.67,101.25 152.3,100.88 152.3,100.48 v2(152.6,100.18)
USB3_PRX_DTX_P3: length 283
  TOP w0.076: 147.09,44.23 147.07,44.23 147.07,44.22 144.59,44.22 144.38,44.01 UH1.C10
  TOP w0.102: v2(147.85,45.13) 147.93,45.21 148.1,45.21 148.19,45.13 148.19,44.83 147.58,44.23 147.09,44.23
  IN2 w0.094: v2(147.85,45.13) 148.04,44.94 148.04,43.8 149.11,42.73 150.5,42.73 150.77,42.46 151.79,42.46 153.23,41.02 153.23,34.93 154.63,33.52 154.63,33.52 154.71,33.44 154.71,26.86 157.97,23.6 157.97,18.76 171.2,5.52 244.15,5.52 246.85,8.22 254.34,8.22 256.67,5.89 268.09,5.89 268.43,6.23 292.85,6.23 296.3,9.68 309.16,9.68 321.35,21.88 333.47,21.88 334.23,22.64 336.11,22.64 346.4,32.93 352.59,32.93 355.81,36.15 358.02,36.15 359.74,37.87 366.77,37.87 367.63,37.02 370.92,37.02 378.2,44.3 378.3,44.3 v2(378.54,44.06)
  BOTTOM w0.102: v2(378.54,44.06) 378.81,44.32 379.15,44.32 CI74.1
USB3_PRX_DTX_P4: length 159.6
  TOP w0.102: JUSB3.6 116.82,163 116.72,162.9 116.72,162.23 116.13,161.65 115.22,161.65 114.69,161.11 112.91,161.11 112.22,160.42 112.22,158.63 112.37,158.48 DI4.8 DI4.2 112.37,157.05 112.22,156.9 112.22,156.71 111.75,156.24 111.75,155.88 v2(112.02,155.62) ; UH1.J15 v2(141.66,42.18)
  IN4 w0.102: v2(141.66,42.18) 141.5,42.18 140.91,42.77 139.99,42.77 138.88,43.87 138.88,44.66 139.55,45.33 139.55,45.9 140.41,46.76 140.41,48.06 139.56,48.91 139.56,53.01 139.96,53.41 141.19,53.41 143.24,55.46 144.24,55.46 148.81,60.03 150.11,60.03 151.15,61.07 151.15,61.56 149.87,62.84 149.87,66 150.42,66.55 150.42,79.81 148.95,81.27 148.95,82.95 148.46,83.44 148.46,84.05 146.77,85.74 144.48,85.74 143.61,86.6 140.37,86.6 139.52,87.45 135.22,87.45 127.58,95.09 127.58,99.06 126.18,100.46 126.18,105.49 125.84,105.84 125.84,107.45 125.27,108.02 125.27,111.92 125.95,112.6 125.95,113.82 121.87,117.9 121.87,120.03 121.42,120.48 121.42,128.13 114.16,135.39 114.16,139.49 114.73,140.06 114.73,144.45 114.95,144.67 114.95,147.6 111.89,150.66 111.89,154.94 111.73,155.1 111.73,155.34 v2(112.02,155.62)
USB3_PRX_L_DTX_N2: length 4.5
  BOTTOM w0.102: JNGFF2.21 152.24,106.23 152.4,106.06 152.4,105.32 152.17,105.08 v3(152.17,104.74) 152.17,103.84 151.82,103.49 LI16.4 151.82,102.89 RI28.2
USB3_PRX_L_DTX_P2: length 4.5
  BOTTOM w0.102: RI27.2 152.67,102.89 LI16.1 152.67,103.49 152.36,103.8 152.36,104.41 152.4,104.45 152.4,105.04 152.59,105.24 152.59,106.06 152.74,106.21 JNGFF2.23
USB3_PRX_RD_DTX_N1: length 19.8
  BOTTOM w0.109: JUSB1.5 394.14,65.22 393.52,65.22 392.59,64.29 392.59,62.6 390.68,60.69 390.68,56.35 390.23,55.9 390.08,55.9 390.07,55.89 DI1.1 DI1.9 387.55,55.89 387.05,55.4 v3(385.98,55.4) 383.72,55.4 383.72,55.39 UI4.8
USB3_PRX_RD_DTX_N3: length 12.3
  BOTTOM w0.109: UI5.8 387.27,44.72 387.28,44.73 389.44,44.73 390.19,43.98 390.19,43.96 390.2,43.95 DI6.9 DI6.1 392.23,43.95 392.24,43.96 v3(392.97,43.96) 393.26,43.96 394.04,43.19 394.04,40.65 394.38,40.31 394.77,40.31 394.92,40.47 JUSB2.5
USB3_PRX_RD_DTX_P1: length 19.8
  BOTTOM w0.109: UI4.9 383.72,54.89 383.72,54.88 387.27,54.88 387.76,55.37 388.59,55.37 DI1.8 DI1.2 390.07,55.39 390.08,55.38 390.45,55.38 391.2,56.13 v3(391.2,56.81) 391.2,60.48 393.11,62.39 393.11,64.08 393.73,64.7 394.22,64.7 JUSB1.6
USB3_PRX_RD_DTX_P3: length 12.3
  BOTTOM w0.109: JUSB2.6 394.92,39.64 394.76,39.8 394.17,39.8 393.52,40.44 393.52,42.97 393.05,43.45 392.24,43.45 392.23,43.45 DI6.2 DI6.8 389.98,43.45 389.23,44.21 v3(388.36,44.21) 387.28,44.21 387.27,44.22 UI5.9
USB3_PTX_C_DRX_N1: length 13.7
  BOTTOM w0.109: JUSB1.8 394.18,59.26 393.65,59.26 393.12,58.73 393.12,55.52 392,54.4 v3(391.08,54.4) 389.48,54.4 DI1.4 DI1.7 388.59,54.4 388.01,54.4 387.39,53.78 385.97,53.78 CI64.1
USB3_PTX_C_DRX_N2: length 2.1
  BOTTOM w0.102: CZ28.2 153.81,100.4 153.81,100.97 153.47,101.32 LI17.3 153.47,101.89 RI29.1
USB3_PTX_C_DRX_N3: length 13.1
  BOTTOM w0.109: CI73.1 389.71,42.46 390.35,42.46 390.35,42.45 DI6.7 391.06,42.45 391.07,42.46 391.22,42.46 391.23,42.45 DI6.4 391.84,42.47 392.39,42.47 392.91,41.95 v3(392.91,39.13) 392.91,35.26 393.85,34.32 394.19,34.32 JUSB2.8
USB3_PTX_C_DRX_N4: length 16.5
  TOP w0.102: CI16.1 113.41,156.22 113.41,156.64 113.53,156.76 113.53,156.88 113.37,157.03 DI4.4 DI4.7 113.37,158.69 113.53,158.85 113.53,159.69 113.87,160.02 114.6,160.02 114.64,159.99 v3(115.91,159.99) 116.34,159.99 116.75,160.4 116.75,161.4 117.37,162.02 122.32,162.02 122.53,162.22 122.53,162.9 122.42,163 JUSB3.8
USB3_PTX_C_DRX_P1: length 13.7
  BOTTOM w0.109: JUSB1.9 394.18,58.74 393.87,58.74 393.64,58.51 393.64,55.31 392.21,53.88 389.64,53.88 389.63,53.89 DI1.5 DI1.6 388.6,53.89 388.59,53.88 388.22,53.88 387.61,53.26 v3(386.88,53.26) 385.89,53.26 CI63.1
USB3_PTX_C_DRX_P2: length 2.1
  BOTTOM w0.102: RI30.1 154.32,101.89 LI17.2 154.32,101.33 154,101.01 154,100.5 CZ29.2
USB3_PTX_C_DRX_P3: length 13.2
  BOTTOM w0.109: JUSB2.9 394.17,33.8 393.64,33.8 392.39,35.05 v3(392.39,40.62) 392.39,41.74 392.18,41.95 DI6.5 391.23,41.95 391.22,41.95 390.96,41.95 DI6.6 390.35,41.95 390.35,41.95 389.81,41.95 CI71.1
USB3_PTX_C_DRX_P4: length 16.5
  TOP w0.102: CI13.1 113.6,156.22 113.6,156.57 113.72,156.68 113.72,156.89 113.87,157.05 DI4.5 DI4.6 113.87,158.69 113.72,158.85 113.72,159.61 113.91,159.8 v3(114.31,159.8) 115.58,159.8 115.62,159.76 116.2,159.76 116.24,159.8 116.42,159.8 116.94,160.32 116.94,161.32 117.45,161.83 122.4,161.83 122.72,162.14 122.72,162.89 122.83,163 JUSB3.9
USB3_PTX_C_RD_DRX_N1: length 3.8
  BOTTOM w0.102: UI4.20 378.58,53.89 378.43,53.73 378.11,53.73 v3(377.8,53.43) 377.55,53.17 377.55,52.49 377.06,52 376.82,52 CI65.1
USB3_PTX_C_RD_DRX_N3: length 2.4
  BOTTOM w0.102: UI5.20 382.13,43.22 381.98,43.07 381.84,43.07 381.54,42.77 381.02,42.77 380.99,42.73 380.76,42.73 CI72.1
USB3_PTX_C_RD_DRX_P1: length 3.8
  BOTTOM w0.102: CI62.1 376.82,51.81 377.19,51.81 v3(377.48,52.1) 377.74,52.36 377.74,53.04 378.24,53.54 378.42,53.54 378.57,53.39 UI4.19
USB3_PTX_C_RD_DRX_P3: length 2.4
  BOTTOM w0.102: CI70.1 380.76,42.54 v3(381.32,42.54) 381.58,42.54 381.92,42.87 382.02,42.87 382.18,42.72 UI5.19
USB3_PTX_DRX_N1: length 298
  TOP w0.102: UH1.F9 142.8,44.76 v2(142.32,44.44)
  IN2 w0.094: v2(142.32,44.44) 142.56,44.44 142.67,44.56 142.67,44.76 142.59,44.85 141.91,44.85 141.7,44.64 141.7,43.69 142.5,42.9 143.89,42.9 144.13,42.9 148.46,38.57 148.46,38 153.64,32.82 153.64,26.3 156.09,23.85 156.09,19.23 170.79,4.53 170.88,4.53 170.9,4.51 244.72,4.51 247.34,7.14 253.66,7.14 256.67,4.12 270.04,4.12 270.78,3.38 302.04,3.38 307.25,8.58 310.17,8.58 322.43,20.84 327.63,20.84 328.32,20.16 330.17,20.16 330.74,20.72 333.82,20.72 334.7,21.6 336.6,21.6 346.77,31.77 352.9,31.77 355.31,34.19 364.02,34.19 365.1,35.27 368.49,35.27 369.09,35.87 371.36,35.87 372.03,36.54 373.96,36.54 379.59,42.17 379.59,44.74 373.89,50.44 373.89,51.68 374.13,51.92 374.29,51.92 v2(374.63,52.27)
  BOTTOM w0.102: CI65.2 375.51,51.97 374.92,51.97 v2(374.63,52.27)
USB3_PTX_DRX_N2: length 62.4
  TOP w0.102: v2(143.99,47.73) 144.12,47.7 UH1.C3
  IN1 w0.102: v2(153.46,98.47) 153.66,98.47 153.76,98.38 153.76,97.62 153.37,97.23 152.67,97.23 151.42,95.98 151.42,95.82 150.94,95.34 150.94,76.21 150.71,75.99 150.71,74.21 151.52,73.4 151.52,71.52 152.16,70.88 153.11,70.88 153.43,70.56 153.43,68.44 152.97,67.99 152.97,66.21 153.38,65.8 153.38,62.88 153.02,62.53 153.02,59.3 149.87,56.15 149.87,54.99 149.39,54.51 147.84,52.96 147.84,49.56 147.21,48.93 145.62,47.34 143.93,47.34 143.82,47.45 143.82,47.56 v2(143.99,47.73)
  BOTTOM w0.102: v2(153.46,98.47) 153.83,98.84 153.83,99.2 CZ28.1
USB3_PTX_DRX_N3: length 285.1
  TOP w0.102: UH1.F11 142.89,43.71 v2(142.89,44.2)
  IN2 w0.094: v2(142.89,44.2) 142.79,44.2 142.67,44.08 142.67,43.89 143.04,43.53 147.51,43.53 147.91,43.12 147.91,42.15 147.63,41.87 147.63,41.62 148.02,41.23 151.23,41.23 151.31,41.32 152.22,41.32 152.82,40.71 152.82,34.77 154.24,33.35 154.24,26.76 157.57,23.44 157.57,18.59 171.04,5.12 171.62,5.12 171.63,5.12 244.34,5.12 246.98,7.75 253.95,7.75 256.98,4.72 267.85,4.72 268.93,5.8 293.11,5.8 294.8,7.49 305.21,7.49 306.92,9.19 309.87,9.19 322.16,21.48 333.71,21.48 334.45,22.22 336.37,22.22 346.55,32.4 352.67,32.4 355.65,35.38 358.24,35.38 360.33,37.47 366.58,37.47 367.56,36.49 371.1,36.49 377.34,42.74 378.3,42.74 v2(378.55,42.99)
  BOTTOM w0.102: v2(378.55,42.99) 378.82,42.73 379.48,42.73 CI72.2
USB3_PTX_DRX_N4: length 150.1
  TOP w0.102: UH1.B14 144.84,42.37 144.77,42.37 144.65,42.25 144.65,42.12 144.7,42.08 145.1,42.08 145.4,41.77 146.58,41.77 146.8,42 146.8,42.33 146.73,42.4 146.49,42.4 v2(146.39,42.31) ; v2(113.14,153.89) 113.4,154.15 113.4,154.82 CI16.2
  IN4 w0.102: v2(146.39,42.31) 146.68,42.59 146.68,43.26 146.45,43.49 146.45,47.14 146.96,47.65 146.96,54.67 149.52,57.22 150.77,57.22 152.98,59.44 152.98,60.86 153.4,61.28 153.4,63.95 153.76,64.3 153.76,66.56 154.01,66.82 154.01,72.73 153.23,73.52 153.23,75.73 152.97,75.98 152.97,78.17 152.11,79.03 152.11,81.24 151.42,81.93 151.42,83.69 145.62,89.5 140.09,89.5 136.1,93.49 135.33,93.49 134.82,94 133.97,94 129.53,98.44 129.53,99.69 127.86,101.36 127.86,103.41 129.69,105.24 129.69,107.75 128.64,108.8 128.64,110.75 129.35,111.46 131.14,111.46 131.39,111.71 131.39,112.94 126.74,117.6 126.02,117.6 124.11,119.5 124.11,122.26 122.69,123.67 122.69,128.27 116.34,134.62 116.34,139.72 118.37,141.75 118.37,150.05 116.36,152.07 114.52,152.07 113.42,153.17 113.42,153.6 v2(113.14,153.89)
USB3_PTX_DRX_P1: length 298.1
  TOP w0.102: v2(142.63,45.21) 142.79,45.05 142.94,45.05 UH1.F7
  IN2 w0.094: v2(142.63,45.21) 142.46,45.04 141.83,45.04 141.51,44.72 141.51,43.61 142.42,42.7 143.97,42.7 143.97,42.7 144.05,42.7 148.27,38.49 148.27,37.92 153.45,32.74 153.45,26.22 155.9,23.77 155.9,19.14 170.71,4.33 170.8,4.33 170.82,4.32 244.8,4.32 247.42,6.94 253.58,6.94 256.59,3.92 269.96,3.92 270.7,3.19 302.13,3.19 307.33,8.39 310.25,8.39 322.51,20.65 327.55,20.65 328.24,19.96 330.25,19.96 330.82,20.53 333.9,20.53 334.78,21.41 336.69,21.41 346.85,31.57 352.98,31.57 355.39,33.99 364.1,33.99 365.18,35.07 368.57,35.07 369.17,35.67 371.44,35.67 372.11,36.34 374.05,36.34 379.79,42.09 379.79,44.82 374.08,50.52 374.08,51.6 374.21,51.73 374.35,51.73 v2(374.63,51.45)
  BOTTOM w0.102: v2(374.63,51.45) 374.96,51.78 375.57,51.78 CI62.2
USB3_PTX_DRX_P2: length 62.3
  TOP w0.102: UH1.D4 144.12,47.18 v2(143.67,47.03)
  IN1 w0.102: v2(143.67,47.03) 143.8,47.16 145.7,47.16 148.03,49.48 148.03,52.88 150.06,54.91 150.06,56.07 153.21,59.22 153.21,62.45 153.57,62.8 153.57,65.88 153.16,66.28 153.16,67.91 153.62,68.37 153.62,70.64 153.19,71.07 152.23,71.07 151.71,71.59 151.71,73.47 150.9,74.28 150.9,75.91 151.12,76.14 151.12,95.26 151.61,95.75 151.61,95.9 152.75,97.04 153.44,97.04 153.94,97.54 153.94,98.18 v2(154.23,98.47)
  BOTTOM w0.102: CZ29.1 154.02,99.14 154.02,98.68 v2(154.23,98.47)
USB3_PTX_DRX_P3: length 285.1
  TOP w0.102: UH1.G12 142.34,43.71 v2(142.23,43.82)
  IN2 w0.094: v2(378.55,42.28) 378.29,42.54 377.42,42.54 371.18,36.3 367.48,36.3 366.5,37.27 360.41,37.27 358.32,35.18 355.73,35.18 352.75,32.2 346.63,32.2 336.45,22.02 334.53,22.02 333.79,21.28 322.24,21.28 309.96,9 307,9 305.29,7.29 294.88,7.29 293.19,5.6 269.01,5.6 267.93,4.53 256.9,4.53 253.87,7.56 247.06,7.56 244.42,4.92 171.55,4.92 171.54,4.93 170.96,4.93 157.37,18.51 157.37,23.36 154.04,26.68 154.04,33.27 152.63,34.69 152.63,40.63 152.14,41.12 151.39,41.12 151.31,41.04 147.94,41.04 147.43,41.54 147.43,41.95 147.71,42.23 147.71,43.04 147.43,43.33 142.96,43.33 142.47,43.82 v2(142.23,43.82)
  BOTTOM w0.102: CI70.2 379.48,42.54 378.82,42.54 v2(378.55,42.28)
USB3_PTX_DRX_P4: length 150.1
  TOP w0.102: CI13.2 113.59,154.8 113.59,154.15 v2(113.86,153.89) ; UH1.C14 144.46,42.04 144.52,41.98 144.62,41.89 145.02,41.89 145.32,41.58 146.66,41.58 146.99,41.92 146.99,42.08 v2(147.23,42.32)
  IN4 w0.102: v2(147.23,42.32) 146.87,42.69 146.87,43.34 146.64,43.57 146.64,47.07 147.15,47.58 147.15,54.59 149.59,57.04 150.84,57.04 153.17,59.36 153.17,60.78 153.59,61.2 153.59,63.87 153.95,64.23 153.95,66.49 154.2,66.74 154.2,72.81 153.41,73.6 153.41,75.81 153.16,76.06 153.16,78.25 152.3,79.11 152.3,81.32 151.61,82.01 151.61,83.77 145.7,89.69 140.17,89.69 136.18,93.67 135.41,93.67 134.9,94.19 134.05,94.19 129.72,98.52 129.72,99.77 128.05,101.44 128.05,103.34 129.88,105.17 129.88,107.83 128.83,108.88 128.83,110.67 129.42,111.27 131.21,111.27 131.58,111.63 131.58,113.02 126.82,117.78 126.09,117.78 124.3,119.58 124.3,122.33 122.88,123.75 122.88,128.35 116.53,134.7 116.53,139.64 118.56,141.67 118.56,150.13 116.43,152.26 114.6,152.26 113.61,153.25 113.61,153.64 v2(113.86,153.89)
USB3_PTX_L_DRX_N2: length 4.4
  BOTTOM w0.102: JNGFF2.27 153.74,106.09 153.89,105.94 153.89,105.22 153.79,105.12 v3(153.79,104.78) 153.79,103.82 153.47,103.49 LI17.4 153.47,102.89 RI29.2
USB3_PTX_L_DRX_P2: length 4.4
  BOTTOM w0.102: RI30.2 154.32,102.89 LI17.1 154.32,103.5 153.98,103.84 153.98,104.45 154.02,104.49 154.02,105.08 154.09,105.14 154.09,105.94 154.24,106.09 JNGFF2.29
USB3_PTX_RD_DRX_N1: length 2.3
  BOTTOM w0.109: UI4.11 383.42,53.89 383.44,53.9 383.75,53.9 383.83,53.82 384.97,53.82 CI64.2
USB3_PTX_RD_DRX_N3: length 3
  BOTTOM w0.109: CI73.2 388.67,42.41 388.1,42.41 388.01,42.51 388.01,42.84 387.62,43.23 387.28,43.23 387.27,43.22 UI5.11
USB3_PTX_RD_DRX_P1: length 2.2
  BOTTOM w0.109: UI4.12 383.53,53.39 383.62,53.3 v3(384.26,53.3) 384.97,53.3 CI63.2
USB3_PTX_RD_DRX_P3: length 3
  BOTTOM w0.109: UI5.12 387.27,42.72 387.28,42.71 387.4,42.71 387.49,42.62 387.49,42.29 v3(387.68,42.1) 387.89,41.89 388.68,41.89 CI71.2
USB3_TEST: length 4.2
  BOTTOM w0.109: RI85.2 385.63,39.78 v1(385.63,38.28)
  BOTTOM w0.254: UI5.14 385.28,41.51 386.13,40.65 RI85.2
USB20_N1: length 307.4
  TOP w0.076: 141.84,49.77 141.82,49.75 141.8,49.75 141.54,49.49 141.54,47.74 UH1.J3
  TOP w0.102: v2(142.41,50.53) 142.41,50.88 142.25,51.04 142.07,51.04 142,50.96 142,49.93 141.84,49.77 ; v2(383.21,57.46) 383.57,57.83 383.57,58.1 383.39,58.28 UI1.2
  IN2 w0.094: v2(142.41,50.53) 142.65,50.77 142.65,50.98 142.56,51.07 142.16,51.07 142,50.91 142,49.57 143.06,48.5 144.74,48.5 145.31,47.93 150.56,47.93 158.09,40.4 158.09,32.27 159.47,30.89 159.47,21.31 163.86,16.92 163.86,14.82 171.67,7.01 243.5,7.01 246.15,9.65 255.02,9.65 256.59,8.08 292.74,8.08 295.73,11.07 307.29,11.07 316.02,19.8 316.02,20.07 321.12,25.16 336.67,25.16 345.85,34.33 351.69,34.33 356.61,39.26 366.46,39.26 369.39,42.19 369.39,50.52 375.27,56.4 383.13,56.4 383.56,56.83 383.56,57.35 383.45,57.46 v2(383.21,57.46)
USB20_N1_R: length 21
  TOP w0.102: LI3.4 387.56,63.97 387.72,63.81 387.83,63.81 388.15,64.13 388.56,64.13 DI2.2 389.43,64.42 389.56,64.29 390.02,64.29 390.39,64.65 v3(390.39,66.59) 390.39,67.03 390.63,67.27 391.7,67.27 391.74,67.31 392.33,67.31 392.36,67.27 396.68,67.27 397.78,66.17 397.78,62.6 396.93,61.75 396.53,61.75 396.42,61.64 JUSB1.2
USB20_N2: length 283.7
  TOP w0.102: UI2.2 380.34,36.47 380.19,36.32 380.12,36.32 379.87,36.57 379.47,36.57 379.37,36.68 v2(379.37,36.9) ; UH1.N13 139.32,42.08 v2(139.24,42.08)
  IN2 w0.094: v2(379.37,36.9) 379.11,36.65 378.59,36.65 378.36,36.88 376.06,36.88 374.41,35.23 372.74,35.23 371.1,33.59 355.78,33.59 353.33,31.14 347.42,31.14 337.28,20.99 334.98,20.99 333,19.01 328.09,19.01 326.89,20.22 322.64,20.22 310.24,7.82 307.37,7.82 302.25,2.7 269.91,2.7 269.22,3.39 256.54,3.39 253.39,6.54 247.65,6.54 245.01,3.89 170.53,3.89 155.21,19.22 155.21,21.62 153.43,23.4 153.43,25.16 153.05,25.53 153.05,32.54 147.67,37.92 147.67,38.28 146.99,38.96 146.52,38.96 143.35,42.13 142.6,42.13 141.94,42.8 139.79,42.8 139.63,42.64 139.41,42.42 139.41,42.25 v2(139.24,42.08)
USB20_N2_R: length 21.9
  TOP w0.102: LI4.4 387.43,36.98 387.59,36.83 388.33,36.83 DI3.2 389.2,36.93 389.3,36.83 389.72,36.83 390.32,37.42 390.32,38.96 v3(390.6,39.24) 391.63,40.27 391.63,40.32 392.04,40.73 392.09,40.73 393.58,42.21 396.94,42.21 397.95,41.2 397.95,37.09 397.6,36.74 397.11,36.74 JUSB2.2
USB20_N3: length 134.9
  TOP w0.076: 140.74,48.15 140.74,48.13 140.76,48.11 140.76,47.19 140.88,47.07 UH1.K4
  TOP w0.102: v2(115.95,148.34) 116.21,148.6 116.21,148.7 116.05,148.86 UI3.2 ; v2(140.82,50.34) 140.73,50.42 140.73,50.58 140.83,50.68 141.2,50.68 141.28,50.6 141.28,50.28 140.93,49.93 140.93,48.66 140.74,48.47 140.74,48.15
  IN4 w0.102: v2(115.95,148.34) 116.1,148.19 116.1,147.44 117.11,146.43 117.11,141.76 114.56,139.22 114.56,135.56 122,128.13 122,121.19 122.34,120.85 122.34,118.66 126.96,114.04 126.96,112.89 125.97,111.9 125.97,108.68 126.77,107.88 126.77,105.3 126.59,105.12 126.59,100.94 128.19,99.34 128.19,97.75 128.8,97.14 128.8,95.75 136.57,87.98 139.72,87.98 140.68,87.02 143.86,87.02 144.65,86.24 146.92,86.24 149.13,84.03 149.13,83.44 149.76,82.82 149.76,81.14 150.89,80.01 150.89,74.09 151.68,73.3 151.68,70.37 151.42,70.12 151.42,63.8 150.88,63.25 150.88,62.43 151.6,61.71 151.6,60.36 150.14,58.9 149.03,58.9 145.09,54.96 143.78,54.96 143.13,54.31 143.13,52.94 142.93,52.74 141.57,52.74 140.2,51.37 140.2,50.74 140.43,50.51 140.65,50.51 v2(140.82,50.34)
USB20_N3_R: length 14.2
  TOP w0.102: v2(118.12,160.93) 118.38,160.67 118.38,159.47 119.64,158.21 119.64,157.79 119.53,157.69 DI5.2 119.64,156.82 119.64,156.01 119.48,155.85 LI7.4
  BOTTOM w0.102: JUSB3.2 120.2,164.08 120.2,163.93 120.72,163.41 120.72,161.32 v3(120.56,161.15) 120.41,161 120.35,161 119.6,160.25 118.68,160.25 118.45,160.48 118.45,160.6 v2(118.12,160.93)
USB20_N4: length 162.5
  TOP w0.102: v2(140.13,44.67) 140.2,44.6 140.2,44.13 UH1.M10
  IN2 w0.094: v2(140.13,44.67) 140.13,44.94 140.01,45.05 139.72,45.05 139.42,45.36 139.42,45.88 140.09,46.55 140.09,47.07 139.45,47.72 138.61,47.72 138.27,47.38 132.86,47.38 132.29,47.95 128.8,47.95 128.31,48.44 128.31,51.27 128.02,51.56 126.56,51.56 126.34,51.78 122.35,51.78 120.5,53.63 117.37,53.63 116.79,54.21 115.4,54.21 114.21,53.02 111.67,53.02 110.8,52.14 106.48,52.14 105.62,51.28 101.64,51.28 100.42,50.07 100.42,44.79 96.6,40.98 96.6,36.44 93.32,33.16 92.18,33.16 92.04,33.01 90.37,33.01 88.21,30.86 87.66,30.86 85.03,28.23 84.43,28.23 82.58,26.39 79.84,26.39 76.01,22.55 72.84,22.55 71.7,21.41 68.37,21.41 67.72,20.75 66.93,20.75 65.54,19.37 62.99,19.37 60.52,21.84 60.52,22.56 58.88,24.2 54.26,24.2 51.94,26.52 51.52,26.52 47.15,30.9 42.88,30.9 41.93,31.85 28.8,31.85 28.33,31.38 28.33,30.11 28.61,29.83 28.61,26.84 27.7,25.92 24.14,25.92 23.69,26.37 20.89,26.37 20.64,26.12 20.64,25.78 20.71,25.71 21.03,25.71 v2(21.03,25.71)
  BOTTOM w0.102: v2(21.03,25.71) 20.74,25.71 20.5,25.94 20.5,26.51 RT560.2
USB20_N5: length 149.4
  TOP w0.102: v2(140.32,49.69) 140.7,49.31 140.7,48.9 140.35,48.54 UH1.M1
  IN2 w0.094: v2(26.63,33.96) 26.85,33.74 28.13,33.74 29.12,32.76 36.14,32.76 36.89,33.5 41.17,33.5 42.97,35.3 46.72,35.3 47.53,34.5 48.48,34.5 50.96,32.02 52.72,32.02 53.88,30.85 54.58,30.85 61.88,23.55 61.88,22.22 62.3,21.8 62.68,21.8 64.15,20.33 65,20.33 68.31,23.65 69.21,23.65 70.56,25 72.02,25 72.46,24.56 76.53,24.56 79.16,27.19 82.16,27.19 84.05,29.08 84.45,29.08 87.45,32.08 88.31,32.08 90.18,33.94 90.62,33.94 93.2,36.53 95.35,36.53 95.64,36.82 95.64,41.14 99.63,45.12 99.63,50.39 101.31,52.07 105.26,52.07 106.38,53.19 110.26,53.19 111.09,54.02 113.57,54.02 114.85,55.29 121.01,55.29 121.17,55.46 126.45,55.46 129.98,51.92 130.4,51.92 131.19,51.14 131.19,50.32 133.28,48.23 137.63,48.23 138.49,49.1 139.3,49.1 139.71,49.51 140.14,49.51 v2(140.32,49.69)
  BOTTOM w0.102: v2(26.63,33.96) 26.34,33.68 26.06,33.68 RT556.1
USB20_N6: length 1.2
  TOP w0.109: UH1.K7 141.38,45.33 v2(141.48,45.23)
  BOTTOM w0.109: v2(141.48,45.23) 141.48,44.7 T313.1
USB20_N8: length 77.6
  TOP w0.076: v2(143.87,49.99) 143.87,50.28 143.83,50.32 143.47,50.32 142.85,49.7 142.85,49.48 142.3,48.93 142.3,48.42 142.48,48.24 142.48,47.29 142.33,47.14 142.33,47.01 142.46,46.88 142.62,46.88 142.68,46.94 UH1.G4
  IN1 w0.102: v2(143.87,49.99) 144.02,50.14 144.25,50.14 144.57,50.45 144.57,51.82 152.36,59.61 152.36,64.42 151.97,64.81 151.97,68.01 151.53,68.44 151.53,70.49 151.02,71 150.61,71 150.17,70.56 149.91,70.56 149.73,70.73 149.73,70.99 150.48,71.73 150.48,72.14 150.19,72.43 149.78,72.43 149.04,71.68 148.78,71.68 148.61,71.86 148.61,72.12 149.05,72.56 149.05,72.97 148.66,73.36 148.66,74.72 150.42,76.47 150.42,95.59 151.14,96.32 151.14,103.44 147.08,107.51 147.08,108.41 v2(147.25,108.59)
  BOTTOM w0.102: v2(147.25,108.59) 147.07,108.41 147.07,107.85 147.24,107.68 JNGFF2.9
USB20_N10: length 261
  TOP w0.076: 142.08,49.51 142.06,49.5 142.06,49.47 141.7,49.11 141.7,47.95 UH1.H3
  TOP w0.102: v2(143.65,52.07) 143.35,51.77 143.29,51.77 142.86,51.34 142.86,50.45 142.27,49.86 142.27,49.71 142.08,49.51 ; v2(326.17,41.37) 326.36,41.55 326.36,41.86 327.01,42.51 327.01,42.56 327.46,43.02 327.52,43.02 330.6,46.1 330.6,53.24 332.08,54.73 333.49,54.73 334.31,55.55 JUSH1.19
  IN2 w0.094: v2(143.65,52.07) 143.95,51.77 145.01,51.77 145.38,51.41 146.56,51.41 149.18,48.78 150.64,48.78 159.18,40.25 159.18,32.15 160.06,31.26 160.06,21.59 164.52,17.13 164.52,16.01 166.79,13.74 166.79,12.83 171.93,7.69 242.89,7.69 245.45,10.25 255.48,10.25 256.96,8.78 292.6,8.78 295.48,11.66 306.98,11.66 313.71,18.39 313.71,20.5 321.51,28.3 321.51,39.09 322.95,40.53 326.07,40.53 326.39,40.86 326.39,41.15 v2(326.17,41.37)
USB20_N11: length 98.6
  TOP w0.102: v2(139.47,43.81) 139.17,43.91 UH1.R10 ; LV2.1 129.87,113.37 129.97,113.27 129.97,112.36 v2(129.77,112.16)
  IN4 w0.102: v2(139.47,43.81) 139.76,43.81 139.9,43.67 140.22,43.67 140.69,44.14 141.07,44.52 141.07,46.43 143.02,48.39 143.99,48.39 144.58,48.98 144.58,52.26 145.68,53.35 145.68,54.31 149.24,57.87 150.28,57.87 152.4,59.99 152.4,63.92 153.16,64.68 153.16,66.84 153.59,67.27 153.59,72.15 152.52,73.22 152.52,77.99 151.69,78.83 151.69,80.71 150.77,81.63 150.77,83.58 145.43,88.93 139.01,88.93 137.87,90.07 135.82,90.07 133.83,92.06 133.83,93.44 129.01,98.25 129.01,99.63 127.44,101.2 127.44,103.57 128.55,104.68 128.55,107.86 127.45,108.96 127.45,111.39 129.04,112.98 129.55,112.98 130.18,112.35 130.18,112.15 130.05,112.02 129.91,112.02 v2(129.77,112.16)
USB20_N11_R: length 15.9
  TOP w0.102: LV2.2 129.87,115.28 130.03,115.44 130.03,115.55 129.95,115.63 129.7,115.63 128.84,114.77 128.69,114.77 128.56,114.64 128.56,114.35 DV41.2 127.95,114.36 127.85,114.45 127.49,114.45 126.38,115.56 123.88,115.56 123.25,116.19 122.6,116.19 122.2,115.8 120.77,115.8 v3(120.56,116.01) 120.35,116.22 120.35,117.96 120.2,118.12 JEDP1.15
