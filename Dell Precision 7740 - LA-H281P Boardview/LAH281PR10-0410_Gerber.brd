# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
PU1200  NCP302045MNTXG_PQFN33_5X5  [NCP302045MNTXG_PQFN33_5X5-S]  289.9 55.14 90 top
PU1201  NCP302045MNTXG_PQFN33_5X5  [NCP302045MNTXG_PQFN33_5X5-S]  290 44.39 90 top
PU1202  NCP302045MN_PQFN33_5X5  [NCP302045MNTXG_PQFN33_5X5-S]  290 34.66 90 top
PU1203  NCP302045MN_PQFN33_5X5  [NCP302045MNTXG_PQFN33_5X5-S]  289.98 23.61 90 top
PU1700  NCP302045MN_PQFN33_5X5  [NCP302045MNTXG_PQFN33_5X5-S]  290 13.91 90 top
PU1800  NCP302045MN_PQFN33_5X5  [NCP302045MNTXG_PQFN33_5X5-S]  288.07 65.14 90 top
PU2001  -  [LM393DGKR_VSSOP8]  51.47 21.5 270 bottom
PU2003  -  [LM393DGKR_VSSOP8]  38.12 15.39 0 bottom
PU2004  -  [LM393DGKR_VSSOP8]  81.51 27.65 180 bottom
PWRSW1  @SHORT PADS~D  [SHORTPADS]  355.93 53.1 180 top
QA10  -  [L2N7002WT1G_SC-70-3]  387.36 17.41 90 top
QE2  -  [L2N7002DW1T1G_SC88-6]  124.25 74.58 0 top
QE3  -  [LMBT3904WT1G_SC70-3]  242.11 60.52 90 bottom
QE4  -  [LMBT3904WT1G_SC70-3]  163.25 58.91 270 bottom
QE6  -  [LMBT3904WT1G_SC70-3]  163.06 103.01 180 bottom
QE7  -  [LMBT3904WT1G_SC70-3]  313.18 35.17 90 bottom
QE11  -  [L2N7002WT1G_SC-70-3]  157.43 57.61 0 bottom
QE12  -  [L2N7002WT1G_SC-70-3]  153.49 77.8 180 bottom
QE15  -  [PJ2301_SOT23-3]  143.33 88.81 180 top
QE17  -  [L2N7002WT1G_SC-70-3]  147.61 86.39 90 top
QE26  -  [LMBT3904WT1G_SC70-3]  305.25 29.29 180 top
QE104  -  [LMBT3904WT1G_SC70-3]  146.38 21.28 180 top
QH4  -  [L2N7002DW1T1G_SC88-6]  109.84 22.67 90 top
QH6  -  [L2N7002WT1G_SC-70-3]  117.17 20.9 0 top
QH7  -  [PJ2301_SOT23-3]  113.61 20.06 0 top
QL1  -  [2N7002KDW_SOT363-6]  133.82 148.28 180 top
QL7  -  [L2N7002WT1G_SC-70-3]  135.26 144.41 270 top
QN1  -  [2N7002KDW_SOT363-6]  306.89 21.92 270 bottom
QR1  -  [L2N7002WT1G_SC-70-3]  31.77 21.67 0 bottom
QT1  -  [L2N7002WT1G_SC-70-3]  45.04 19.05 180 top
QT2  S TR AO7401 1P SC70-3  [SI1303DL-T1-E3_SOT323-3]  47.28 14.43 270 top
QT3  S TR AO7401 1P SC70-3  [SI1303DL-T1-E3_SOT323-3]  38.05 13.44 180 top
QT4  -  [2N7002KDW_SOT363-6]  40.1 15.35 270 top
QT5  -  [L2N7002WT1G_SC-70-3]  12.76 39.03 270 bottom
QT6  -  [L2N7002WT1G_SC-70-3]  30.35 29.16 0 bottom
QT7  -  [L2N7002WT1G_SC-70-3]  32.94 29.19 0 bottom
QT8  -  [L2N7002WT1G_SC-70-3]  28.9 24.47 0 bottom
QT9  -  [L2N7002WT1G_SC-70-3]  26.36 24.47 0 bottom
QT10  -  [EMB80P03JS_SOT-23-3]  54.75 14.77 180 top
QV1  -  [AO6405_TSOP6]  145.06 133.9 90 top
QV2  -  [L2N7002WT1G_SC-70-3]  139.14 136.98 270 top
QV23  -  [L2N7002DW1T1G_SC88-6]  137.63 136.8 180 bottom
QV30  -  [2N7002KDW_SOT363-6]  276.5 79.68 180 bottom
QV40  -  [L2N7002WT1G_SC-70-3]  282.15 84.74 180 bottom
QV41  -  [L2N7002WT1G_SC-70-3]  280.94 80.85 270 bottom
QV42  -  [L2N7002WT1G_SC-70-3]  284.5 78.97 180 bottom
QV43  -  [L2N7002WT1G_SC-70-3]  143.11 129.22 270 top
QV44  -  [L2N7002DW1T1G_SC88-6]  168.75 107.61 90 top
QZ1  -  [PJ2301_SOT23-3]  134.48 130.44 0 bottom
QZ3  -  [LMUN5111T1G_SC70-3]  388.59 11.72 90 top
QZ7  -  [L2N7002WT1G_SC-70-3]  394.41 9.22 180 top
QZ15  -  [L2N7002WT1G_SC-70-3]  145.23 100.02 0 top
QZ17  -  [L2N7002DW1T1G_SC88-6]  137.87 96.9 90 top
QZ18  -  [L2N7002DW1T1G_SC88-6]  135.97 100.93 270 top
QZ19  AOSP21357L_SO8  [Q_P_SO8]  123.52 89.3 0 top
QZ20  -  [DMN3150LW-7_SOT323-3]  132.79 86.83 90 top
QZ21  -  [L2N7002WT1G_SC-70-3]  352.38 52.22 270 top
QZ22  -  [LMBT3904WT1G_SC70-3]  98.24 65.29 90 top
R127  100K_0402_5%  [R_0402]  147.6 101.36 180 top
R128  100K_0402_5%  [R_0402]  168.18 140.31 0 bottom
R129  100K_0402_5%  [R_0402]  150.71 101.41 0 top
RA5  2.2K_0402_5%  [R_0402]  386.66 21.91 90 top
RA6  2.2K_0402_5%  [R_0402]  384.76 22.38 90 bottom
RA7  16.2_0402_1%  [R_0402]  387.37 21.1 180 top
RA8  16.2_0402_1%  [R_0402]  387.37 20.33 180 top
RA9  33_0402_5%  [R_0402]  380.06 16.96 90 top
RA12  1K_0402_5%  [R_0402]  389.63 29.22 0 top
RA13  1K_0402_5%  [R_0402]  389.38 26.18 0 top
RA14  22_0402_5%  [R_0402]  376.04 23.51 0 top
RA17  33_0402_5%  [R_0402]  379.17 18.13 270 top
RA18  10K_0402_5%  [R_0402]  375.82 25.44 90 top
RA44  100K_0402_5%  [R_0402]  385.9 30.19 270 top
RA48  0_0402_5%  [R0402_0OHM]  374.14 26.3 0 top
RA50  0_0402_5%  [R_0402]  374.14 25.54 0 top
RA52  100K_0402_5%  [R_0402]  374.27 23.76 0 top
RA201  0_0603_5%  [R0603_0OHM]  374.79 16.4 0 top
RA209  10K_0402_5%  [R_0402]  389.53 26.95 0 bottom
RA213  0_0402_5%  [R_0402]  386.84 24.91 0 top
RA214  10K_0402_5%  [R_0402]  386.84 24.91 0 bottom
RA219  10K_0402_5%  [R_0402]  391.87 20.89 90 bottom
RA220  100K_0402_5%  [R_0402]  386.08 15.33 270 bottom
RA221  0_0402_5%  [R0402_0OHM]  382.39 14.62 0 bottom
RA222  0_0402_5%  [R0402_0OHM]  386.18 32.49 270 top
RA223  0_0402_5%  [R0402_0OHM]  389.8 30.01 270 bottom
RA224  10K_0402_5%  [R_0402]  340.89 8.75 90 top
RA225  10K_0402_5%  [R_0402]  389.56 27.05 0 top
RA226  0_0402_5%  [R0402_0OHM]  382.33 31.93 0 bottom
RA227  0_0402_5%  [R0402_0OHM]  394.45 13.87 90 bottom
RA228  0_0402_5%  [R0402_0OHM]  384.41 13.06 90 top
RC1  24.9_0402_1%  [R_0402]  267.68 68.17 0 bottom
RC2  24.9_0402_1%  [R_0402]  226.69 65.42 0 top
RC5  121_0402_1%  [R_0402]  226.18 67.96 0 top
RC6  75_0402_1%  [R_0402]  226.2 64 0 top
RC7  100_0402_1%  [R_0402]  226.2 63.23 0 top
RC66  20_0402_5%  [R_0402]  263.46 66.75 0 top
RC71  1K_0402_5%  [R_0402]  277.01 67.78 180 bottom
RC74  10K_0402_5%  [R_0402]  119.02 41.23 0 bottom
RC75  10K_0402_5%  [R_0402]  124.1 20.74 90 top
RC78  60.4_0402_1%  [R_0402]  221.21 68.45 270 bottom
RC79  49.9_0402_1%  [R_0402]  258.61 21.92 90 top
RC80  1K_0402_5%  [R_0402]  277.02 66.95 180 bottom
RC83  1K_0402_5%  [R_0402]  252.38 24.21 270 top
RC84  499_0402_1%  [R_0402]  252.83 21.88 0 top
RC114  49.9_0402_1%  [R_0402]  248.84 24.45 270 top
RC115  2.2K_0402_5%  [R_0402]  245.01 22.15 270 bottom
RC121  1K_0402_5%  [R_0402]  258.32 14.03 0 bottom
RC122  0_0402_5%  [R_0402]  258.32 14.8 0 bottom
RC124  1K_0402_5%  [R_0402]  234.15 13.55 0 bottom
RC126  1K_0402_5%  [R_0402]  262.81 12.69 180 bottom
RC127  0_0402_5%  [R0402_0OHM]  237.44 19.28 90 bottom
RC128  1K_0402_5%  [R_0402]  234.24 15.41 0 bottom
RC129  0_0402_5%  [R_0402]  235.91 15.37 90 bottom
RC132  150_0402_5%  [R_0402]  261.16 12.99 270 top
RC133  1.5K_0402_5%  [R_0402]  232.17 16.47 270 top
RC135  51_0402_5%  [R_0402]  242.88 24.03 180 bottom
RC136  51_0402_5%  [R_0402]  239.5 21.46 90 bottom
RC137  3K_0402_5%  [R_0402]  243.62 23.98 90 bottom
RC138  51_0402_5%  [R_0402]  259.03 16.36 180 bottom
RC139  51_0402_5%  [R_0402]  236.8 18.11 270 bottom
RC143  0_0402_5%  [R0402_0OHM]  236.03 18.11 270 bottom
RC144  0_0402_5%  [R0402_0OHM]  244.23 21.36 90 bottom
RC152  56.2_0402_1%  [R_0402]  265.17 12.59 0 bottom
RC153  220_0402_5%  [R_0402]  266.01 13.4 90 bottom
RC157  100_0402_5%  [R_0402]  265.25 13.4 90 bottom
RC166  1K_0402_5%  [R_0402]  277.03 68.54 180 bottom
RC168  20_0402_5%  [R_0402]  255.5 19.5 90 top
RC169  0_0402_5%  [R0402_0OHM]  273.52 68.18 180 bottom
RC171  0_0402_5%  [R_0402]  228.88 24.02 180 top
RC177  30_0402_5%  [R_0402]  270.96 68.18 0 bottom
RC178  0_0402_5%  [R0402_0OHM]  268.73 68.98 0 bottom
RC179  0_0402_5%  [R0402_0OHM]  268.73 69.99 0 bottom
RC181  1K_0402_5%  [R_0402]  250.93 13.37 180 bottom
RC216  0_0603_5%  [R0603_0OHM]  246.91 22.43 270 bottom
RC217  0_0402_5%  [R_0402]  260.25 12.69 0 bottom
RC218  150_0402_5%  [R_0402]  259.25 12.47 180 bottom
RC219  10K_0402_5%  [R_0402]  255.68 13.71 0 bottom
RC221  49.9_0402_1%  [R_0402]  260.52 49.94 270 top
RC228  0_0402_5%  [R0402_0OHM]  238.26 19.8 90 bottom
RC229  0_0402_5%  [R0402_0OHM]  238.58 22.41 270 bottom
RC230  0_0402_5%  [R0402_0OHM]  242.33 21.19 90 bottom
RC239  0_0402_5%  [R_0402]  250.39 21.52 270 top
RC240  0_0402_5%  [R_0402]  251.33 21.82 270 top
RC241  1.5K_0402_5%  [R_0402]  235.3 13.9 90 top
RC304  0_0402_5%  [R0402_0OHM]  268.37 67.9 180 top
RC314  0_0402_5%  [R0402_0OHM]  258.33 13.26 0 bottom
RC315  0_0402_5%  [R0402_0OHM]  258.32 15.58 0 bottom
RC319  0_0402_5%  [R0402_0OHM]  256.36 17.67 90 top
RC321  1K_0402_5%  [R_0402]  254.38 13.52 180 bottom
RC322  1K_0402_5%  [R_0402]  244.42 22.95 270 top
RC323  1K_0402_5%  [R_0402]  247.8 13.39 180 bottom
RC324  1K_0402_5%  [R_0402]  242.71 21.91 270 top
RC325  1K_0402_5%  [R_0402]  245.53 22.14 270 top
RC326  0_0402_5%  [R0402_0OHM]  266.03 82.2 0 top
RC366  15_0402_5%  [R_0402]  120.46 27.29 180 bottom
RC367  15_0402_5%  [R_0402]  120.46 26.51 180 bottom
RC368  15_0402_5%  [R_0402]  120.2 31.09 180 bottom
RC369  15_0402_5%  [R_0402]  126.57 30.11 0 bottom
RC370  10K_0201_5%  [R_0201]  126.46 38.52 90 bottom
RC436  1K_0402_5%  [R_0402]  252.71 13.37 180 bottom
RC437  1K_0402_5%  [R_0402]  253.98 20.35 90 bottom
RC438  1K_0402_5%  [R_0402]  252.2 21.13 90 bottom
RC439  1K_0402_5%  [R_0402]  253.16 21.13 90 bottom
RC440  1K_0402_5%  [R_0402]  251.28 21.12 90 bottom
RC441  1K_0402_5%  [R_0402]  250.33 21.28 90 bottom
RC442  1K_0402_5%  [R_0402]  249.39 21.24 90 bottom
RC443  1K_0402_5%  [R_0402]  248.49 21.24 90 bottom
RC444  10K_0402_5%  [R_0402]  128.32 22.17 270 top
RC560  0_0402_5%  [R_0402]  135.77 25.12 90 bottom
RC561  0_0402_5%  [R_0402]  134.53 26.98 270 bottom
RC562  0_0201_5%  [R_0201]  278.84 73.76 270 top
RD4  470_0402_1%  [R_0402]  166.19 43.14 270 bottom
RD7  1K_0402_5%  [R_0402]  162.96 57.29 180 bottom
RD8  1K_0402_5%  [R_0402]  165.27 57.78 90 bottom
RD9  2_0402_1%  [R_0402]  168.58 57.78 90 bottom
RD10  2_0402_1%  [R_0402]  167.81 57.78 90 bottom
RD11  1K_0402_5%  [R_0402]  166.04 58.69 270 bottom
RD12  24.9_0402_1%  [R_0402]  170.3 58.69 270 bottom
RD14  0_0402_5%  [R_0402]  179.47 89.88 270 bottom
RD15  0_0402_5%  [R_0402]  168.85 64 90 bottom
RD16  0_0603_5%  [R0603_0OHM]  168.3 79.64 270 bottom
RD17  330K_0402_5%  [R_0402]  149.26 15.1 90 bottom
RD18  0_0402_5%  [R_0402]  181.05 88.97 90 bottom
RD21  1K_0402_5%  [R_0402]  162.96 56.53 180 bottom
RD22  0_0402_5%  [R_0402]  174.19 91.91 270 top
RD23  0_0402_5%  [R_0402]  175.21 91.91 270 top
RD24  0_0402_5%  [R_0402]  169.79 61.51 0 bottom
RD29  1K_0402_5%  [R_0402]  162.13 54.8 90 bottom
RD30  1K_0402_5%  [R_0402]  202.28 57.05 0 bottom
RD31  2_0402_1%  [R_0402]  205.1 57.05 180 bottom
RD32  1K_0402_5%  [R_0402]  205.46 55.27 0 bottom
RD33  24.9_0402_1%  [R_0402]  207.07 56.23 180 bottom
RD34  1K_0402_5%  [R_0402]  206.55 59.67 270 bottom
RD36  0_0402_5%  [R_0402]  204.77 59.41 270 bottom
RD37  1K_0402_5%  [R_0402]  205.79 58.75 90 bottom
RD40  0_0402_5%  [R_0402]  199.28 60.01 180 bottom
RD42  0_0402_5%  [R_0402]  199.69 78.9 270 bottom
RD43  0_0402_5%  [R_0402]  204.35 78.93 270 bottom
RD45  1K_0402_5%  [R_0402]  161.36 54.8 90 bottom
RD46  0_0402_5%  [R_0402]  192.37 91.03 270 top
RD48  0_0402_5%  [R_0402]  168.86 62.7 270 bottom
RD51  0_0402_5%  [R_0402]  191.59 89.32 180 top
RD76  0_0402_5%  [R0402_0OHM]  168.78 42.18 90 bottom
RD77  0_0402_5%  [R0402_0OHM]  167.95 42.19 90 bottom
RD78  0_0402_5%  [R0402_0OHM]  181.81 88.97 90 bottom
RD79  0_0402_5%  [R0402_0OHM]  180.26 89.88 270 bottom
RD80  0_0402_5%  [R0402_0OHM]  168.05 63.98 90 bottom
RD81  0_0402_5%  [R0402_0OHM]  174.19 89.63 270 top
RD82  0_0402_5%  [R0402_0OHM]  175.21 89.63 270 top
RD83  0_0402_5%  [R0402_0OHM]  169.79 60.73 0 bottom
RD84  0_0402_5%  [R0402_0OHM]  203 59.41 270 bottom
RD85  0_0402_5%  [R0402_0OHM]  200.45 78.9 270 bottom
RD86  0_0402_5%  [R0402_0OHM]  205.11 78.93 270 bottom
RD87  0_0402_5%  [R0402_0OHM]  199.28 59.25 180 bottom
RD88  0_0402_5%  [R0402_0OHM]  191.6 90.12 90 top
RD89  0_0402_5%  [R0402_0OHM]  193.24 89.32 180 top
RD90  0_0402_5%  [R0402_0OHM]  168.09 62.7 270 bottom
RD92  0_0603_5%  [R0603_0OHM]  179.65 88.98 90 top
RD93  0_0603_5%  [R0603_0OHM]  182.82 88.5 90 bottom
RD94  0_0603_5%  [R0603_0OHM]  200.29 87.9 0 top
RE8  100K_0402_5%  [R_0402]  144.66 70.14 0 top
RE10  100K_0402_5%  [R_0402]  144.7 76.1 0 top
RE11  100K_0402_5%  [R_0402]  130.5 81.16 180 top
RE12  100K_0402_5%  [R_0402]  127.66 73.8 180 top
RE20  100K_0402_5%  [R_0402]  131.01 66.46 180 top
RE21  10K_0402_5%  [R_0402]  144.7 80.14 0 top
RE25  100K_0402_5%  [R_0402]  143.85 63.83 180 top
RE26  10_0402_5%  [R_0402]  145.82 61.64 180 top
RE30  0_0402_5%  [R0402_0OHM]  117.09 53.8 0 bottom
RE31  100K_0402_5%  [R_0402]  123.97 79.4 0 top
RE32  0_0402_5%  [R0402_0OHM]  135.46 80.74 90 bottom
RE33  1K_0402_5%  [R_0402]  124.89 78.64 180 top
RE35  10K_0402_5%  [R_0402]  144.68 68.46 0 top
RE37  2.2K_0402_5%  [R_0402]  132.81 67.37 270 top
RE38  10K_0402_5%  [R_0402]  144.66 69.32 0 top
RE43  2.2K_0402_5%  [R_0402]  131.81 67.36 270 top
RE55  100K_0402_5%  [R_0402]  130.42 83.52 180 top
RE56  10K_0402_5%  [R_0402]  134.62 67.39 270 top
RE57  1K_0402_5%  [R_0402]  129.5 82.73 0 top
RE58  100K_0402_5%  [R_0402]  130.5 81.92 180 top
RE59  0_0402_5%  [R0402_0OHM]  145.55 70.11 180 bottom
RE60  33_0402_5%  [R_0402]  144.66 70.94 0 top
RE63  100K_0402_5%  [R_0402]  145.61 73.59 90 top
RE64  300_0402_5%  [R_0402]  129.97 71.78 180 bottom
RE65  100_0402_1%  [R_0402]  144.73 73.59 90 top
RE67  10K_0402_5%  [R_0402]  126.67 74.68 0 top
RE68  100K_0402_5%  [R_0402]  126.58 76.53 0 top
RE69  8.2K_0402_5%  [R_0402]  133.31 63.38 270 top
RE70  2.2K_0402_5%  [R_0402]  159.38 58.36 0 bottom
RE71  10_0402_1%  [R_0402]  118.13 63.2 180 bottom
RE72  10K_0402_5%  [R_0402]  118.01 58.64 180 bottom
RE73  10K_0402_5%  [R_0402]  118.01 55.39 180 bottom
RE74  10K_0402_5%  [R_0402]  118.01 54.56 180 bottom
RE75  100K_0402_5%  [R_0402]  118.01 57.88 180 bottom
RE77  1.58K_0402_1%  [R_0402]  141.25 83.4 90 top
RE79  2K_0402_5%  [R_0402]  149.76 63.39 180 bottom
RE83  100K_0402_5%  [R_0402]  145.54 65.61 270 top
RE84  100K_0402_5%  [R_0402]  144.65 65.61 270 top
RE86  10K_0402_5%  [R_0402]  117.09 57.11 0 bottom
RE90  0_0402_5%  [R0402_0OHM]  159.38 59.25 0 bottom
RE91  100K_0402_5%  [R_0402]  144.7 76.86 0 top
RE93  100K_0201_5%  [R_0201]  155.01 75.54 90 bottom
RE94  75_0402_5%  [R_0402]  151.84 78.07 270 bottom
RE95  100K_0402_5%  [R_0402]  137.92 66.47 90 top
RE274  0_0402_5%  [R_0402]  127.69 66.29 0 top
RE275  0_0402_5%  [R0402_0OHM]  128.27 65.42 0 top
RE280  0_0402_5%  [R_0402]  157.75 61.08 90 bottom
RE288  100_0402_5%  [R_0402]  144.71 72.81 0 top
RE290  0_0402_5%  [R0402_0OHM]  134.31 81.66 180 top
RE292  0_0402_5%  [R_0402]  157.68 64.4 180 bottom
RE300  4.3K_0402_5%  [R_0402]  134.1 63.36 270 top
RE302  2.2K_0402_5%  [R_0402]  126.58 77.29 0 top
RE303  2.2K_0402_5%  [R_0402]  127.08 80.87 0 top
RE304  0_0402_5%  [R_0402]  154.77 59.69 0 bottom
RE306  0_0402_5%  [R_0402]  118.01 56.28 180 bottom
RE312  300_0402_5%  [R_0402]  129.84 70.64 180 bottom
RE313  10K_0402_5%  [R_0402]  129.84 68.48 180 bottom
RE314  100_0402_1%  [R_0402]  128.77 76.53 270 top
RE318  0_0402_5%  [R0402_0OHM]  129.77 74.63 0 top
RE342  10K_0402_5%  [R_0402]  136.14 67.39 270 top
RE343  33K_0402_5%  [R_0402]  149.76 62.63 180 bottom
RE349  43K_0402_1%  [R_0402]  135.38 66.47 90 top
RE350  33_0402_5%  [R_0402]  143.57 67.39 270 top
RE362  100K_0402_5%  [R_0402]  130.5 80.39 180 top
RE365  100K_0402_5%  [R_0402]  144.7 77.65 0 top
RE505  100K_0402_5%  [R_0402]  130.5 79.63 180 top
RE506  0_0402_5%  [R0402_0OHM]  138.68 67.39 270 top
RE507  100K_0402_5%  [R_0402]  135.45 81.57 0 top
RE508  100K_0402_5%  [R_0402]  136.72 81.05 90 bottom
RE526  10K_0402_5%  [R_0402]  145.61 78.45 180 top
RE532  4.7K_0402_5%  [R_0402]  145.62 75.28 180 top
RE536  0_0402_5%  [R_0402]  145.77 76.09 180 bottom
RE539  100_0402_5%  [R_0402]  154.92 71.15 180 bottom
RE541  100K_0402_5%  [R_0402]  143.68 84.84 0 top
RE543  1M_0402_5%  [R_0402]  145.74 85.82 270 top
RE546  10K_0402_5%  [R_0402]  147.44 89.23 270 top
RE548  0_0402_5%  [R0402_0OHM]  133.76 66.47 90 top
RE549  100K_0402_5%  [R_0402]  129.77 69.86 0 top
RE550  100K_0402_5%  [R_0402]  130.69 70.75 180 top
RE551  0_0402_5%  [R_0402]  146.68 89.23 270 top
RE552  0_0402_5%  [R0402_0OHM]  151.58 86.04 90 top
RE557  10K_0402_5%  [R_0402]  114.64 67.9 180 top
RE561  100K_0402_5%  [R_0402]  134.52 67.58 180 bottom
RE563  10K_0402_5%  [R_0402]  158.57 69.77 270 bottom
RE564  10K_0402_5%  [R_0402]  154.81 74.06 0 bottom
RE565  10K_0402_5%  [R_0402]  158.32 79.21 270 bottom
RE566  10K_0402_5%  [R_0402]  159.35 68.89 0 bottom
RE567  10K_0402_5%  [R_0402]  159.08 78.3 90 bottom
RE568  10K_0402_5%  [R_0402]  160.27 69.67 180 bottom
RE569  0_0402_5%  [R_0402]  153.11 86.96 270 top
RE570  0_0402_5%  [R_0402]  152.35 86.96 270 top
RE700  100K_0402_5%  [R_0402]  130.34 72.89 180 top
RE701  100K_0402_5%  [R_0402]  130.45 73.67 180 top
RE702  1M_0402_5%  [R_0402]  130.34 72.11 180 top
RE703  0_0402_5%  [R_0402]  122.63 65.55 0 top
RE730  2.2K_0402_5%  [R_0402]  136.28 84.52 90 top
RE731  2.2K_0402_5%  [R_0402]  137.04 84.52 90 top
RE732  100K_0402_5%  [R_0402]  141.87 65.31 270 top
RE733  100K_0402_5%  [R_0402]  141.11 65.31 270 top
RE734  100K_0402_5%  [R_0402]  140.35 65.31 270 top
RE735  100K_0402_5%  [R_0402]  139.58 65.31 270 top
RE736  100K_0402_5%  [R_0402]  138.12 74.89 270 bottom
RE737  100K_0402_5%  [R_0402]  137.93 68.99 270 bottom
RE738  100K_0402_5%  [R_0402]  138.12 75.63 90 bottom
RE739  10K_0402_5%  [R_0402]  118.13 59.9 180 bottom
RE740  10K_0402_5%  [R_0402]  118.13 60.72 180 bottom
RE741  10K_0402_5%  [R_0402]  118.13 61.55 180 bottom
RE742  10K_0402_5%  [R_0402]  118.13 62.37 180 bottom
RE743  0_0201_5%  [R_0201]  117.17 75.81 270 bottom
RE745  0_0402_5%  [R_0402]  143.58 70.11 90 bottom
RE746  0_0201_5%  [R_0201]  141.36 69.4 270 bottom
RE747  0_0402_5%  [R0402_0OHM]  143.7 81.68 0 top
RE748  100K_0402_5%  [R_0402]  142.94 64.72 0 top
RE749  0_0402_5%  [R0402_0OHM]  140.6 81.36 0 bottom
RE750  100K_0402_5%  [R_0402]  137.51 80.74 90 bottom
RH1  100K_0402_5%  [R_0402]  128.27 56.4 0 bottom
RH6  0_0402_5%  [R0402_0OHM]  163.31 72.07 90 bottom
RH28  33_0402_5%  [R_0402]  101.41 25.51 180 bottom
RH29  33_0402_5%  [R_0402]  119.47 24.2 0 bottom
RH30  20K_0402_5%  [R_0402]  114.01 21.34 90 bottom
RH37  0_0402_5%  [R0402_0OHM]  123.26 11.62 90 bottom
RH38  30_0402_5%  [R_0402]  128.72 52.67 270 top
RH39  30_0402_5%  [R_0402]  129.49 52.67 270 top
RH42  30_0402_5%  [R_0402]  130.81 52.11 90 top
RH43  0_0402_5%  [R0402_0OHM]  127.45 20.22 180 top
RH44  10M_0402_5%  [R_0402]  125.77 21.08 270 top
RH45  33_0402_5%  [R_0402]  116.73 43.39 0 top
RH46  33_0402_5%  [R_0402]  116.73 44.17 0 top
RH48  33_0402_5%  [R_0402]  119.06 42.04 0 top
RH50  33_0402_5%  [R_0402]  119 45.52 0 top
RH56  1K_0402_5%  [R_0402]  113.84 35.12 0 top
RH57  1K_0402_5%  [R_0402]  111.63 24.56 180 top
RH61  4.7K_0402_5%  [R_0402]  116.71 36.34 0 top
RH65  100K_0402_5%  [R_0402]  111.73 33.24 90 bottom
RH66  0_0402_5%  [R0402_0OHM]  123.21 57.98 270 top
RH67  499_0402_1%  [R_0402]  116.71 35.57 0 top
RH70  8.2K_0402_5%  [R_0402]  122.53 58.92 180 top
RH73  13_0402_5%  [R_0402]  131.71 56.23 90 top
RH74  10K_0402_5%  [R_0402]  130.95 56.23 90 top
RH75  620_0402_5%  [R_0402]  133.53 55.95 0 top
RH76  10K_0402_5%  [R_0402]  128.85 21.58 90 bottom
RH77  499_0402_1%  [R_0402]  115.97 35.93 90 top
RH78  4.7K_0402_5%  [R_0402]  119 36.51 0 top
RH80  1K_0402_5%  [R_0402]  115.01 33.31 180 top
RH81  1K_0402_5%  [R_0402]  113.59 34.3 0 top
RH83  1K_0402_5%  [R_0402]  123.23 27.77 90 bottom
RH86  4.7K_0402_5%  [R_0402]  119.29 33.44 0 bottom
RH90  10K_0402_5%  [R_0402]  342.06 46.02 180 top
RH92  1K_0201_5%  [R_0201]  122.96 21.68 270 top
RH93  10K_0201_5%  [R_0201]  115.26 25.37 180 top
RH94  8.2K_0402_5%  [R_0402]  119.53 25.41 180 top
RH95  10K_0402_5%  [R_0402]  112.27 28.72 0 top
RH97  33_0402_5%  [R_0402]  124.15 30.65 180 bottom
RH99  22_0402_5%  [R_0402]  120.2 32.64 180 bottom
RH100  0_0402_5%  [R0402_0OHM]  168.23 94.91 0 bottom
RH101  1K_0402_5%  [R_0402]  169.15 95.82 180 bottom
RH110  10K_0402_5%  [R_0402]  137.88 47.06 0 bottom
RH123  10K_0201_5%  [R_0201]  117.75 32.4 180 top
RH124  10K_0201_5%  [R_0201]  115.59 31.6 90 top
RH126  10K_0201_5%  [R_0201]  128.93 33.62 180 bottom
RH127  10K_0201_5%  [R_0201]  123.98 33.67 180 bottom
RH128  10K_0201_5%  [R_0201]  123.98 32.91 180 bottom
RH130  10K_0201_5%  [R_0201]  134.69 22.79 270 top
RH131  10K_0201_5%  [R_0201]  135.27 22.79 270 top
RH132  10K_0201_5%  [R_0201]  136.47 22.82 270 bottom
RH133  10K_0201_5%  [R_0201]  134.12 22.79 270 top
RH134  10K_0201_5%  [R_0201]  137.23 22.79 270 bottom
RH152  0_0201_5%  [R_0201]  139.38 53.98 180 top
RH153  1M_0402_1%  [R_0402]  139.7 54.66 180 top
RH154  0_0402_5%  [R0402_0OHM]  134.22 58.25 90 top
RH155  0_0402_5%  [R0402_0OHM]  133.45 58.26 90 top
RH156  30_0402_5%  [R_0402]  132.5 56.24 90 top
RH161  0_0402_5%  [R0402_0OHM]  147.36 55.61 270 top
RH166  0_0402_5%  [R0402_0OHM]  146.6 55.61 270 top
RH167  0_0402_5%  [R0402_0OHM]  145.21 54.68 90 top
RH168  0_0402_5%  [R0402_0OHM]  144.45 54.68 90 top
RH169  0_0402_5%  [R0402_0OHM]  146.48 53.69 270 top
RH170  0_0402_5%  [R0402_0OHM]  145.72 53.69 270 top
RH171  2.7K_0402_1%  [R_0402]  138.96 54.07 0 bottom
RH177  0_0201_5%  [R_0201]  114.2 16.59 270 bottom
RH178  4.99_0402_1%  [R_0402]  110.56 20.18 270 bottom
RH179  4.99_0402_1%  [R_0402]  117.23 20.28 270 bottom
RH180  1K_0402_5%  [R_0402]  126.95 21.85 180 top
RH181  4.99_0402_1%  [R_0402]  115.19 23.73 90 bottom
RH182  0_0201_5%  [R0201_0OHM]  115.05 22.62 0 bottom
RH183  4.99_0402_1%  [R_0402]  114.01 23.9 270 bottom
RH184  4.99_0402_1%  [R_0402]  110.69 22.38 90 bottom
RH185  0_0402_5%  [R_0402]  102.13 16.87 0 bottom
RH192  100_0402_1%  [R_0402]  150.23 43.29 180 bottom
RH193  113_0402_1%  [R_0402]  144.27 51.63 90 top
RH198  1M_0402_5%  [R_0402]  126.57 23.81 90 bottom
RH199  100K_0402_5%  [R_0402]  124.12 55.5 90 top
RH200  20K_0402_5%  [R_0402]  120.37 20.78 90 top
RH201  20K_0402_5%  [R_0402]  121.26 20.78 90 top
RH203  10K_0402_5%  [R_0402]  119.91 31.38 180 top
RH204  10K_0402_5%  [R_0402]  114.93 27.08 180 top
RH214  100K_0402_5%  [R_0402]  116.71 46.62 0 top
RH215  0_0402_5%  [R0402_0OHM]  122.4 19.4 0 top
RH221  2.2K_0402_5%  [R_0402]  126.57 56.33 90 bottom
RH222  2.2K_0402_5%  [R_0402]  132.03 56.58 90 bottom
RH223  2.2K_0402_5%  [R_0402]  132.92 56.58 90 bottom
RH224  2.2K_0402_5%  [R_0402]  131.14 56.58 90 bottom
RH225  2.2K_0402_5%  [R_0402]  130.25 56.58 90 bottom
RH237  0_0402_5%  [R0402_0OHM]  131.98 38.75 180 bottom
RH239  0_0603_5%  [R_0603]  122.84 66.52 90 top
RH240  0_0402_5%  [R0402_0OHM]  149.76 47.64 180 bottom
RH241  0_0603_5%  [R_0603]  145.62 54.43 270 bottom
RH242  0_0603_5%  [R0603_0OHM]  124.06 69.48 270 top
RH243  10K_0402_5%  [R_0402]  117.85 26.33 180 top
RH246  0_0402_5%  [R0402_0OHM]  129.21 25.59 90 bottom
RH247  0_0603_5%  [R0603_0OHM]  123.26 37.47 270 bottom
RH250  0_0402_5%  [R_0402]  130.02 26.51 270 bottom
RH254  0_1206_5%  [R1206_0OHM]  147.04 33.76 0 bottom
RH255  0_0402_5%  [R_0402]  118.62 23.64 0 top
RH256  0_0402_5%  [R0402_0OHM]  132.1 34.12 90 bottom
RH257  0_0402_5%  [R0402_0OHM]  135.91 41.42 180 bottom
RH258  0_0402_5%  [R0402_0OHM]  136.75 40.32 270 bottom
RH259  0_0402_5%  [R0402_0OHM]  150.65 51.32 180 bottom
RH260  0_0402_5%  [R0402_0OHM]  140.15 41.23 180 bottom
RH267  10K_0402_5%  [R_0402]  117.66 33.26 180 top
RH268  10K_0402_5%  [R_0402]  119.91 33.8 180 top
RH279  0_1206_5%  [R1206_0OHM]  117.1 34.81 0 bottom
RH286  0_0402_5%  [R0402_0OHM]  140.02 39.93 180 bottom
RH287  0_0402_5%  [R0402_0OHM]  133.8 32.45 90 bottom
RH288  0_0402_5%  [R0402_0OHM]  132.41 32.45 90 bottom
RH290  0_0402_5%  [R0402_0OHM]  134.72 32.26 90 bottom
RH291  0_0402_5%  [R_0402]  130.83 34.47 180 bottom
RH292  0_0402_5%  [R0402_0OHM]  121.33 35.98 90 bottom
RH293  0_0402_5%  [R0402_0OHM]  124.37 37.18 270 bottom
RH294  0_0402_5%  [R0402_0OHM]  129.92 33.67 0 bottom
RH295  0_0402_5%  [R_0402]  122.22 35.98 90 bottom
RH296  0_0402_5%  [R_0402]  125.14 35.38 90 bottom
RH297  0_0402_5%  [R0402_0OHM]  125.8 23.81 90 bottom
RH298  0_0603_5%  [R0603_0OHM]  122.2 45.37 90 bottom
RH299  0_0402_5%  [R0402_0OHM]  122.68 44.49 0 bottom
RH300  0_0402_5%  [R0402_0OHM]  127.9 25.16 90 bottom
RH302  0_0402_5%  [R0402_0OHM]  136.09 36.3 90 bottom
RH303  0_0402_5%  [R0402_0OHM]  133.74 30.49 90 bottom
RH304  0_0402_5%  [R0402_0OHM]  129.23 37.3 270 bottom
RH305  0_0402_5%  [R0402_0OHM]  128.78 38.67 0 bottom
RH306  0_0402_5%  [R0402_0OHM]  134.57 30.33 90 bottom
RH308  100K_0402_5%  [R_0402]  117.89 26.01 180 bottom
RH309  10K_0402_5%  [R_0402]  125.95 37.23 0 bottom
RH310  10K_0402_5%  [R_0402]  132.23 22.68 180 top
RH311  8.2K_0402_5%  [R_0402]  126.16 34.93 90 bottom
RH312  51_0402_5%  [R_0402]  125.56 56.21 90 top
RH313  51_0402_5%  [R_0402]  127.26 56.26 90 top
RH314  51_0402_5%  [R_0402]  130.11 56.25 90 top
RH315  51_0402_5%  [R_0402]  128.09 56.26 90 top
RH319  10K_0201_5%  [R_0201]  121.37 116.48 0 top
RH324  10K_0402_5%  [R_0402]  370.09 13.37 270 top
RH325  10K_0201_5%  [R_0201]  136.54 20.04 90 top
RH326  10K_0201_5%  [R_0201]  129.3 22.2 90 top
RH327  1K_0402_5%  [R_0402]  119.91 30.24 180 top
RH328  1K_0402_5%  [R_0402]  116.72 42.62 0 top
RH329  150K_0402_5%  [R_0402]  114.96 30.62 180 top
RH330  49.9K_0402_1%  [R_0402]  18.97 46.48 90 bottom
RH331  4.7K_0402_5%  [R_0402]  119 32.78 0 top
RH333  2.2K_0402_5%  [R_0402]  110.82 22.35 90 top
RH334  1K_0402_5%  [R_0402]  111.93 23.91 0 bottom
RH335  20K_0402_5%  [R_0402]  112.14 22.23 90 bottom
RH339  10K_0402_5%  [R_0402]  128.65 34.94 180 bottom
RH340  8.2K_0402_1%  [R_0402]  120.2 31.87 180 bottom
RH349  100K_0402_5%  [R_0402]  119.94 40.45 180 bottom
RH350  100K_0402_5%  [R_0402]  119.93 36.35 180 bottom
RH351  33_0402_5%  [R_0402]  120.72 11.62 90 bottom
RH352  0_0402_5%  [R_0402]  112.89 26.41 180 bottom
RH353  33_0402_5%  [R_0402]  112 24.73 90 bottom
RH355  10K_0402_1%  [R_0402]  127.14 38.62 0 bottom
RH360  49.9K_0402_1%  [R_0402]  115.95 39.19 0 top
RH361  49.9K_0402_1%  [R_0402]  115.95 38.39 0 top
RH364  1K_0402_5%  [R_0402]  144.63 51.64 90 bottom
RH365  0_0402_5%  [R0402_0OHM]  143.03 52.67 90 bottom
RH371  10K_0402_5%  [R_0402]  119.93 37.24 180 bottom
RH372  10K_0402_5%  [R_0402]  119.93 38.13 180 bottom
RH373  100K_0402_5%  [R_0402]  117.63 40.71 180 top
RH374  2.2K_0402_5%  [R_0402]  107.89 24.98 0 top
RH376  49.9K_0402_1%  [R_0402]  16.83 46.5 90 bottom
RH378  10K_0402_5%  [R_0402]  116.71 41.63 0 top
RH379  100_0402_1%  [R_0402]  126.66 32.67 0 bottom
RH380  10K_0402_5%  [R_0402]  332.02 55.11 180 bottom
RH400  10K_0402_5%  [R_0402]  116.9 41.89 270 bottom
RH401  10K_0402_5%  [R_0402]  119.91 42.43 180 bottom
RH402  10K_0402_5%  [R_0402]  116.84 31.13 0 top
RH424  10K_0402_5%  [R_0402]  127.34 20.72 0 bottom
RH431  100K_0402_5%  [R_0402]  117.68 17.79 270 top
RH432  499K_0402_1%  [R_0402]  115.95 23.26 0 top
RH433  49.9K_0402_1%  [R_0402]  117.61 22.13 0 top
RH435  60.4_0402_1%  [R_0402]  140.33 55.29 180 bottom
RH436  0_0201_5%  [R_0201]  140.18 55.33 180 top
RH439  0_0402_5%  [R_0402]  112.2 18.25 0 top
RH440  0_0402_5%  [R0402_0OHM]  111.16 17.78 180 top
RH441  0_0402_5%  [R_0402]  119.91 28.16 180 top
RH442  0_0402_5%  [R0402_0OHM]  124.03 14.57 0 top
RH443  0_0402_5%  [R_0402]  117.7 29.94 180 top
RH445  0_0402_5%  [R0402_0OHM]  119.67 16.11 90 top
RH446  0_0201_5%  [R_0201]  123.53 61.2 0 top
RH553  10K_0402_5%  [R_0402]  119.94 38.9 180 bottom
RH554  10K_0402_5%  [R_0402]  119.94 39.68 180 bottom
RH555  10K_0402_5%  [R_0402]  126.95 35.84 270 bottom
RH556  10K_0402_5%  [R_0402]  129.98 35.75 0 bottom
RH600  100K_0402_5%  [R_0402]  111.33 20.18 270 bottom
RH601  100K_0402_5%  [R_0402]  136.47 21.85 90 top
RH602  100K_0402_5%  [R_0402]  114.86 26.15 180 top
RH603  10K_0201_5%  [R_0201]  125.74 52.21 90 top
RH604  4.7K_0201_5%  [R_0201]  124.92 52.5 270 bottom
RH605  20K_0201_5%  [R_0201]  122.18 51.96 90 top
RH606  100K_0201_5%  [R_0201]  122.76 51.96 90 top
RH607  100K_0201_5%  [R_0201]  127.89 44.26 270 bottom
RH608  100K_0201_5%  [R_0201]  126.59 44.9 270 bottom
RH609  200_0402_1%  [R_0402]  118.31 51.7 0 top
RH610  200_0402_1%  [R_0402]  123.28 49.05 270 bottom
RH611  200_0402_1%  [R_0402]  124.99 48.66 180 bottom
RH612  150_0402_1%  [R_0402]  121.49 52.67 270 top
RH613  20K_0402_5%  [R_0402]  126.44 52.72 270 top
RH614  20K_0402_5%  [R_0402]  123.52 52.53 270 top
RH615  2.2K_0402_5%  [R_0402]  137.23 21.85 90 top
RH616  0_0402_5%  [R0402_0OHM]  125.07 52.53 270 top
RH617  75K_0402_5%  [R_0402]  119.94 40.33 180 top
RH619  0_0402_5%  [R0402_0OHM]  111.68 32.4 0 bottom
RH622  0_0402_5%  [R0402_0OHM]  113.56 33.29 270 bottom
RH623  0_0201_5%  [R_0201]  135.01 11.85 180 bottom
RH624  0_0201_5%  [R0201_0OHM]  148.33 136.26 180 top
RH625  0_0201_5%  [R0201_0OHM]  114.75 35.42 270 bottom
RH626  0_0201_5%  [R0201_0OHM]  24.79 23.12 0 bottom
RH628  2.2K_0402_5%  [R_0402]  127.45 56.33 90 bottom
RH629  100K_0201_5%  [R_0201]  117.4 31.47 180 bottom
RH630  100K_0402_5%  [R_0402]  129.36 44.64 90 bottom
RH631  100K_0201_5%  [R_0201]  116.81 27.31 90 top
RH632  100K_0201_5%  [R_0201]  122.15 29.44 90 bottom
RH633  75K_0201_5%  [R_0201]  111.14 33.19 0 top
RH634  100K_0201_5%  [R_0201]  111.59 37.8 180 top
RH635  100K_0201_5%  [R_0201]  109.42 13.26 270 bottom
RH636  100K_0201_5%  [R_0201]  119.15 46.22 0 top
RH637  100K_0201_5%  [R_0201]  119.2 44.49 0 top
RH638  100K_0201_5%  [R_0201]  120.57 29.69 90 bottom
RH639  100K_0201_5%  [R_0201]  117.16 29.95 180 bottom
RH640  100K_0201_5%  [R_0201]  127.98 22.53 270 bottom
RH641  100K_0201_5%  [R_0201]  114.27 32.32 180 top
RH710  10K_0402_5%  [R_0402]  132.66 20.73 270 top
RH711  10K_0402_5%  [R_0402]  131.65 18.1 90 top
RH712  10K_0402_5%  [R_0402]  134.9 19.06 180 top
RH713  10K_0402_5%  [R_0402]  130.06 18.1 90 top
RH714  10K_0402_5%  [R_0402]  130.95 20.67 270 bottom
RH715  10K_0402_5%  [R_0402]  131.71 20.67 270 bottom
RH716  10K_0402_5%  [R_0402]  132.47 20.67 270 bottom
RH717  10K_0402_5%  [R_0402]  133.23 20.67 270 bottom
RH718  15K_0402_5%  [R_0402]  135.27 16.41 270 top
RH719  15K_0402_5%  [R_0402]  134.5 16.41 270 top
RH720  15K_0402_5%  [R_0402]  132.98 16.41 270 top
RH721  15K_0402_5%  [R_0402]  133.74 16.41 270 top
RH722  33_0402_5%  [R_0402]  117.23 21.35 0 bottom
RH723  33_0402_5%  [R_0402]  117.22 22.18 0 bottom
RH724  33_0402_5%  [R_0402]  117.09 23.83 0 bottom
RH725  33_0402_5%  [R_0402]  117.09 24.59 0 bottom
RH726  33_0402_5%  [R_0402]  109.05 22.94 180 bottom
RH727  33_0402_5%  [R_0402]  109.05 20.21 180 bottom
RH728  33_0402_5%  [R_0402]  109.05 21.1 180 bottom
RH729  33_0402_5%  [R_0402]  109.05 21.92 180 bottom
RH730  10K_0402_5%  [R_0402]  131.7 22.56 0 bottom
RH731  10K_0402_5%  [R_0402]  138.76 20.7 90 top
RH732  0_0402_5%  [R0402_0OHM]  138.94 19.64 0 top
RH733  75K_0402_5%  [R_0402]  123.26 41.79 90 bottom
RH734  10K_0402_5%  [R_0402]  163.97 47.4 90 bottom
RH735  0_0402_5%  [R_0402]  113.12 26.37 180 top
RH736  100K_0402_5%  [R_0402]  111.9 35.05 90 top
RI13  10K_0402_5%  [R_0402]  384.6 56.45 0 top
RI14  22.1K_0402_1%  [R_0402]  379.62 59.21 0 top
RI27  0_0402_5%  [R_0402-NPM]  152.62 101.93 90 bottom
RI28  0_0402_5%  [R_0402-NPM]  151.86 101.93 90 bottom
RI29  0_0402_5%  [R_0402-NPM]  153.51 101.93 90 bottom
RI30  0_0402_5%  [R_0402-NPM]  154.28 101.93 90 bottom
RI49  0_0402_5%  [R_0402-NPM]  111.83 100.84 90 bottom
RI50  0_0402_5%  [R_0402-NPM]  110.82 100.84 90 bottom
RI60  0_0402_5%  [R_0402-NPM]  385.95 64.09 0 top
RI61  0_0402_5%  [R_0402-NPM]  385.95 63.32 0 top
RI62  4.7K_0402_5%  [R_0402]  380.84 49.61 90 bottom
RI63  4.7K_0402_5%  [R_0402]  380.08 49.61 90 bottom
RI64  4.7K_0402_5%  [R_0402]  379.32 49.61 90 bottom
RI65  4.7K_0402_5%  [R_0402]  378.56 49.61 90 bottom
RI66  4.7K_0402_5%  [R_0402]  381.61 49.61 90 bottom
RI67  10K_0402_5%  [R_0402]  378.99 35.45 180 top
RI68  0_0402_5%  [R_0402-NPM]  385.82 37.1 0 top
RI69  4.7K_0402_5%  [R_0402]  381.22 59.16 270 bottom
RI70  0_0402_5%  [R_0402-NPM]  385.82 36.34 0 top
RI71  22.1K_0402_1%  [R_0402]  381.45 40.48 270 top
RI72  4.7K_0402_5%  [R_0402]  380.46 59.16 270 bottom
RI73  4.7K_0402_5%  [R_0402]  379.7 59.16 270 bottom
RI74  4.7K_0402_5%  [R_0402]  382.75 59.16 270 bottom
RI75  2K_0402_5%  [R_0402]  381.99 59.16 270 bottom
RI76  4.99K_0402_1%  [R_0402]  385.54 56.67 180 bottom
RI77  0_0402_5%  [R_0402]  375.56 55.02 0 bottom
RI78  4.7K_0402_5%  [R_0402]  385.16 39.32 90 bottom
RI79  22.1K_0402_1%  [R_0402]  112.52 150.26 0 top
RI80  4.7K_0402_5%  [R_0402]  383.38 39.32 90 bottom
RI81  4.7K_0402_5%  [R_0402]  384.27 39.32 90 bottom
RI82  10K_0402_5%  [R_0402]  118.11 147.14 0 top
RI83  4.7K_0402_5%  [R_0402]  382.49 39.32 90 bottom
RI84  0_0402_5%  [R_0402-NPM]  119.33 154.5 90 top
RI85  4.7K_0402_5%  [R_0402]  386.13 39.36 90 bottom
RI86  4.7K_0402_5%  [R_0402]  385.17 48.55 270 bottom
RI87  0_0402_5%  [R_0402-NPM]  120.15 154.5 90 top
RI88  4.7K_0402_5%  [R_0402]  384.24 48.55 270 bottom
RI89  4.7K_0402_5%  [R_0402]  383.44 48.55 270 bottom
RI90  4.7K_0402_5%  [R_0402]  387.01 48.55 270 bottom
RI91  2K_0402_5%  [R_0402]  386.09 48.55 270 bottom
RI92  4.99K_0402_1%  [R_0402]  388.92 45.62 180 bottom
RI93  0_0402_5%  [R_0402]  379.45 45.75 0 bottom
RI94  0_0603_5%  [R_0603]  376.62 57.1 270 top
RI95  0_0603_5%  [R_0603]  384.57 39.89 180 top
RL1  10K_0402_5%  [R_0402]  147.77 138.82 0 top
RL2  10K_0402_5%  [R_0402]  147.77 137.67 0 top
RL3  0_0402_5%  [R0402_0OHM]  158.83 139.35 0 bottom
RL5  10K_0402_5%  [R_0402]  159.75 137.79 180 bottom
RL6  4.7K_0402_5%  [R_0402]  161.05 134.1 180 top
RL7  0_0402_5%  [R0402_0OHM]  159.73 136.23 180 bottom
RL8  0_0603_5%  [R0603_0OHM]  158.95 136.2 0 top
RL9  10K_0402_5%  [R_0402]  158.83 137 0 bottom
RL10  0_0402_5%  [R0402_0OHM]  159.83 135.21 180 top
RL12  1K_0402_1%  [R_0402]  148.68 139.83 180 top
RL13  3.01K_0402_1%  [R_0402]  158.23 142.88 90 top
RL14  150_0402_5%  [R_0402]  136.86 157.54 90 bottom
RL15  75_0402_1%  [R_0402]  158.26 161.32 0 top
RL16  75_0402_1%  [R_0402]  158.14 168.94 0 top
RL17  75_0402_1%  [R_0402]  158.26 162.59 0 top
RL18  75_0402_1%  [R_0402]  158.14 170.21 0 top
RL19  150_0402_5%  [R_0402]  134.82 149.93 90 top
RL20  150_0402_5%  [R_0402]  134.06 149.93 90 top
RL29  1M_0402_5%  [R_0402]  130.3 146.45 0 top
RL30  1M_0402_5%  [R_0402]  134.26 142.64 180 top
RL34  0_0402_5%  [R_0402]  158.17 141.96 270 top
RL50  4.7K_0402_5%  [R_0402]  159.75 138.57 180 bottom
RL71  0_0402_5%  [R0402_0OHM]  158.04 145.82 90 top
RL72  0_0402_5%  [R0402_0OHM]  156.77 145.82 90 top
RL73  0_0402_5%  [R0402_0OHM]  155.54 145.15 90 top
RL74  0_0402_5%  [R0402_0OHM]  154.27 145.15 90 top
RL75  0_0402_5%  [R0402_0OHM]  153 145.15 90 top
RL76  0_0402_5%  [R0402_0OHM]  151.73 145.15 90 top
RL77  0_0402_5%  [R0402_0OHM]  150.46 145.15 90 top
RL78  0_0402_5%  [R0402_0OHM]  149.19 145.15 90 top
RN1  100K_0402_5%  [R_0402]  305.28 19.66 0 bottom
RN2  100K_0402_5%  [R_0402]  303.39 21.83 270 bottom
RN37  10K_0402_5%  [R_0402]  329.23 22.95 90 bottom
RN99  0_0402_5%  [R0402_0OHM]  329.4 16.02 0 bottom
RN200  10K_0402_5%  [R_0402]  316 16.14 180 bottom
RN202  10K_0402_5%  [R_0402]  365.05 13.22 180 bottom
RN203  10K_0402_5%  [R_0402]  368.88 12.46 90 bottom
RN205  0_0402_5%  [R0402_0OHM]  369.67 12.46 90 bottom
RN207  0_0402_5%  [R0402_0OHM]  329.47 40.81 0 bottom
RN208  10K_0402_5%  [R_0402]  316.51 40.91 180 bottom
RN210  10K_0402_5%  [R_0402]  129.99 87.54 0 bottom
RN211  10K_0402_5%  [R_0402]  126.24 99.71 0 bottom
RN213  0_0402_5%  [R0402_0OHM]  122.5 87.21 270 bottom
RN216  0_0402_5%  [R_0402]  329.44 55.13 0 bottom
RN217  0_0402_5%  [R_0402]  329.87 29.1 0 bottom
RN218  0_0402_5%  [R_0402]  371.45 12.82 90 top
RN219  0_0402_5%  [R0402_0OHM]  329.87 29.99 0 bottom
RN220  0_0402_5%  [R0402_0OHM]  380.06 13.67 90 top
RN474  0_0402_5%  [R_0402]  135.74 87.94 270 top
RN475  0_0402_5%  [R0402_0OHM]  330.83 55.96 0 bottom
RN476  0_0402_5%  [R0402_0OHM]  136.51 87.94 270 top
RR200  0_0603_5%  [R0603_0OHM]  22.74 8.9 180 bottom
RR201  10K_0402_5%  [R_0402]  16.12 22.44 0 bottom
RR205  6.2K_0402_1%  [R_0402]  17.97 21.37 90 bottom
RR211  10K_0402_5%  [R_0402]  23.92 24.45 270 bottom
RR213  10_0402_5%  [R_0402]  14.78 11.69 270 bottom
RR227  0_0603_1%  [R_0603]  10.82 19.65 0 bottom
RR228  0_0402_5%  [R0402_0OHM]  12.52 13.26 270 bottom
RR229  0_0402_5%  [R0402_0OHM]  12.67 11.58 270 bottom
RR230  0_0402_5%  [R0402_0OHM]  13.44 11.58 270 bottom
RR231  0_0402_5%  [R0402_0OHM]  23.52 9.92 180 bottom
RR232  0_0402_5%  [R_0402]  23.11 10.68 0 bottom
RR233  0_0402_5%  [R0402_0OHM]  16.51 9.53 90 bottom
RR234  0_0402_5%  [R0402_0OHM]  15.73 9.53 90 bottom
RR235  0_0402_5%  [R_0402]  21.71 7.89 0 bottom
RR236  10K_0402_5%  [R_0402]  23.96 3.25 0 bottom
RR237  10K_0402_5%  [R_0402]  23.96 2.36 0 bottom
RR238  10K_0402_5%  [R_0402]  13.18 5.58 90 bottom
RR239  10K_0402_5%  [R_0402]  24.88 4.02 180 bottom
RT1  3.3K_0402_5%  [R_0402]  46.48 42.56 0 top
RT2  2.2K_0402_5%  [R_0402]  47.06 52.72 90 top
RT3  2.2K_0402_5%  [R_0402]  46.03 52.69 90 top
RT4  3.3K_0402_5%  [R_0402]  44.52 52.72 90 top
RT5  10K_0402_5%  [R_0402]  41.73 42.76 270 top
RT6  10K_0402_5%  [R_0402]  39.11 40.88 0 top
RT7  10K_0402_5%  [R_0402]  40.89 42.76 270 top
RT8  10K_0402_5%  [R_0402]  40.08 42.76 270 top
RT9  0_0402_5%  [R_0402]  45.13 51.45 180 bottom
RT11  10K_0402_5%  [R_0402]  31.99 56.38 90 bottom
RT16  10K_0201_5%  [R_0201]  36.49 52.98 90 top
RT17  10K_0201_5%  [R_0201]  37.06 52.98 90 top
RT20  10K_0402_5%  [R_0402]  41.97 55.63 90 bottom
RT23  100K_0402_5%  [R_0402]  40.85 58.34 135 bottom
RT26  100K_0402_5%  [R_0402]  39.7 49.77 270 top
RT27  100K_0402_5%  [R_0402]  41.73 52.85 90 top
RT33  100K_0402_5%  [R_0402]  38.17 57.46 180 bottom
RT34  3.01K_0402_1%  [R_0402]  37.97 44.57 0 top
RT36  100_0402_5%  [R_0402]  44.24 44.66 270 bottom
RT37  0_0402_5%  [R_0402]  30.55 56.33 90 bottom
RT39  4.75K_0402_0.5%  [R_0402]  34.93 52.35 0 top
RT40  0_0402_5%  [R_0402]  32.41 39.44 180 bottom
RT41  200_0402_1%  [R_0402]  32.26 42.92 0 top
RT42  200_0402_1%  [R_0402]  32.26 43.73 0 top
RT120  0_0402_5%  [R0402_0OHM]  15.39 53.61 180 bottom
RT121  0_0402_5%  [R0402_0OHM]  15.39 54.75 180 bottom
RT122  0_0402_5%  [R0402_0OHM]  14.86 54.12 0 top
RT123  0_0402_5%  [R0402_0OHM]  14.86 54.88 0 top
RT184  100K_0402_5%  [R_0402]  38.43 52.77 90 top
RT372  10K_0402_5%  [R_0402]  40.23 52.75 90 top
RT385  0_0201_5%  [R0201_0OHM]  24.62 30.81 180 bottom
RT386  0_0201_5%  [R0201_0OHM]  24.62 31.44 180 bottom
RT387  0_0201_5%  [R0201_0OHM]  24.36 29.03 0 bottom
RT388  0_0201_5%  [R0201_0OHM]  24.36 29.61 0 bottom
RT391  10K_0402_5%  [R_0402]  46.49 56.85 180 bottom
RT392  0_0201_5%  [R0201_0OHM]  39.34 52.75 90 top
RT394  0_0402_5%  [R_0402]  30.62 39.45 270 bottom
RT440  1M_0201_5%  [R_0201]  118.73 63.58 180 top
RT441  0_0201_5%  [R0201_0OHM]  119.31 62.98 90 top
RT445  0_0201_5%  [R_0201]  112.84 65.23 0 top
RT447  10K_0201_5%  [R_0201]  118.73 65.29 180 top
RT448  0_0201_5%  [R0201_0OHM]  113.32 63.39 0 top
RT456  0_0201_5%  [R0201_0OHM]  112.84 64.59 0 top
RT499  0_0201_5%  [R0201_0OHM]  114.02 61.61 0 top
RT500  0_0201_5%  [R0201_0OHM]  114.02 60.84 0 top
RT501  0_0201_5%  [R0201_0OHM]  118.4 59.77 0 top
RT502  10K_0402_5%  [R_0402]  42.19 47.54 90 top
RT503  2.2K_0402_5%  [R_0402]  42.19 50.18 270 top
RT505  100K_0402_5%  [R_0402]  43.13 55.69 90 bottom
RT506  100K_0402_5%  [R_0402]  44 57.97 180 bottom
RT507  100K_0402_5%  [R_0402]  44.14 55.69 90 bottom
RT508  100K_0402_5%  [R_0402]  39.82 57.46 180 bottom
RT509  100K_0402_5%  [R_0402]  39.57 55.56 90 bottom
RT510  2.2K_0402_5%  [R_0402]  12.09 30.88 180 bottom
RT511  2.2K_0402_5%  [R_0402]  12.09 32.91 180 bottom
RT512  0_0603_5%  [R_0603]  19.19 25.92 180 bottom
RT514  2.2K_0402_5%  [R_0402]  12.09 31.89 180 bottom
RT515  2.2K_0402_5%  [R_0402]  12.09 33.8 180 bottom
RT516  100K_0201_5%  [R_0201]  26.41 29.35 0 bottom
RT517  10K_0201_5%  [R_0201]  16.84 38.66 270 bottom
RT518  100K_0201_5%  [R_0201]  26.78 30.52 0 bottom
RT519  10K_0201_5%  [R_0201]  15.66 27.7 0 bottom
RT521  10K_0201_5%  [R_0201]  19.19 38.85 270 bottom
RT522  10K_0201_5%  [R_0201]  15.66 26.43 0 bottom
RT523  100K_0201_5%  [R_0201]  26.41 28.59 0 bottom
RT524  100K_0201_5%  [R_0201]  26.78 29.94 0 bottom
RT525  4.7K_0402_5%  [R_0402]  20.39 40.22 270 bottom
RT526  1K_0402_5%  [R_0402]  12.09 30.11 180 bottom
RT527  1K_0402_5%  [R_0402]  12.09 29.35 180 bottom
RT528  10K_0201_5%  [R_0201]  25.04 32.12 180 bottom
RT529  10K_0402_5%  [R_0402]  22.04 38.89 270 bottom
RT534  1.3K_0402_1%  [R_0402]  26.64 39.05 180 bottom
RT535  13.3K_0402_1%  [R_0402]  17.75 39.2 270 bottom
RT536  9.1K_0402_1%  [R_0402]  25.52 38.27 0 bottom
RT537  13.3K_0402_1%  [R_0402]  18.51 38.29 90 bottom
RT538  0_0402_5%  [R0402_0OHM]  14.59 63.1 90 bottom
RT539  0_0402_5%  [R0402_0OHM]  14.59 64.02 270 top
RT540  0_0402_5%  [R0402_0OHM]  15.59 63.1 90 bottom
RT541  0_0402_5%  [R0402_0OHM]  15.59 64.02 270 top
RT542  0_0805_5%  [R0805_0OHM]  39.99 17.41 180 top
RT543  300K_0402_5%  [R_0402]  47.94 19.59 180 top
RT544  300K_0402_5%  [R_0402]  44.05 17.62 180 top
RT545  1M_0402_1%  [R_0402]  44.44 13.87 270 top
RT546  10K_0402_1%  [R_0402]  44.54 14.69 180 top
RT547  0_0805_5%  [R0805_0OHM]  41.01 11.06 0 top
RT548  100K_0402_1%  [R_0402]  39.32 12.16 270 top
RT549  0_0402_5%  [R0402_0OHM]  39.34 12.97 0 top
RT550  0_0402_5%  [R0402_0OHM]  43.74 16.42 270 top
RT551  0_0201_5%  [R0201_0OHM]  18.21 46.52 90 bottom
RT552  0_0201_5%  [R0201_0OHM]  17.57 46.52 90 bottom
RT553  10K_0402_5%  [R_0402]  42.19 50.92 90 top
RT554  10K_0402_5%  [R_0402]  35.58 41.46 90 top
RT555  0_0201_5%  [R0201_0OHM]  25.77 33.16 180 bottom
RT556  0_0201_5%  [R0201_0OHM]  25.77 33.97 180 bottom
RT557  0_0201_5%  [R_0201]  23.91 33.16 0 bottom
RT558  0_0201_5%  [R_0201]  23.91 33.97 0 bottom
RT559  0_0201_5%  [R0201_0OHM]  19.9 27.51 270 bottom
RT560  0_0201_5%  [R0201_0OHM]  20.91 27.51 270 bottom
RT561  0_0201_5%  [R_0201]  19.9 28.2 90 bottom
RT562  0_0201_5%  [R_0201]  20.91 28.2 90 bottom
RT564  100K_0402_5%  [R_0402]  11.24 37.23 0 bottom
RT565  100_0603_5%  [R_0603]  30.82 27.8 180 bottom
RT566  100_0603_5%  [R_0603]  32.34 27.7 0 bottom
RT567  100K_0201_5%  [R_0201]  23.9 35.89 0 bottom
RT568  100K_0201_5%  [R_0201]  25.8 35.12 0 bottom
RT569  0_0603_5%  [R_0603]  19.19 24.65 180 bottom
RT570  0_0402_5%  [R0402_0OHM]  38.39 23.83 0 bottom
RT571  51K_0201_1%  [R_0201]  36.78 25.12 90 bottom
RT573  100K_0201_5%  [R_0201]  41.01 26.04 180 bottom
RT574  0_0402_5%  [R0402_0OHM]  45.07 23.33 180 bottom
RT575  51K_0201_1%  [R_0201]  43.74 26.73 90 bottom
RT577  100K_0201_5%  [R_0201]  45.84 25.58 90 bottom
RT578  0_0402_5%  [R_0402]  56.33 33.62 270 top
RT579  0_0201_5%  [R0201_0OHM]  23.23 28.35 270 bottom
RT580  0_0201_5%  [R0201_0OHM]  22.08 28.35 270 bottom
RT581  0_0201_5%  [R0201_0OHM]  24.51 35.33 180 bottom
RT582  0_0201_5%  [R0201_0OHM]  24.51 34.75 180 bottom
RT583  100K_0201_5%  [R_0201]  22.63 25.86 90 bottom
RT584  100K_0201_5%  [R_0201]  22.04 25.86 90 bottom
RT585  56K_0402_1%  [R_0402]  44.41 27.6 270 bottom
RT586  64.9K_0402_1%  [R_0402]  43.99 29.18 90 bottom
RT587  56K_0402_1%  [R_0402]  37.54 25.62 270 bottom
RT588  64.9K_0402_1%  [R_0402]  37.84 26.48 180 bottom
RT589  0_0201_5%  [R0201_0OHM]  21.5 28.35 270 bottom
RT590  0_0201_5%  [R0201_0OHM]  22.65 28.35 270 bottom
RT591  10K_0201_5%  [R_0201]  44.07 54.49 90 top
RT592  10K_0201_5%  [R_0201]  40.97 52.97 90 top
RT593  10K_0402_5%  [R_0402]  41.88 55.54 90 top
RT594  0_0201_5%  [R0201_0OHM]  28.23 43.83 0 top
RT595  0_0201_5%  [R0201_0OHM]  28.23 43.19 0 top
RT596  0_0201_5%  [R0201_0OHM]  28.23 46.5 0 bottom
RT597  0_0201_5%  [R0201_0OHM]  28.23 47.13 0 bottom
RT598  0_0201_5%  [R0201_0OHM]  29.2 48.02 180 top
RT599  0_0201_5%  [R0201_0OHM]  29.2 47.39 180 top
RT600  0_0201_5%  [R0201_0OHM]  29.96 50.69 180 bottom
RT601  0_0201_5%  [R0201_0OHM]  29.96 51.32 180 bottom
RT606  0_0201_5%  [R0201_0OHM]  25.08 27.43 0 bottom
RT607  0_0201_5%  [R0201_0OHM]  25.08 28.01 0 bottom
RT608  0_0201_5%  [R0201_0OHM]  24.5 36.46 180 bottom
RT609  0_0201_5%  [R0201_0OHM]  24.49 37.04 180 bottom
RT610  10K_0201_5%  [R_0201]  40.63 23.42 270 bottom
RT611  100K_0201_5%  [R_0201]  118.98 60.34 180 top
RT612  0_0201_5%  [R_0201]  119.64 60.34 270 top
RT613  10K_0201_5%  [R_0201]  44.93 55.51 0 bottom
RT614  100K_0402_5%  [R_0402]  39.77 54.82 0 top
RT615  100K_0402_5%  [R_0402]  130.57 20.07 90 top
RT616  100K_0402_5%  [R_0402]  130.57 21.79 90 top
RT617  100K_0201_5%  [R_0201]  21.6 40.08 90 bottom
RT618  100K_0201_5%  [R_0201]  22.74 39.85 90 bottom
RT619  0_0201_5%  [R0201_0OHM]  41.4 57.22 180 bottom
RT620  0_0201_5%  [R0201_0OHM]  39.05 58.3 180 bottom
RT621  0_0201_5%  [R_0201]  114.87 58.61 0 top
RT622  0_0201_5%  [R_0201]  111.94 66.12 90 top
RT623  0_0201_5%  [R_0201]  39.2 59.59 270 bottom
RT624  0_0201_5%  [R_0201]  38.62 59.59 270 bottom
RT643  10K_0201_5%  [R_0201]  39.79 55.6 90 top
RT644  100K_0402_5%  [R_0402]  129.04 20.03 0 bottom
RV3  100K_0402_5%  [R_0402]  113.93 145.19 270 top
RV4  100K_0402_5%  [R_0402]  142.68 136.97 0 top
RV5  47K_0402_5%  [R_0402]  141.69 137.92 180 top
RV7  4.7K_0402_5%  [R_0402]  123.9 133.6 270 top
RV50  4.99K_0402_1%  [R_0402]  305.32 75.51 270 top
RV55  4.7K_0402_5%  [R_0402]  297.63 77.94 270 bottom
RV56  4.7K_0402_5%  [R_0402]  298.4 77.03 90 bottom
RV57  4.7K_0402_5%  [R_0402]  292.07 84.09 0 top
RV58  4.7K_0402_5%  [R_0402]  292.98 83.19 180 top
RV59  4.7K_0402_5%  [R_0402]  292.07 82.27 0 top
RV60  4.7K_0402_5%  [R_0402]  292.98 81.36 180 top
RV61  4.7K_0402_5%  [R_0402]  292.09 80.39 0 top
RV62  4.7K_0402_5%  [R_0402]  293.01 79.45 180 top
RV63  4.7K_0402_5%  [R_0402]  292.05 78.58 0 top
RV64  4.7K_0402_5%  [R_0402]  292.96 77.62 180 top
RV65  4.7K_0402_5%  [R_0402]  294.13 74.57 90 top
RV66  4.7K_0402_5%  [R_0402]  295.04 75.49 270 top
RV125  4.7K_0402_5%  [R_0402]  292.04 76.68 0 top
RV126  4.7K_0402_5%  [R_0402]  304.38 74.62 90 top
RV127  4.7K_0402_5%  [R_0402]  292.04 75.71 0 top
RV130  1M_0402_5%  [R_0402]  301.98 87.57 180 top
RV131  1M_0402_5%  [R_0402]  302.79 82.31 180 bottom
RV485  0_0402_5%  [R0402_0OHM]  244.66 83.89 180 top
RV737  0_0201_5%  [R_0201]  165.28 108.32 0 top
RV738  0_0201_5%  [R_0201]  164.68 108.32 180 top
RV739  10K_0402_5%  [R_0402]  165.68 107.44 180 top
RV740  10K_0402_5%  [R_0402]  170.6 108.26 180 top
RV741  1K_0402_5%  [R_0402]  165.09 109.02 180 top
RV742  0_0201_5%  [R_0201]  169.62 107.3 0 top
RV800  0_0402_5%  [R0402_0OHM]  287.26 75.7 180 bottom
RV803  10K_0402_5%  [R_0402]  282.76 77.46 90 bottom
RV804  4.7K_0402_5%  [R_0402]  276.69 82.68 180 bottom
RV805  4.7K_0402_5%  [R_0402]  275.93 78.63 0 bottom
RV806  10K_0402_5%  [R_0402]  284.03 75.83 0 bottom
RV807  10K_0402_5%  [R_0402]  283.23 74.95 90 bottom
RV808  0_0402_5%  [R0402_0OHM]  67.94 51.32 0 top
RV809  0_0402_5%  [R0402_0OHM]  67.94 52.21 0 top
RV812  100K_0402_5%  [R_0402]  287.9 83.33 270 bottom
RV813  100K_0402_5%  [R_0402]  284.56 80.26 0 bottom
RV815  10K_0402_5%  [R_0402]  286.35 77.47 0 bottom
RV816  10K_0402_5%  [R_0402]  280.49 83.4 270 bottom
RV817  10K_0402_5%  [R_0402]  285.08 84.54 180 bottom
RV818  100K_0402_5%  [R_0402]  286.35 74.9 0 bottom
RV819  4.7K_0402_5%  [R_0402]  277.98 83.55 270 bottom
RV820  10K_0402_5%  [R_0402]  280.38 76.47 180 bottom
RV821  10K_0402_5%  [R_0402]  281.37 76.93 90 bottom
RV822  4.7K_0402_5%  [R_0402]  156.8 124.32 90 top
RV823  4.7K_0402_5%  [R_0402]  148.51 119.41 180 top
RV824  4.7K_0402_5%  [R_0402]  148.51 115.6 180 top
RV825  4.7K_0402_5%  [R_0402]  148.51 116.36 180 top
RV826  4.7K_0402_5%  [R_0402]  148.51 121.19 180 top
RV827  4.7K_0402_5%  [R_0402]  148.51 121.95 180 top
RV828  4.7K_0402_5%  [R_0402]  148.51 117.12 180 top
RV829  4.7K_0402_5%  [R_0402]  148.51 117.88 180 top
RV830  4.7K_0402_5%  [R_0402]  155.58 127.36 0 top
RV831  4.7K_0402_5%  [R_0402]  148.51 118.65 180 top
RV832  1M_0402_5%  [R_0402]  151.89 124.9 90 top
RV833  4.7K_0402_5%  [R_0402]  148.51 120.42 180 top
RV834  4.7K_0402_5%  [R_0402]  148.51 122.71 180 top
RV835  4.99K_0402_1%  [R_0402]  158.73 125.48 270 top
RV836  4.7K_0402_5%  [R_0402]  170.66 129.1 90 top
RV839  4.7K_0402_5%  [R_0402]  164.43 129.63 270 top
RV840  100K_0402_5%  [R_0402]  128.1 134.54 180 top
RV842  100K_0402_5%  [R_0402]  125.41 134.54 0 top
RV843  100K_0402_5%  [R_0402]  110.98 147.53 270 bottom
RV848  4.7K_0402_5%  [R_0402]  57.86 40.1 270 bottom
RV849  4.7K_0402_5%  [R_0402]  60.45 53.74 0 top
RV850  4.7K_0402_5%  [R_0402]  48.7 45.6 180 bottom
RV851  4.7K_0402_5%  [R_0402]  48.7 43.69 180 bottom
RV852  4.7K_0402_5%  [R_0402]  48.7 44.71 180 bottom
RV853  4.7K_0402_5%  [R_0402]  48.7 42.68 180 bottom
RV855  100K_0402_5%  [R_0402]  50.33 56.02 270 top
RV856  4.7K_0402_5%  [R_0402]  55.57 42.51 270 bottom
RV857  4.7K_0402_5%  [R_0402]  56.84 42.51 270 bottom
RV858  4.7K_0402_5%  [R_0402]  57.73 42.51 270 bottom
RV861  4.99K_0402_1%  [R_0402]  52.4 38.17 90 bottom
RV862  4.7K_0402_5%  [R_0402]  71.54 42.89 270 top
RV863  4.7K_0402_5%  [R_0402]  83.51 56.45 90 top
RV864  4.7K_0402_5%  [R_0402]  81.48 58.74 90 top
RV865  4.7K_0402_5%  [R_0402]  80.46 58.74 90 top
RV866  4.7K_0402_5%  [R_0402]  83.51 58.74 90 top
RV867  4.7K_0402_5%  [R_0402]  82.5 58.74 90 top
RV868  4.7K_0402_5%  [R_0402]  80.46 56.45 90 top
RV869  100K_0402_5%  [R_0402]  68.86 54.5 180 top
RV870  4.99K_0402_1%  [R_0402]  86 51.96 180 top
RV871  4.7K_0402_5%  [R_0402]  85.09 51.07 0 top
RV872  4.7K_0402_5%  [R_0402]  85.09 50.05 0 top
RV873  4.7K_0402_5%  [R_0402]  85.09 49.16 0 top
RV874  4.7K_0402_5%  [R_0402]  85.09 48.15 0 top
RV875  4.7K_0402_5%  [R_0402]  81.48 56.45 90 top
RV876  4.7K_0402_5%  [R_0402]  54.77 42.5 270 bottom
RV877  4.7K_0402_5%  [R_0402]  56.72 40.1 270 bottom
RV878  4.7K_0402_5%  [R_0402]  55.57 40.1 270 bottom
RV879  4.7K_0402_5%  [R_0402]  54.43 40.1 270 bottom
RV880  4.7K_0402_5%  [R_0402]  51.46 44.34 180 bottom
RV881  4.7K_0402_5%  [R_0402]  51.46 45.61 180 bottom
RV882  4.7K_0402_5%  [R_0402]  51.46 46.37 180 bottom
RV883  4.7K_0402_5%  [R_0402]  51.46 43.58 180 bottom
RV884  4.7K_0402_5%  [R_0402]  82.5 56.45 90 top
RV885  4.7K_0402_5%  [R_0402]  82.8 48.15 0 top
RV886  4.7K_0402_5%  [R_0402]  82.8 49.16 0 top
RV887  4.7K_0402_5%  [R_0402]  82.8 51.07 0 top
RV888  4.7K_0402_5%  [R_0402]  82.8 50.18 0 top
RV889  100K_0402_5%  [R_0402]  68.86 53.23 180 top
RV890  100K_0402_5%  [R_0402]  49.54 56.01 270 top
RV891  4.7K_0402_5%  [R_0402]  51.67 51.71 180 top
RV892  4.7K_0402_5%  [R_0402]  52.7 49.8 0 top
