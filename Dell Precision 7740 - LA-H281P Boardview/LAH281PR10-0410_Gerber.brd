# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_CTX_PRX_P2: length 158.6
  TOP w0.076: v2(235.28,70.75) 234.98,71.05 234.79,71.05 234.41,70.67 234.41,68.49 234.59,68.32 234.59,67.84 234.4,67.65 UC1.B5
  TOP w0.094: v2(141.62,32.69) UH1.J32
  IN1 w0.102: v2(141.62,32.69) 141.37,32.69 141.29,32.76 141.29,33.06 141.52,33.29 141.87,33.29 142.32,32.84 144.45,32.84 145.6,33.99 153.15,33.99 155.37,36.21 157.75,36.21 159.19,37.66 159.19,40.88 161.3,42.99 161.3,50.11 163.07,51.88 163.07,56.27 165.81,59.01 165.81,64.56 166.82,65.57 166.82,76.79 171.4,81.36 171.4,86.54 175.74,90.89 177.54,90.89 178.39,91.74 181.14,91.74 181.85,91.03 185.2,91.03 185.61,90.62 194.63,90.62 195.1,91.09 212.06,91.09 219.06,84.09 220.9,84.09 223.32,81.67 229.37,81.67 233.18,77.85 233.18,72.13 234.3,71.01 235.02,71.01 v2(235.28,70.75)
DMI_CTX_PRX_P3: length 159.9
  TOP w0.076: UC1.D4 233.24,66.47 233.3,66.53 233.57,66.53 233.88,66.83 233.88,67.11 233.8,67.19 233.8,71.06 235.01,72.27 235.78,72.27 235.84,72.2 v2(235.84,71.95)
  TOP w0.094: v2(143.11,33.6) UH1.F30
  IN1 w0.102: v2(235.84,71.95) 235.55,72.25 234.71,72.25 233.82,73.14 233.82,78.05 229.49,82.39 223.79,82.39 221.49,84.68 219.54,84.68 212.52,91.71 182.03,91.71 181.39,92.35 177.89,92.35 177.06,91.52 174.25,91.52 170.75,88.02 170.75,81.61 166.16,77.03 166.16,65.92 165.18,64.93 165.18,59.23 162.41,56.46 162.41,52.23 160.58,50.4 160.58,43.26 158.6,41.28 158.6,38.11 157.64,37.16 155.48,37.16 153.09,34.77 145.4,34.77 144.79,34.17 143.01,34.17 142.78,33.94 142.78,33.67 142.85,33.6 v2(143.11,33.6)
DMIC0: length 376.5
  TOP w0.109: v2(127.86,110.44) 126.99,111.32 CV843.1 126.36,111.32 125.78,110.73 124.56,110.73 124.07,111.23 124.07,111.53 DV4.2 122.21,113.39 122.21,115.29 122.11,115.39 120.6,115.39 119.32,116.67 119.32,117.36 119.25,117.44 119.25,117.61 119.2,117.66 JEDP1.13 ; UA1.4 375.43,24.01 RA52.2 374.72,23.3 374.01,23.3 v2(373.86,23.16) ; v2(162.37,60.76) v1(162.89,60.76)
  IN1 w0.102: v2(159.03,81.57) 160.35,81.57 162.08,79.85 162.08,74.04 161.89,73.86 161.89,72.87 162.06,72.7 162.42,72.7 163.09,72.04 163.09,66.42 163.2,66.31 163.2,61.59 v2(162.37,60.76)
  IN2 w0.081: v2(130.99,115.42) 130.87,115.42 130.04,114.58 130.04,114.25 129.66,113.88 129.66,113.67 128.75,112.75 128.75,111.18 128.02,110.44 v2(127.86,110.44)
  IN3 w0.081: v2(373.86,23.16) 373.86,23.12 374.34,22.64 374.34,21.57 369.86,17.08 364.77,17.08 364.49,16.8 356.3,16.8 356.07,16.58 350.41,16.58 350.22,16.77 346.33,16.77 345.6,16.04 344.8,16.04 344.63,15.86 342.24,15.86 341.83,15.45 333.8,15.45 332.55,16.69 319.61,16.69 315.1,12.18 310.62,12.18 309.7,11.26 300.82,11.26 300.19,10.63 278.76,10.63 277.72,11.67 271.26,11.67 266.84,16.09 263.96,16.09 263.46,16.59 262.01,16.59 260.62,17.98 256.28,17.98 256.16,17.86 248.18,17.86 247.57,18.46 243.63,18.46 242.89,17.72 240.63,17.72 240.04,17.13 240.04,17.13 239.75,16.84 233.55,16.84 229.23,12.52 215.42,12.52 214.29,11.39 175.15,11.39 173.8,12.74 171.34,12.74 167.43,16.65 167.43,22.21 166.26,23.38 166.26,26.09 167.13,26.95 167.13,35.19 163.52,38.8 163.52,46.62 165.24,48.34 165.24,48.78 165.99,49.53 165.99,50.15 166.18,50.35 166.18,53.65 163.72,56.1 162.37,56.1 160.91,57.56 160.91,59.93 161.74,60.76 v2(162.37,60.76)
  IN4 w0.102: v2(130.99,115.42) 131.38,115.42 132.55,114.25 132.55,108.97 133.23,108.28 133.23,103.96 133.89,103.31 137.71,103.31 140.53,100.49 140.53,99.53 140.85,99.2 141.86,99.2 149.1,91.96 152.81,91.96 158.8,85.97 158.8,82.7 159.03,82.47 v2(159.03,81.57)
DMIC_CLK: length 379.1
  TOP w0.109: v2(373.37,21.26) v1(374.05,21.26) 374.8,22.01 CA54.1 374.8,22.64 375.09,22.93 375.47,22.93 RA14.1 ; v2(126.67,110.66) 126.54,110.66 126.47,110.59 126.4,110.59 125.98,110.17 CV842.1 125.82,109.84 124.18,109.84 123.47,110.56 DV4.3 123.11,111.1 121.97,112.24 121.97,114.84 121.8,115 120.29,115 118.83,116.47 118.83,117.16 118.76,117.23 118.76,117.41 118.2,117.97 JEDP1.11
  IN1 w0.102: v2(162.36,59.57) 162.26,59.67 162.1,59.67 161.56,60.21 161.56,60.6 161.93,60.97 161.93,65.5 162.11,65.68 162.11,66.8 162.5,67.19 162.5,70.51 161.39,71.62 161.39,76.43 160.7,77.12 160.7,78 160.17,78.54 159.11,78.54 157.91,79.74 157.91,81.14 v2(158.37,81.6)
  IN2 w0.081: v2(131,114.84) 130.56,114.4 130.56,113.91 129.23,112.58 129.23,110.97 128.19,109.94 127.41,109.94 126.69,110.66 v2(126.67,110.66)
  IN3 w0.081: v2(373.37,21.26) 373.16,21.26 369.58,17.69 364.51,17.69 364.12,17.3 356.11,17.3 355.87,17.06 351.42,17.06 350.54,17.93 346.81,17.93 345.4,16.52 344.04,16.52 343.86,16.35 341.98,16.35 341.56,15.93 334.58,15.93 333.29,17.22 330.06,17.22 327.19,20.09 322.17,20.09 314.89,12.81 309.74,12.81 309.1,12.16 302.79,12.16 302.37,11.74 300.53,11.74 299.9,11.11 278.96,11.11 277.92,12.16 271.46,12.16 267.04,16.58 264.16,16.58 263.66,17.07 262.22,17.07 260.33,18.96 256.58,18.96 256.1,18.48 248.24,18.48 247.19,19.53 243.21,19.53 241.88,18.2 238.86,18.2 238.01,17.35 233.38,17.35 229.03,13 214.89,13 213.77,11.87 175.32,11.87 173.99,13.2 171.6,13.2 168.06,16.73 168.06,22.26 166.83,23.5 166.83,25.97 167.61,26.75 167.61,35.54 164,39.15 164,45.14 165.86,46.99 165.86,48.46 166.49,49.09 166.49,49.9 166.66,50.08 166.66,56.23 166.1,56.79 166.1,57.41 165.77,57.73 164.07,57.73 163.59,57.26 162.89,57.26 161.45,58.69 161.45,59.18 161.94,59.67 162.26,59.67 v2(162.36,59.57)
  IN4 w0.102: v2(158.37,81.6) 158.37,82.26 158.14,82.49 158.14,85.77 152.66,91.25 149.13,91.25 141.69,98.69 140.68,98.69 140.23,99.14 138.57,99.14 138.4,99.3 138.4,99.31 138.25,99.46 138.25,101.78 137.21,102.82 133.33,102.82 130.53,105.63 130.53,107.99 132.06,109.52 132.06,113.81 131.04,114.84 v2(131,114.84)
DMIC_CLK_CODEC: length 2.9
  TOP w0.109: UA1.5 377.62,23.61 377.52,23.51 RA14.2 376.96,22.71 v1(377.1,22.57)
DP1_GPU_SEL#: length 176.1
  TOP w0.109: v2(162.3,73.19) 161.37,72.26 157.44,72.26 v1(157.17,72.53) v2(156.41,73.29)
  IN1 w0.102: v2(162.15,98.92) 161.34,98.92 159.73,97.31 159.73,95.66 158.06,93.99 158.06,91.88 157.27,91.09 157.27,84.62 159.52,82.37 160.34,82.37 162.3,80.41 v2(162.3,73.19)
  IN2 w0.081: v2(162.15,98.92) 161.67,99.41 156.7,99.41 154.72,97.43 153.49,97.43 153.13,97.07 150.98,97.07 150.24,96.33 149.31,96.33 147.95,97.69 143.01,97.69 141.56,99.14 138.57,99.14 137.37,97.94 120.97,97.94 116.55,93.52 116.55,90.4 115.02,88.87 115.02,88.6 114.64,88.22 110.6,88.22 106.22,83.83 106.22,81.42 103.99,79.19 102.48,76.31 96.62,70.24 96.62,67.6 96.21,67.19 94.49,67.19 90.59,63.29 87.32,63.29 83.3,59.27 80.18,59.27 79.04,58.14 79.04,55.78 78.62,55.36 77.39,55.36 77.29,55.46 75.23,55.46 74.41,56.29 66.66,56.29 66.26,56.69 64.19,56.69 63.77,57.11 61.11,57.11 59.76,55.77 59.76,53.1 59.43,52.77 59.43,51.65 v2(59.76,51.32)
  BOTTOM w0.109: v2(59.76,51.32) 59.41,51.32 59,50.92 UV66.9 ; UE12.16 156.47,73.23 v2(156.41,73.29)
DP1_SW1_REXT: length 6.7
  BOTTOM w0.109: UV66.31 54.8,43.82 53.41,42.43 53.41,41.94 52.23,40.76 v1(52.23,40.62) 52.23,39.8 52.4,39.64 RV861.2
DP1_SW2_CFG0: length 5.2
  TOP w0.109: v1(290.99,76.49) 291.07,76.49 291.72,77.14 292.43,77.14 292.89,76.68 RV125.2 293.72,77.44 293.72,78.09 294.17,78.54 UV8.59
DP1_SW2_PC10: length 6.1
  TOP w0.109: v1(290.42,78.07) 290.47,78.12 292.47,78.12 RV64.1 RV63.2 293.46,79.08 293.46,79.45 293.76,79.74 UV8.56
DP1_SW2_PC11: length 5.4
  TOP w0.109: v1(290.76,79.33) 290.76,79.48 291.21,79.92 292.42,79.92 292.89,79.45 RV62.1 293.01,79.46 RV61.2 293.49,80.39 293.73,80.14 UV8.55
DP1_SW2_PC20: length 5
  TOP w0.109: UV8.54 293.8,80.54 RV60.1 ; RV60.1 292.98,81.36 RV59.2 ; RV60.1 292.51,80.89 291.13,80.89 v1(291.09,80.85)
DP1_SW2_PC21: length 5.4
  TOP w0.109: UV8.53 293.93,80.94 293.68,81.2 293.68,82.48 292.98,83.17 RV58.1 292.98,83.19 RV57.2 292.98,84.66 v1(292.55,85.09)
DP1_SW2_PEQ: length 3.2
  TOP w0.203: v2(298.05,76.35) 298.17,76.47 UV8.8
  BOTTOM w0.109: v1(297.98,75.85) 297.98,76.28 v2(298.05,76.35) 298.4,76.7 RV56.1 RV55.2
DP1_SW2_PI0: length 4.9
  TOP w0.109: UV8.60 294.19,78.14 294.02,77.97 294.02,76.77 RV127.2 292.96,75.65 292.07,74.77 v1(291.87,74.77)
DP1_SW2_PI1: length 4.2
  TOP w0.109: UV8.1 295.37,76.78 295.04,76.45 RV66.1 294.13,75.49 RV65.2 293.91,75.49 v1(293.16,74.74)
DP1_SW2_SW: length 5.4
  TOP w0.109: UV8.18 302.17,76.81 302.31,76.66 302.7,76.66 303.38,75.99 303.93,75.99 RV126.2 304.38,75.49 304.86,75.01 304.86,73.73 v1(304.82,73.69)
DP2_GPU_SEL#: length 128.8
  TOP w0.109: v2(107.69,78.81) 108.29,78.81 108.81,79.33 113.23,79.33 113.8,79.9 115.96,79.9 116.53,79.33 119.11,79.33 119.73,79.95 119.73,80.65 120.19,81.11 122.28,81.11 122.9,81.73 v1(123.76,81.73) 124.29,81.73 v2(125.99,83.43) ; v2(75.04,47.14) 75.07,47.18 UV67.9
  IN1 w0.102: v2(75.04,47.14) 76.25,45.94 88.29,45.94 89.43,47.08 89.43,49.38 98.7,58.64 98.7,64.87 104.07,70.24 106.36,70.24 106.65,70.54 106.65,78.37 107.08,78.81 v2(107.69,78.81)
  BOTTOM w0.109: v2(125.99,83.43) 125.7,83.13 125.7,81 126.26,80.43 126.26,79.67 125.42,78.83 125.42,76.57 127.1,74.89 127.61,74.89 128.42,75.71 131.07,75.71 131.37,75.41 132.35,75.41 132.74,75.02 133.69,75.02 134.02,74.69 136.66,74.69 136.85,74.5 136.85,73.04 137.84,72.05 139.77,72.05 139.98,71.83 139.98,71.58 140.3,71.26 141.32,71.26 141.64,71.58 141.64,71.83 141.86,72.05 143.35,72.05 144.22,71.18 144.22,69.36 145.68,67.9 149.04,67.9 149.44,68.3 149.44,69.77 152.06,72.39 153.55,72.39 153.98,72.82 155.45,72.82 155.5,72.77 155.82,72.77 156,72.95 156,73.52 156.62,74.13 UE12.18
DP2_SW1_REXT: length 4
  TOP w0.109: RV870.2 84.96,52.09 v1(83.39,52.09) 83.12,52.09 82.72,51.69 UV67.31
DPSRC_HPD: length 5
  TOP w0.109: v1(38.87,54.74) 38.87,53.24 38.43,52.8 RT184.1 38.4,52.74 38.4,50.44 v2(38.39,50.42)
  BOTTOM w0.109: v2(38.39,50.42) 38.39,50.46 38.68,50.76 UT1.R5
DRON: length 91.7
  TOP w0.109: PU1800.16 286.92,63.76 v2(286.6,63.44) v1(286.21,63.05)
  TOP w0.203: PU1100.17 299.34,43.75 v2(299.06,44.02)
  TOP w0.254: PU1700.16 288.85,12.63 v2(288.99,12.49)
  IN1 w0.254: v2(290.33,43) 292.85,43 294.43,41.42 298.52,41.42 299.11,42 299.11,43.97 v2(299.06,44.02)
  IN3 w0.254: v2(286.6,63.44) 287.13,62.9 287.13,59.98 289.32,57.78 289.32,55.51 288.44,54.62 286.33,54.62 286.01,54.31 286.01,52.78 286.52,52.28 v2(289.13,52.28) 289.48,51.93 289.79,51.93 290.73,50.99 290.73,50.59 289.19,49.05 289.19,45.99 290.33,44.85 v2(290.33,43) 290.33,42.62 289.57,41.86 287.92,41.86 287.74,41.68 287.74,38.94 290.12,36.57 290.12,34.51 290.52,34.1 v2(290.52,33.73) 290.52,32.5 288.8,30.77 288.8,25.69 289.41,25.08 289.41,23.42 v2(290.33,22.49)
  IN4 w0.254: v2(288.99,12.49) 288.99,12.49 288.99,13.59 289.43,14.04 289.43,16.37 288.59,17.21 288.59,21.07 288.81,21.29 290.01,21.29 290.33,21.6 v2(290.33,22.49)
  BOTTOM w0.254: PR1221.1 PR1220.1 289.82,34.75 290.52,34.05 v2(290.52,33.73) ; v2(290.33,22.49) 290.04,22.79 290.04,23.48 289.82,23.7 PR1222.1 PR1223.1 ; PR1219.1 PR1218.1 290.13,44.48 290.33,44.27 v2(290.33,43) ; PR1217.1 288.95,52.45 v2(289.13,52.28) 289.3,52.45 PR1216.1
EC_FPM_EN: length 2
  TOP w0.109: RZ1483.2 337.39,57.05 JUSH1.22
EDP_AUXN: length 147.4
  TOP w0.102: v2(164.68,119.3) 164.79,119.19 164.92,119.19 165.03,119.31 165.03,119.67 164.82,119.88 163.72,119.88 CV838.1 ; v2(249.45,66.98) 249.77,67.3 UC1.B26
  IN1 w0.102: v2(249.45,66.98) 249.75,67.29 249.75,67.5 249,68.25 249,69.16 246.76,71.39 241.43,71.39 229.65,83.17 223.99,83.17 221.81,85.35 219.85,85.35 212.83,92.38 182.33,92.38 174.36,100.34 170.67,100.34 167.88,103.14 163.15,103.14 161.91,104.38 159.74,104.38 158.98,103.61 158.45,103.61 157.49,104.57 157.49,104.64 156.25,105.87 152.52,105.87 151.61,106.79 151,106.79 149.67,108.11 149.67,109.2 148.96,109.91 148.96,113.21 152.53,116.79 160.23,116.79 160.78,116.25 163.38,116.25 165.01,117.87 165.01,118.97 v2(164.68,119.3)
EDP_AUXN_C: length 3.1
  TOP w0.102: CV838.2 162.46,119.86 v3(161.22,119.86) 160.52,119.86 160.41,119.75 UV64.27
EDP_AUXP: length 147.4
  TOP w0.102: v2(250.23,66.98) 250.16,66.98 UC1.C26 ; v2(165.51,119.29) 165.22,119.58 165.22,119.75 164.89,120.07 163.72,120.07 CV837.1
  IN1 w0.102: v2(250.23,66.98) 249.94,67.27 249.94,67.57 249.18,68.33 249.18,69.23 246.84,71.58 241.51,71.58 229.73,83.36 224.07,83.36 221.89,85.54 219.93,85.54 212.91,92.56 182.4,92.56 174.43,100.53 170.75,100.53 167.96,103.32 163.23,103.32 161.99,104.57 159.67,104.57 158.9,103.8 158.53,103.8 157.68,104.65 157.68,104.71 156.33,106.06 152.6,106.06 151.69,106.97 151.08,106.97 149.86,108.19 149.86,109.27 149.14,109.99 149.14,113.14 152.61,116.6 160.16,116.6 160.7,116.06 163.46,116.06 165.2,117.79 165.2,118.97 v2(165.51,119.29)
EDP_AUXP_C: length 3.1
  TOP w0.102: CV837.2 162.41,120.05 161.55,120.05 161.52,120.09 160.93,120.09 160.89,120.05 160.49,120.05 160.38,120.15 UV64.28
EDP_COMP: length 11.6
  TOP w0.109: v2(257.55,66.14) 257.12,66.14 UC1.D37
  BOTTOM w0.109: v2(257.55,66.14) 257.95,66.54 v1(263.83,66.54) 265.46,68.17 RC1.1
EDP_IN1_AEQ#: length 3.9
  TOP w0.109: UV64.59 150.11,117.75 149.49,117.13 v1(149.49,116.16) 148.93,115.6 RV824.1
EDP_IN1_PEQ: length 3.4
  TOP w0.109: RV833.1 RV826.1 148.83,121.19 149.46,120.55 v1(149.59,120.55) UV64.52
EDP_IN2_AEQ#: length 3.5
  TOP w0.109: RV825.1 148.82,116.36 149.04,116.58 149.04,117.21 v1(149.43,117.6) 149.99,118.15 UV64.58
EDP_IN2_PEQ: length 3.6
  TOP w0.109: UV64.51 150.41,120.95 v1(149.46,121.9) 149.41,121.95 RV827.1 RV834.1
EDP_SW1_PC0: length 6.5
  TOP w0.109: RV830.1 155.58,126.65 v1(155.9,126.34) 156.23,126 156.23,124.89 RV822.1 156.8,123.92 156.55,123.67 156.55,123.35 156.71,123.19 156.71,122.59 156.42,122.3 UV64.38
EDP_SW1_PC1: length 5.7
  TOP w0.109: v1(146.45,120.17) 146.61,120.02 147.14,120.02 147.22,119.94 148.03,119.94 148.51,119.46 RV823.1 ; RV831.1 RV823.1 ; RV823.1 148.62,119.52 149.4,119.52 149.57,119.35 UV64.55
EDP_SW1_PI0: length 3.6
  TOP w0.109: RV828.1 RV829.1 148.7,117.88 v1(149.68,118.87) 149.77,118.95 UV64.56
EDP_TXN0: length 127.4
  TOP w0.102: v2(150.48,112.27) 150.09,112.66 150.09,112.78 CV830.1 ; v2(251.81,65.03) 252.13,65.35 UC1.E29
  IN1 w0.076: 251.17,68.09 251.18,68.08 251.18,68.05 251.45,67.78 251.74,67.78 252.34,67.18 252.34,66.63 252.17,66.46 252.17,65.51 v2(251.81,65.03)
  IN1 w0.102: v2(150.48,112.27) 150.18,111.97 150.18,111.72 150.34,111.55 151.45,111.55 152.74,110.26 152.74,107.94 153.39,107.3 170.36,107.3 183.91,93.75 213.9,93.75 220.93,86.73 222.74,86.73 223.8,85.67 224.92,85.67 225.92,84.67 230.1,84.67 241.93,72.84 247.61,72.84 250.98,69.47 250.98,68.28 251.17,68.09
EDP_TXN0_C: length 4.2
  TOP w0.102: UV64.2 152.02,116.15 151.91,116.04 151.91,115.78 v3(151.56,115.43) 151.16,115.03 150.7,115.03 150.28,114.6 150.22,114.6 150.06,114.44 150.06,114.05 CV830.2
EDP_TXN1: length 125.7
  TOP w0.102: UC1.E28 251.36,65.35 v2(251.02,65.02) ; CV832.1 151.12,110.33 151.12,110.07 v2(151.48,109.7)
  IN1 w0.076: 250.46,67.52 250.48,67.5 250.5,67.5 251.38,66.63 251.38,66.23 251.16,66.01 251.16,65.49 251.09,65.42 250.75,65.42 250.62,65.29 250.62,65.08 250.68,65.02 v2(251.02,65.02)
  IN1 w0.102: v2(151.48,109.7) 151.26,109.48 151.11,109.48 151.02,109.57 151.02,109.84 151.32,110.14 151.71,110.14 151.96,109.89 151.96,107.58 153.02,106.52 165.86,106.52 168.16,104.22 171.82,104.22 182.01,94.03 183.07,92.97 213.37,92.97 220.4,85.95 222.26,85.95 224.38,83.82 229.84,83.82 241.61,72.05 247.13,72.05 250.25,68.92 250.25,67.73 250.46,67.52
EDP_TXN1_C: length 6.6
  TOP w0.102: UV64.5 153.22,116.27 153.11,116.17 153.11,115.52 v3(152.85,115.26) 152.09,114.49 151.8,114.49 151.56,114.25 151.56,113.9 151.6,113.86 151.6,113.26 151.56,113.22 151.56,112.5 151.15,112.09 151.15,111.61 CV832.2
EDP_TXN2: length 124.7
  TOP w0.076: 251.85,68.39 251.84,68.37 251.84,68.35 251.7,68.21 251.7,67.8 UC1.B29
  TOP w0.102: v2(251.42,69.05) 251.42,69.31 251.52,69.41 251.72,69.41 251.96,69.17 251.96,68.5 251.85,68.39 ; CV834.1 152.88,112.6 152.88,112.42 152.7,112.24 152.7,111.77 v2(152.96,111.51)
  IN1 w0.102: v2(152.96,111.51) 152.75,111.3 152.75,111.11 153.34,110.53 153.34,108.42 153.85,107.91 170.68,107.91 184.25,94.35 214.16,94.35 221.18,87.32 223.1,87.32 224.05,86.37 225.18,86.37 226.17,85.38 230.23,85.38 242.17,73.45 249.34,73.45 252.04,70.74 252.04,69.47 251.79,69.23 251.6,69.23 v2(251.42,69.05)
EDP_TXN2_C: length 3.9
  TOP w0.102: CV834.2 152.88,113.94 152.88,114.37 153.17,114.66 153.52,114.66 153.91,115.05 153.91,116.09 154.02,116.2 UV64.7
EDP_TXN3: length 126.2
  TOP w0.076: UC1.B28 251.41,66.99 251.34,66.92 251.22,66.92 251.07,67.07 251.07,67.37 251.14,67.44 251.14,68.09 250.81,68.42 250.81,69.23 250.83,69.25 250.83,69.27
  TOP w0.102: CV836.1 154.23,110.39 154.23,109.93 v2(154.57,109.58) ; 250.83,69.27 250.83,70.39 251.25,70.81 v3(252.17,70.81) 252.53,70.81 252.61,70.74 v2(252.61,70.48)
  IN1 w0.102: v2(252.61,70.48) 252.79,70.66 253,70.66 253.21,70.87 253.21,71.95 251.07,74.08 242.37,74.08 228.84,87.62 228.84,90.09 227.72,91.21 226.82,91.21 226.43,91.59 222.33,91.59 218.98,94.94 184.76,94.94 171.18,108.52 154.69,108.52 154.28,108.92 154.28,109.3 v2(154.57,109.58)
EDP_TXN3_C: length 6.1
  TOP w0.102: UV64.10 155.22,116.2 155.1,116.09 155.1,115.38 154.23,114.5 v3(154.23,114.15) 154.23,113.86 154.4,113.68 154.4,113.15 154.44,113.11 154.44,112.41 154.18,112.15 154.18,111.63 CV836.2
EDP_TXP0: length 127.3
  TOP w0.102: UC1.D29 251.87,65.68 v2(251.81,65.68) ; v2(149.57,112.26) 149.9,112.58 149.9,112.74 CV829.1
  IN1 w0.076: v2(251.81,65.68) 251.58,65.68 251.49,65.77 251.49,65.89 251.64,66.04 251.94,66.04 252.02,66.11 252.02,66.52 252.19,66.69 252.19,67.12 251.68,67.63 251.39,67.63 251.07,67.94 251.05,67.94 251.03,67.96
  IN1 w0.102: v2(149.57,112.26) 149.99,111.83 149.99,111.64 150.26,111.37 151.37,111.37 152.56,110.18 152.56,107.86 153.31,107.11 170.29,107.11 183.83,93.57 213.82,93.57 220.85,86.54 222.66,86.54 223.72,85.49 224.84,85.49 225.84,84.49 230.02,84.49 241.86,72.65 247.53,72.65 250.79,69.39 250.79,68.2 251.03,67.96
EDP_TXP0_C: length 4.3
  TOP w0.102: CV829.2 149.87,114.04 149.87,114.52 v3(150.32,114.97) 150.57,115.22 151.08,115.22 151.19,115.33 151.19,115.38 151.6,115.8 151.65,115.8 151.72,115.87 151.72,116.06 151.62,116.16 UV64.1
EDP_TXP1: length 125.8
  TOP w0.102: CV831.1 150.93,110.36 150.93,110.09 v2(150.54,109.7) ; v2(251.05,64.38) 251.37,64.7 UC1.F28
  IN1 w0.076: v2(251.05,64.38) 251.39,64.71 251.39,65.24 251.31,65.32 251.31,65.95 251.53,66.17 251.53,66.69 250.61,67.61 250.61,67.64 250.6,67.65
  IN1 w0.102: v2(150.54,109.7) 150.73,109.7 150.84,109.8 150.84,109.92 151.24,110.32 151.79,110.32 152.15,109.97 152.15,107.65 153.1,106.71 165.94,106.71 168.23,104.41 171.9,104.41 183.15,93.16 213.45,93.16 220.48,86.14 222.33,86.14 224.46,84.01 229.92,84.01 241.69,72.24 247.21,72.24 250.44,69 250.44,67.81 250.6,67.65
EDP_TXP1_C: length 6.6
  TOP w0.102: UV64.4 152.82,116.24 152.92,116.13 152.92,115.65 152.42,115.15 152.42,115.1 152.01,114.68 151.72,114.68 151.37,114.33 v3(151.37,113.57) 151.37,112.58 150.96,112.17 150.96,111.65 CV831.2
EDP_TXP2: length 124.7
  TOP w0.076: UC1.A29 252.2,67.72 252.14,67.66 252.05,67.66 251.85,67.87 251.85,68.15 251.96,68.25 251.99,68.25
  TOP w0.102: v2(251.42,69.76) 251.58,69.6 251.8,69.6 252.15,69.25 252.15,68.42 251.99,68.25 ; v2(152.25,111.51) 152.51,111.77 152.51,112.32 152.69,112.5 152.69,112.63 CV833.1
  IN1 w0.102: v2(251.42,69.76) 251.42,69.48 251.48,69.42 251.72,69.42 251.85,69.55 251.85,70.67 249.26,73.26 242.09,73.26 230.15,85.2 226.09,85.2 225.11,86.18 223.97,86.18 223.02,87.14 221.11,87.14 214.08,94.16 184.17,94.16 170.6,107.72 153.77,107.72 153.15,108.34 153.15,110.45 152.57,111.04 152.57,111.2 v2(152.25,111.51)
EDP_TXP2_C: length 3.9
  TOP w0.102: CV833.2 152.69,113.92 152.69,114.45 153.09,114.85 153.44,114.85 153.72,115.13 153.72,116.06 153.62,116.16 UV64.6
EDP_TXP3: length 126.1
  TOP w0.076: UC1.C28 251.3,66.77 251.16,66.77 250.92,67 250.92,67.44 250.99,67.51 250.99,68.02 250.66,68.36 250.66,69.23 250.64,69.25 250.64,69.27
  TOP w0.102: v2(153.85,109.58) 154.04,109.76 154.04,110.3 CV835.1 ; 250.64,69.27 250.64,70.47 251.17,71 251.86,71 251.9,71.04 252.46,71.04 v2(252.61,71.2)
  IN1 w0.102: v2(252.61,71.2) 252.61,70.9 252.67,70.85 252.92,70.85 253.02,70.95 253.02,71.87 250.99,73.89 242.29,73.89 228.65,87.54 228.65,90.01 227.64,91.02 226.74,91.02 226.36,91.4 222.25,91.4 218.9,94.75 184.68,94.75 171.1,108.33 154.61,108.33 154.09,108.85 154.09,109.34 v2(153.85,109.58)
EDP_TXP3_C: length 6.1
  TOP w0.102: UV64.9 154.82,116.21 154.91,116.12 154.91,115.46 154,114.54 154,113.82 154.21,113.6 v3(154.21,112.82) 154.21,112.45 153.99,112.23 153.99,111.63 CV835.2
EN_1.8V: length 6.9
  TOP w0.109: v1(100.71,23.57) 100.49,23.57 99.96,23.04 99.96,22.21 PC902.1
  TOP w0.254: PC902.1 100.46,21.71 PR902.1 PR901.1 102.05,19.95 101.78,19.68 PU900.7
EN_2.5V: length 3.6
  TOP w0.109: PR401.1 159.84,94.92 160.49,95.57 v1(160.49,96.36)
  TOP w0.254: PU400.7 158.61,93.4 158.88,93.67 158.88,94.41
EN_3V_5V: length 189.8
  TOP w0.109: v2(133.33,113.21) 133.61,112.93 PU100.12
  IN1 w0.102: v2(108.48,86.83) 108.48,85.01 109.15,84.34 109.15,82.18 109.89,81.45 109.89,77.49 108.38,75.97 108.38,69.67 105.38,66.67 105.38,63.38 106.94,61.82 106.94,58.44 105.94,57.44 100.65,57.44 96.25,53.04 96.25,46.2 96.85,45.61 96.85,37.76 98.1,36.51 99.09,36.51 99.79,35.81 102.09,35.81 103.88,34.02 103.88,32.04 103.34,31.5 103.34,30.59 102.79,30.04 100.6,30.04 98.26,27.7 98.26,24.13 95.02,20.89 95.02,19.17 93.88,18.04 93.19,18.04 91.72,16.58 89.87,16.58 89.36,16.07 89.02,16.07 83.47,10.52 80.76,10.52 78.14,7.9 70.06,7.9 69.87,7.71 63.17,7.71 61.81,9.06 58.11,9.06 55.22,6.17 v2(55.22,5.23)
  IN2 w0.081: v2(122.69,106.07) 122.69,105.89 123.04,105.54 123.78,105.54 124,105.76 124,107.43 124.51,107.94 130.82,107.94 132.27,109.39 132.27,112.14 v2(133.33,113.21)
  IN3 w0.081: v2(108.48,86.83) 108.48,86.21 110.23,84.46 111.88,84.46 117.82,90.39 117.82,95.37 119.71,97.26 119.71,103.79 122,106.07 v2(122.69,106.07)
  BOTTOM w0.102: PC129.1 53.71,4.52 PR115.1 PR113.2 55.32,5.13 v2(55.22,5.23)
  BOTTOM w0.109: v1(134.44,113.39) 134.26,113.21 v2(133.33,113.21) ; PU101.12 53.47,4.76 PC129.1
EN_3VR_5VR: length 66.3
  TOP w0.109: PU500.12 354.55,40.28 353.29,39.02 PC515.1 352.99,39.02 352.98,39 PR507.1 PR505.2 351.01,39 v2(350.95,39.07) ; PU501.12 322.27,3.96 v2(322.27,3.95)
  BOTTOM w0.109: v2(322.27,3.95) 323.76,5.44 323.76,8.51 325.54,10.29 336.89,10.29 342.84,16.25 350.57,16.25 354.07,19.75 354.07,36.22 v1(353.73,36.55) 351.22,39.07 v2(350.95,39.07)
EN_+1VSP: length 2.3
  TOP w0.254: PC807.1 PR803.2 107.24,27.63 107.17,27.7 PU800.3
EN_INVPWR: length 82.2
  TOP w0.109: v2(144.47,138) 144.01,138.46 v1(143.57,138.46) 142.07,138.46 141.36,139.17 139.86,139.17 138.25,137.56 137.85,137.56 137.77,137.63 QV2.2 ; UE1.B2 v2(133.27,78.82) ; RE55.1 130.73,83.21 130.81,83.21 v2(131.03,82.99)
  IN1 w0.102: v2(144.47,138) 144.47,137.05 143.3,135.88 143.3,134.85 144.1,134.05 144.1,122.56 144.93,121.73 144.93,120.57 142.11,117.75 142.11,111.48 142.56,111.02 142.56,106.01 143.72,104.86 143.72,99.04 138.05,93.37 138.05,91.74 134.24,87.94 134.24,81.5 134.63,81.11 134.63,80.63 133.27,79.27 v2(133.27,78.82)
  BOTTOM w0.109: v2(133.27,78.82) 133.27,80.37 132.92,80.72 132.92,82.01 131.93,82.99 v2(131.03,82.99)
EN_IO: length 2
  TOP w0.109: 309.79,61.5 309.79,61.59 310.21,62.02 v1(310.21,63.36)
EN_SWR: length 15.7
  IN2 w0.081: v2(16.88,20.36) 16.88,19.64 18.14,18.38 18.14,13.8 19.39,12.55 20.58,12.55 21.09,12.04 v2(21.09,11.88)
  BOTTOM w0.109: v2(16.88,20.36) 16.9,20.34 UR1.41 ; v2(21.09,11.88) 21.1,11.87 21.26,11.87 22.44,10.68 RR232.1 22.6,10.17 RR231.2
ENABLE_DS#: length 4.3
  TOP w0.109: UE1.L2 133.61,71.25 133.2,70.85 132.48,70.85 132.03,70.4 131.53,70.4 131.18,70.75 RE550.1 RE549.2
ENLDO_3V5V: length 191.8
  TOP w0.109: PR109.1 PR108.1 133.27,113.69 v2(133.42,113.84) 133.87,113.38 PU100.11
  IN1 w0.102: v2(54.43,5.35) 54.43,6.1 57.67,9.35 61.91,9.35 63.28,7.98 69.81,7.98 69.96,8.13 78.01,8.13 80.65,10.77 83.4,10.77 88.92,16.3 89.27,16.3 89.78,16.8 91.63,16.8 93.14,18.32 93.84,18.32 94.79,19.27 94.79,20.98 98.04,24.23 98.04,27.8 100.5,30.27 102.69,30.27 103.11,30.68 103.11,31.6 103.65,32.14 103.65,33.93 102,35.58 99.7,35.58 99,36.28 97.97,36.28 96.62,37.63 96.62,45.51 96.36,45.77 95.08,45.77 94.08,46.77 94.08,51.19 100.56,57.67 105.85,57.67 106.72,58.54 106.72,61.73 105.15,63.29 105.15,66.76 108.15,69.76 108.15,76.1 109.66,77.61 109.66,81.35 108.93,82.09 108.93,84.24 107.87,85.29 v2(107.87,86.68)
  IN2 w0.081: v2(133.42,113.84) 132.96,113.84 132.04,112.92 132.04,109.48 130.93,108.38 124.28,108.38 123.62,107.71 123.62,106.13 123.49,106.01 v2(123.27,106.01)
  IN3 w0.081: v2(107.87,86.68) 107.87,86.49 110.13,84.23 111.98,84.23 118.05,90.3 118.05,95.27 119.94,97.16 119.94,103.57 121.92,105.55 122.82,105.55 v2(123.27,106.01)
  BOTTOM w0.102: PU101.11 53.92,5.45 54.02,5.35 v2(54.43,5.35)
  BOTTOM w0.109: v2(133.42,113.84) 133.42,114.13 v1(134,114.71)
ENLDO_3VR5VR: length 69.6
  TOP w0.109: PU501.11 321.82,4.26 321.66,4.1 PR512.1 PR510.1 v2(320.9,3.93) ; PU500.11 354.1,40.18 353.76,39.84 v2(353.21,39.84)
  BOTTOM w0.109: v2(320.9,3.93) 320.9,3.7 321.51,3.09 323.37,3.09 324.52,4.24 324.52,8.5 325.54,9.51 336.78,9.51 342.8,15.53 351.25,15.53 354.95,19.23 v1(354.95,37.19) 354.95,38.1 v2(353.21,39.84)
ENVDD_PCH: length 141.9
  TOP w0.109: v2(126.48,27.69) 126.86,27.69 UH1.AV44 ; v2(121.49,146) 121.42,146.06 v1(120.46,146.06) 117.55,146.06 116.82,146.8 DV42.2
  IN1 w0.102: v2(126.48,27.69) 126.48,27.96 126,28.44 123.48,28.44 120.51,31.41 120.51,35.34 121.5,36.34 121.5,36.7 120.92,37.29 120.92,38.26 120.51,38.67 120.51,50.66 119.78,51.39 119.78,53.61 120.37,54.19 120.37,54.71 119.83,55.24 119.83,55.96 119.34,56.45 119.34,57.73 118.36,58.71 118.36,62.73 117.49,63.61 117.49,66.42 117.84,66.77 117.84,68.47 118.73,69.35 118.73,70.78 118.34,71.17 118.34,72.03 116.75,73.62 116.75,75.45 116.89,75.59 116.89,78.28 117.88,79.27 117.88,81.83 118.23,82.18 118.23,83.88 116.8,85.31 116.8,95.08 115.92,95.96 114.76,95.96 113.89,96.83 113.89,98.07 111.62,100.34 111.62,106.02 112.42,106.82 113.48,106.82 113.95,107.29 113.95,114.68 116.05,116.78 116.05,118.35 116.85,119.15 116.85,141.37 v2(121.49,146)
ESPI_ALERT#: length 76.1
  TOP w0.109: UH1.AW35 126.52,32.08 v2(126.08,32.08) ; UE1.H7 v2(137.27,73.28)
  IN1 w0.102: v2(118.62,75.17) 118.92,74.87 118.92,73.28 119.48,72.71 119.48,71.64 119.87,71.26 119.87,68.66 120.27,68.26 120.27,66.38 120.45,66.19 120.45,62.58 120.55,62.48 120.55,58.46 121.36,57.65 121.36,55.69 121.74,55.31 121.74,52.57 122,52.31 122,47.58 122.27,47.31 122.27,46.13 123.06,45.34 123.06,43.09 123.44,42.71 123.44,41.46 123.74,41.16 123.74,38.2 123.7,38.17 123.7,33.39 124.28,32.81 125.35,32.81 v2(126.08,32.08)
  IN4 w0.102: v2(137.27,73.28) 136.86,73.68 136.86,74.26 136.43,74.69 132.83,74.69 132.39,75.12 130.22,75.12 129.2,76.15 128.61,76.15 128.16,76.6 126.63,76.6 126.18,76.15 121.66,76.15 120.69,75.17 v2(118.62,75.17)
  BOTTOM w0.109: RH340.1 120.94,31.87 121.32,31.49 122.35,31.49 122.53,31.66 124.76,31.66 124.86,31.56 125.55,31.56 126.06,32.08 v2(126.08,32.08) ; v2(118.62,75.17) v1(119.05,74.74)
ESPI_CLK: length 2.2
  TOP w0.109: v2(124.58,31.26) 124.73,31.11 UH1.BB36
  BOTTOM w0.109: v1(125.05,31.13) 124.93,31.26 v2(124.58,31.26) 124.15,30.83 RH97.1
ESPI_CLK_5105: length 130.9
  TOP w0.109: v2(142.97,68.29) 143.57,67.69 RE350.1 ; UE1.G7 v2(137.27,74.08)
  IN1 w0.102: v2(137.27,74.08) 137.93,73.41 137.93,70.93 139.14,69.72 139.14,69.04 140.27,67.91 141.13,67.91 141.82,68.59 142.67,68.59 v2(142.97,68.29) ; v2(117.94,76.94) 117.94,75.77 118.19,75.52 118.19,74.54 118.03,74.38 118.03,73.9 118.46,73.46 118.46,73.09 119.03,72.52 119.03,71.45 119.41,71.07 119.41,68.47 119.81,68.07 119.81,66.16 119.34,65.68 119.34,64.46 119.77,64.03 119.77,62.3 119.87,62.2 119.87,58.17 120.67,57.37 120.67,55.4 121.05,55.02 121.05,52.37 121.43,51.99 121.43,47.34 121.7,47.07 121.7,45.89 122.49,45.11 122.49,42.85 122.87,42.47 122.87,41.16 123.17,40.87 123.17,38.44 123.13,38.4 123.13,36.48 122.09,35.44 122.09,32.2 v2(123.02,31.27)
  IN2 w0.081: v2(123.02,31.27) 121.35,31.27 120.27,30.19 119.56,30.19 118.87,29.5 118.87,28.94 118.59,28.67 117.96,28.67 117.55,28.26 117.55,27.74 117.13,27.32 115.19,27.32 114.09,26.23 112.34,26.23 112.09,25.98 111.05,25.98 109.98,27.05 105.59,27.05 105.19,26.66 104.52,26.66 104.25,26.39 100.54,26.39 100.31,26.17 100.08,26.17 94.73,20.82 94.73,19.45 92.8,17.52 v2(91.4,17.52)
  IN4 w0.102: v2(137.27,74.08) 137.27,74.3 136.65,74.92 132.92,74.92 132.49,75.35 130.37,75.35 129.34,76.37 128.71,76.37 128.26,76.82 126.53,76.82 126.08,76.37 120.84,76.37 120.69,76.22 119.72,76.22 119.07,75.58 118.31,75.58 117.94,75.95 v2(117.94,76.94)
  BOTTOM w0.109: v2(91.4,17.52) 91.99,16.93 94.96,16.93 95.01,16.89 95.48,16.89 95.74,16.62 95.74,15.88 95.83,15.8 JESPI.10 ; v2(123.02,31.27) 123.24,31.05 RH97.2 ; v2(117.94,76.94) v1(117.22,76.94)
ESPI_CS#: length 113
  TOP w0.076: UH1.BE38 124.04,30.29 124.48,30.29 124.55,30.32 124.62,30.39 125.28,30.39 v2(125.54,30.65)
  TOP w0.109: UE1.H6 v2(136.47,73.28)
  IN1 w0.102: v2(118.44,74.06) 118.69,73.81 118.69,73.18 119.26,72.62 119.26,71.55 119.64,71.16 119.64,68.56 120.04,68.17 120.04,66.28 120.23,66.09 120.23,62.49 120.32,62.39 120.32,58.36 121.13,57.56 121.13,55.59 121.51,55.21 121.51,52.53 121.81,52.23 121.81,47.5 122.08,47.23 122.08,46.05 122.87,45.26 122.87,43.01 123.25,42.63 123.25,41.32 123.55,41.02 123.55,38.28 123.51,38.24 123.51,34.8 123.38,34.67 123.38,33.43 125.54,31.27 v2(125.54,30.65)
  IN2 w0.081: v2(96.74,16.23) 95.22,17.74 95.22,20.66 96.48,21.92 97.39,21.92 97.66,22.19 97.66,23.1 100.27,25.71 100.5,25.71 100.73,25.94 103.06,25.94 104.12,24.88 105.73,24.88 106.82,25.97 107.57,25.97 107.64,25.9 109.83,25.9 110.87,24.86 111.72,24.86 112.05,25.18 113.2,25.18 113.38,25 114.48,25 115.47,25.99 116.54,25.99 118.01,27.46 118.01,28.03 118.26,28.29 118.95,28.29 119.25,28.59 119.25,29.33 119.47,29.54 120.36,29.54 120.73,29.91 123.01,29.91 123.31,30.22 123.42,30.22 123.72,30.52 124.86,30.52 125,30.65 v2(125.54,30.65)
  IN4 w0.102: v2(136.47,73.28) 136.05,73.7 133.17,73.7 132.85,74.02 131.7,74.02 131.24,74.48 130.98,74.48 129.97,73.47 128.5,73.47 127.59,74.38 121.26,74.38 121.19,74.31 118.68,74.31 v2(118.44,74.06)
  BOTTOM w0.109: JESPI.7 97.33,15.64 v2(96.74,16.23) ; v2(118.44,74.06) v1(117.83,74.06)
ESPI_IO0: length 113
  TOP w0.109: UE1.K5 v2(135.67,71.68)
  IN2 w0.081: v2(118.62,27.12) 117.62,26.11 116.96,26.11 116.62,25.78 115.59,25.78 114.56,24.75 113.3,24.75 113.1,24.95 112.14,24.95 111.82,24.63 110.77,24.63 109.73,25.67 107.55,25.67 107.47,25.75 106.91,25.75 105.82,24.65 104.02,24.65 102.97,25.71 100.82,25.71 100.59,25.48 100.36,25.48 97.89,23.01 97.89,22.09 97.49,21.69 96.58,21.69 95.45,20.57 95.45,18.33 v2(97.07,16.71)
  IN4 w0.102: v2(135.67,71.68) 135.25,71.26 133.15,71.26 132.83,71.58 132.83,72.05 132.77,72.12 128.41,72.12 127.29,73.24 126.54,73.24 125.51,72.22 120.28,72.22 v2(119.89,71.82)
  BOTTOM w0.109: v2(119.89,71.82) 119.85,71.78 119.85,68.66 119.92,68.58 119.92,66.07 122.57,63.42 122.57,61.97 123.01,61.53 123.01,58.32 120.88,56.19 120.88,51.4 120.27,50.79 v1(118.35,50.79) 117.99,50.43 116.63,50.43 113.55,47.35 113.55,41.7 114.32,40.92 114.32,39.19 114.01,38.88 113.29,38.88 112.82,38.4 112.82,37.51 114.28,36.05 114.28,32.64 115.01,31.91 115.01,28.48 115.34,28.15 115.48,28.15 115.48,28.14 115.82,28.14 115.83,28.15 116.47,28.15 116.6,28.02 117.53,28.02 118.04,27.51 119.33,27.51 RC366.2 119.37,27.12 v2(118.62,27.12) ; v2(97.07,16.71) 97.35,16.71 98.13,15.93 98.97,15.93 99.33,15.56 JESPI.3
ESPI_IO0_R: length 6.7
  TOP w0.109: v2(125.22,29.43) 125.22,29.44 125.22,29.67 UH1.BB39
  BOTTOM w0.109: RC366.1 121.02,27.29 121.13,27.4 121.65,27.4 122.48,28.23 122.48,28.95 123.13,29.61 125.05,29.61 v2(125.22,29.43)
ESPI_IO1: length 136.9
  TOP w0.109: UE1.L4 v2(134.87,70.88) ; v2(120.55,69.42) 119.17,70.8 v1(119.12,70.8) 117.38,70.8 117,71.17 112.73,71.17 112.12,70.56 110.13,70.56 v2(109.93,70.77)
  IN1 w0.102: v2(109.93,70.77) 109.93,69.27 107.85,67.19 107.85,63.96 108.32,63.49 108.32,55.36 106.73,53.77 101.46,53.77 99.36,51.68 99.36,42.09 101.58,39.88 107.65,39.88 110.28,37.24 v2(110.28,35.7)
  IN2 w0.081: v2(110.28,35.7) 109.28,34.69 109.28,34.03 108.54,33.29 104.8,33.29 v2(102.46,30.95)
  IN3 w0.081: v2(134.87,70.88) 134.61,70.88 132.66,68.93 132.15,68.93 131.36,69.72 127.93,69.72 127.41,69.21 126.27,69.21 125.74,69.74 123.15,69.74 122.54,69.13 120.84,69.13 v2(120.55,69.42)
  IN4 w0.102: v2(102.46,30.95) 100.42,28.91 100.42,25.73 100,25.31 98.73,25.31 95.94,22.52 94.75,22.52 94.54,22.73 93.83,22.73 93.39,22.3 93.39,21.78 93.78,21.4 93.78,16.54 93.34,16.11 v2(93.34,15.79)
  BOTTOM w0.109: JESPI.4 98.83,14.39 98.1,13.66 95.38,13.66 93.34,15.7 v2(93.34,15.79) ; RC367.2 119.21,26.17 118.7,26.17 118.51,26.36 118.51,26.71 117.44,27.78 116.82,27.78 116.34,27.3 114.72,27.3 114.46,27.56 114.46,28.15 114.77,28.46 114.77,31.81 114.05,32.54 114.05,34.76 113.52,35.28 112.64,35.28 112.22,35.7 v2(110.28,35.7)
ESPI_IO1_R: length 9.7
  TOP w0.109: v2(126.34,31.05) 126.39,31.05 UH1.AW37
  BOTTOM w0.109: v2(126.34,31.05) 126.34,30.95 125.94,30.55 125.94,30.42 125.63,30.11 125.63,29.25 125.42,29.05 124.99,29.05 124.69,29.35 123.16,29.35 122.68,28.87 122.68,27.97 v1(122.23,27.52) 121.92,27.21 121.46,27.21 120.76,26.51 RC367.1
ESPI_IO2: length 128.7
  TOP w0.109: UE1.G6 v2(136.47,74.08)
  IN1 w0.102: v2(115.2,72.31) 114.87,72.65 113.79,72.65 113.54,72.4 113.54,70.8 112.93,70.18 112.93,69.5 113.56,68.86 113.56,68.58 114.09,68.06 114.09,66.16 112.98,65.04 112.98,63.54 114.31,62.21 114.31,60.75 113.61,60.05 113.61,52.44 114.76,51.29 114.76,48.72 117.31,46.17 117.31,38 117.93,37.39 117.93,29.61 v2(118.31,29.22)
  IN2 w0.081: v2(118.31,29.22) 118.18,29.35 115.13,29.35 113.87,28.08 113.87,26.94 113.61,26.68 112.15,26.68 111.9,26.44 111.24,26.44 109.77,27.9 100.64,27.9 100.4,27.66 99.57,27.66 99.38,27.48 99.38,26.76 99.06,26.44 95.82,23.21 92.15,23.21 89.1,20.15 v2(89.1,18.94)
  IN4 w0.102: v2(115.2,72.31) 115.2,73.4 116.58,74.78 117.91,74.78 118.15,74.54 121.1,74.54 121.17,74.61 127.68,74.61 128.59,73.7 129.87,73.7 130.9,74.73 131.35,74.73 131.85,74.23 132.64,74.23 132.87,74.46 136.08,74.46 v2(136.47,74.08)
  BOTTOM w0.109: v2(115.2,72.31) 115.5,72.62 115.5,73.79 v1(115.77,74.06) ; v2(89.1,18.94) 89.1,17.75 90.39,16.46 94.26,16.46 94.92,15.8 94.92,14.46 95.48,13.9 97.92,13.9 98.33,14.31 JESPI.5 ; RC368.2 119.29,30.05 118.46,29.22 v2(118.31,29.22)
ESPI_IO2_R: length 8.8
  TOP w0.109: v2(126.87,31.33) 127.1,31.33 UH1.AV37
  BOTTOM w0.109: RC368.1 120.28,31.17 122.45,31.17 122.68,30.94 122.68,30.47 122.92,30.22 124.58,30.22 125.94,31.59 v1(126.26,31.59) 126.62,31.59 v2(126.87,31.33)
ESPI_IO3: length 114.2
  TOP w0.109: UE1.L5 v2(135.67,70.88)
  IN1 w0.102: v2(127.89,30.7) 127.71,30.88 127.71,31.47 126.94,32.24 126.78,32.24 126.01,33.01 124.47,33.01 123.89,33.59 123.89,38.09 123.93,38.12 123.93,41.24 123.63,41.54 123.63,42.79 123.25,43.17 123.25,45.42 122.46,46.21 122.46,47.43 122.9,47.86 122.9,51.68 121.97,52.61 121.97,55.4 121.59,55.78 121.59,59.28 120.88,59.99 120.88,62.48 120.68,62.68 120.68,66.28 120.5,66.47 120.5,68.69 v2(120.3,68.89)
  IN2 w0.081: v2(95.07,16.23) 94.99,16.31 94.99,20.76 100.17,25.94 100.4,25.94 100.63,26.16 104.38,26.16 104.65,26.43 105.29,26.43 105.68,26.82 109.88,26.82 110.96,25.75 112.18,25.75 112.43,26 114.38,26 115.32,26.94 117.17,26.94 117.78,27.55 117.78,28.11 118.15,28.48 118.67,28.48 119.06,28.86 119.06,29.42 119.52,29.89 120.37,29.89 120.65,30.16 122.73,30.16 123.34,30.77 124.81,30.77 125.65,31.61 126.06,31.61 126.16,31.71 126.31,31.71 126.54,31.94 127.28,31.94 127.58,31.64 127.58,31.05 127.89,30.75 v2(127.89,30.7)
  IN4 w0.102: v2(135.67,70.88) 136.09,70.45 136.09,69.74 135.96,69.6 135.96,68.33 135.38,67.76 132.13,67.76 130.85,69.04 129.68,69.04 128.63,67.99 127.95,67.99 127.48,67.52 124.01,67.52 122.64,68.89 v2(120.3,68.89)
  BOTTOM w0.109: v2(127.89,30.7) 127.48,30.29 RC369.2 ; JESPI.6 97.83,14.55 97.42,14.14 95.65,14.14 95.16,14.63 95.16,16.14 v2(95.07,16.23)
ESPI_IO3_R: length 2.2
  TOP w0.109: v2(126.2,29.49) 126.07,29.61 UH1.BA38
  BOTTOM w0.109: v1(126.64,29.05) v2(126.2,29.49) 126.2,29.75 RC369.1
ESPI_RESET#: length 137.9
  TOP w0.089: 121.27,29.92 121.49,29.92 121.77,30.21 123.04,30.21 UH1.BF38
  TOP w0.109: 121.27,29.92 120.91,29.92 120.42,29.43 119.04,29.43 118.47,28.85 118.16,28.85 117.8,29.21 112.76,29.21 RH95.1 112.02,28.48 v2(111.58,28.48) 111.49,28.57 111.49,29.82 111.2,30.11 111.2,31.13 110.72,31.61 CH348.1 110.72,32.77 RH633.1 ; UE1.K6 v2(136.47,71.68)
  IN1 w0.102: v2(109.88,56.25) 109.88,51.57 111.51,49.94 111.51,42.12 111.33,41.94 111.33,39.54 111.69,39.18 111.69,31.65 112.03,31.3 112.03,30.77 112.28,30.52 112.28,29.17 v2(111.58,28.48)
  IN2 w0.081: v2(90.42,23.54) 90.62,23.74 93.95,23.74 95.04,24.83 96.48,24.83 97.96,26.31 97.96,27.27 98.9,28.21 100.3,28.21 100.47,28.38 111.48,28.38 v2(111.58,28.48)
  IN3 w0.081: v2(109.88,56.25) 111.18,56.25 112.93,58 112.93,59.63 115.13,61.83 115.13,62.19 116.23,63.29 116.23,63.97 117.71,65.45 118.71,65.45 120.13,66.87 120.13,67.42 121.13,68.42 122.55,68.42 123.17,67.8 127.26,67.8 127.99,67.07 128.27,67.07 130.19,68.99 130.72,68.99 130.97,68.74 130.97,68.46 131.49,67.95 132.63,67.95 134,69.31 134.93,69.31 135.29,69.67 135.9,69.67 136.09,69.86 136.09,71.3 v2(136.47,71.68)
  BOTTOM w0.109: JESPI.8 96.83,14.68 96.62,14.47 95.65,14.47 95.49,14.63 95.49,16.54 95.39,16.65 94.91,16.65 94.86,16.7 90.49,16.7 90.02,17.17 90.02,18.85 89.52,19.35 87.7,19.35 86.78,18.43 v1(86.59,18.43) 85.54,18.43 85.1,18.87 85.1,20.85 86.53,22.28 87.03,22.28 88.9,24.14 88.9,25.1 89.23,25.43 89.91,25.43 90.35,25 90.35,23.61 v2(90.42,23.54)
EXPANDER_ALERT#: length 2.6
  BOTTOM w0.109: RE563.1 158.57,70.45 v1(158.89,70.77) 159.33,71.21 UE12.11
FB_1.2V: length 4
  TOP w0.203: PC211.1 110.07,16.86 PR206.1 110.03,16 PR209.1 110.2,15.02 111.21,14 PU200.6
FB_1.8V: length 3.9
  TOP w0.254: PC904.2 98.65,21.73 PR904.2 PR905.1 97.86,20.8 v1(97.91,20.75) 98.47,20.19 98.98,20.19 PU900.1
FB_2.5V: length 2.4
  TOP w0.109: v1(157.6,97.06) 157.6,96.83 157.34,96.56 157.34,95.57 156.85,95.09 PC402.2
FB_2PH: length 7.8
  TOP w0.109: v1(304.65,32.4) 304.16,32.89 PR1137.1
  TOP w0.203: PU1100.34 303.55,38.09 304.21,37.42 PR1136.1 304.21,36.01 PC1117.1 304.29,34.36 PC1116.2 304.22,33.41 PR1137.1
FB_3VR: length 4
  TOP w0.109: v1(321.64,1.34) 322.13,1.83 322.13,2.7 PC526.1
  TOP w0.254: PU501.13 322.72,4.28 322.87,4.13 322.87,3.44 PC526.1
FB_4PH: length 7.4
  TOP w0.109: PC1115.2 305.06,50.32 v1(305.22,50.47)
  TOP w0.203: PU1100.5 303.95,46.64 304.54,47.23 305.69,47.23 305.93,47.47 PR1131.1 305.93,48.62 PR1130.1 PC1113.2 305.08,49.52 PC1115.2
FB_5V: length 1.7
  BOTTOM w0.254: PC128.1 52.79,4.9 53.02,5.13 PU101.13
FB_5VR: length 1.9
  TOP w0.254: PC514.1 354.14,39.33 355,40.18 PU500.13
FB_+1VSP: length 2.7
  TOP w0.254: PR807.1 PR808.1 108.2,27.02 107.67,27.55 PU800.4
FFS_INT2: length 277
  TOP w0.109: v2(115.78,40.86) 115.96,40.86 116.27,41.17 117.16,41.17 RH378.2 117.72,41.73 118.5,41.73 118.62,41.61 120.32,41.61 120.38,41.67 120.38,42.09 120.7,42.41 121.26,42.41 121.65,42.79 122.54,42.79 122.83,42.5 123.13,42.5 123.22,42.59 123.75,42.59 UH1.BE14
  IN3 w0.081: v2(115.78,40.86) 114.9,39.99 114.9,37.62 114.29,37.01 114.29,30.44 112.71,28.86 112.71,26.78 112.96,26.53 113.61,26.53 114.52,25.62 114.52,25.12 113.9,24.5 113.9,17.73 115.97,15.66 115.97,15.1 118.46,12.61 118.46,11.29 120.47,9.29 123.77,9.29 124.45,8.61 124.45,4.68 127.67,1.45 156.6,1.45 157.84,2.69 165.94,2.69 166.97,1.65 243.59,1.65 248.01,6.08 252.76,6.08 255.37,3.46 264.53,3.46 265.76,4.69 265.76,5.43 266.23,5.9 266.75,5.9 268.38,4.28 273.89,4.28 276.87,1.29 301.7,1.29 303.09,2.68 307.78,2.68 v2(308.94,3.84)
  BOTTOM w0.203: v2(308.94,3.84) 307.22,3.84 306.23,4.82 306.23,7.48 302.69,11.03 302.69,17.92 303.62,18.85 306.83,18.85 v1(307.36,19.38) 307.6,19.62 307.6,21 307.33,21.27 QN1.2 306.42,21.27 306.13,21.57 LGA1.11
FFS_INT2_Q: length 98.2
  IN3 w0.081: v2(309.74,3.25) 309.74,3.11 310.62,2.23 318.98,2.23 319.68,1.52 332.99,1.52 333.7,2.23 339.03,2.23 343.23,6.43 356.6,6.43 360.45,10.28 361.22,10.28 361.7,10.76 362.58,10.76 363.49,11.67 364.96,11.67 365.87,10.76 374,10.76 JNGFF4.32
  BOTTOM w0.109: v2(309.74,3.25) 307.4,3.25 305.95,4.7 305.95,7.36 302.38,10.94 302.38,18.16 v1(302.54,18.32) 303.36,19.14 305.67,19.14 RN1.2 306.89,20.36 QN1.3
FIVR_EN: length 6.5
  BOTTOM w0.109: RC219.2 256.6,13.52 v1(257.4,12.71) 257.92,12.71 258.16,12.47 RC218.2 258.33,12 259.19,11.14 259.97,11.14 260.16,11.33 260.16,12.6 RC217.1
FIVR_EN_R: length 23.6
  TOP w0.109: v2(260.58,11.58) 261.08,12.08 RC132.2 ; v2(243.13,14.88) v1(243.13,15.43)
  IN2 w0.081: v2(243.13,14.88) 243.38,15.13 255.72,15.13 256.73,14.12 258.7,14.12 260.58,12.24 v2(260.58,11.58)
  BOTTOM w0.109: RC126.2 RC217.2 261.16,12.16 v2(260.58,11.58) ; v2(243.13,14.88) 243.08,14.92 JXDP1.45
FRS_ON1_R: length 4.4
  TOP w0.109: UT9.3 39.22,22.79 39.59,22.42 v2(40.06,22.42)
  BOTTOM w0.109: v2(40.06,22.42) 40.17,22.53 40.17,23.07 39.42,23.83 RT570.2 39.3,24.09 38.76,24.64 v1(38.76,24.85)
FRS_ON2_R: length 3.4
  TOP w0.109: v1(45.9,22.07) 45.82,22 45.21,22 44.89,22.32 v2(44.8,22.32) 44.52,22.6 UT11.3
  BOTTOM w0.109: RT574.2 44.16,22.96 v2(44.8,22.32)
FRS_ON_P1: length 43.7
  TOP w0.109: v2(36.69,23.65) 36.69,23.78 36.27,24.2 v1(35.72,24.2)
  IN2 w0.081: v2(36.69,23.65) 36.24,24.09 34.29,24.09 33.83,23.64 30.81,23.64 30.35,24.09 26.23,24.09 25.78,23.64 22.25,23.64 21.43,22.82 20.63,22.82 20.29,23.16 20.06,23.16 18.75,24.47 18.75,26.63 19.48,27.36 19.48,28.6 18.73,29.36 18.73,30.3 17.88,31.15 17.88,34.74 20.5,37.35 v2(21.54,37.35)
  BOTTOM w0.109: RT570.1 38.21,23.65 v2(36.69,23.65) ; RT617.1 21.42,39.9 21.42,38.05 21.54,37.94 v2(21.54,37.35) 21.54,36.92 20.54,35.92 UT5.L7
FRS_ON_P2: length 55.1
  IN2 w0.081: v2(22.81,37.99) 22.76,37.99 21.61,36.84 21.25,36.84 20.59,36.18 19.68,36.18 18.11,34.61 18.11,31.38 18.96,30.53 18.96,29.45 19.71,28.7 19.71,27.27 19.13,26.69 19.13,24.46 20.2,23.39 20.82,23.39 21.54,24.11 22.87,24.11 23.87,25.11 25.98,25.11 26.69,24.4 30.53,24.4 30.94,23.98 33.57,23.98 35.31,25.72 40.47,25.72 40.81,26.06 41.31,26.06 v2(41.83,26.58)
  BOTTOM w0.109: UT5.L8 21.18,35.82 21.18,35.96 22.33,37.11 22.33,37.37 22.81,37.85 v2(22.81,37.99) 22.83,38.01 22.83,39.47 22.74,39.56 RT618.1 ; v2(41.83,26.58) 42.16,26.26 43.15,26.26 43.38,26.02 43.38,24.04 43.56,23.87 44.78,23.87 45.07,23.57 RT574.1 45.51,22.89 45.95,22.89 46.27,23.21 v1(46.27,23.4)
GC6_THM_ON: length 3.7
  BOTTOM w0.109: UE12.7 161.9,72.78 162,72.68 162.53,72.68 162.83,72.98 RH6.2 163.31,73 163.65,73.34 164.33,73.34 v1(164.64,73.03)
GPIO0: length 4.6
  BOTTOM w0.109: UR1.42 17.3,19.75 17.46,19.91 17.46,20.75 17.25,20.96 17.25,21.25 17.03,21.46 RR201.2 17.03,23.32 v1(16.93,23.42)
GPIO_0: length 4.3
  BOTTOM w0.109: UT1.W1 40.63,53.12 42.24,54.73 42.44,54.73 43.13,55.41 RT505.1
GPIO_1: length 8.7
  BOTTOM w0.076: UT1.W2 40.87,52.35 40.87,52.75
  BOTTOM w0.109: v1(44,59.21) RT506.1 43.59,57.55 43.59,55.4 43.48,55.29 43.29,55.29 42.52,54.53 42.32,54.53 40.87,53.08 40.87,52.75
GPIO_3: length 4.6
  BOTTOM w0.109: UT1.Y1 41.09,53.02 42.4,54.33 42.6,54.33 43.28,55.01 43.51,55.01 44.14,55.64 RT507.1
GPP_B23: length 11.2
  TOP w0.089: 122.95,32.55 123.13,32.73 123.13,32.76 123.27,32.9 124.22,32.9 UH1.BD33
  TOP w0.102: 122.95,32.55 122.86,32.46 122.86,32.46 122.65,32.24 122.52,32.12 122.15,32.12 121.77,31.74 120.83,31.74 120.58,31.48 120.58,31.01 120.29,30.72 118.26,30.72 117.95,30.41 116.48,30.41 116.14,30.08 v1(115.84,30.08) 115.5,30.08 RH329.1
GPP_C5: length 4.4
  TOP w0.102: RH78.2 119.91,36.69 120.44,37.23 120.65,37.23 120.83,37.4 v1(120.88,37.4) 121.24,37.04 121.81,37.04 121.95,37.18 123.52,37.18 UH1.BF24
GPP_D12: length 12.2
  TOP w0.109: UH1.AN18 v2(129.82,40.54)
  BOTTOM w0.109: v2(129.82,40.54) 129.3,40.02 v1(127.24,40.02) 125.17,40.88 125,40.88 124.68,41.19 124.16,41.19 123.68,40.71 122.71,40.71 122.39,40.39 122.39,39.88 122.17,39.66 121.4,39.66 120.61,40.45 RH349.1
GPP_F22: length 4.6
  TOP w0.109: UH1.AT49 128.85,24.18 128.85,23.02 128.32,22.49 RC444.1 128.32,22.11 129.06,21.38 v1(129.27,21.38)
GPP_H12: length 4.2
  TOP w0.089: 136.5,24.95 136.29,25.15 135.99,25.15 135.8,25.34 135.8,25.65 UH1.AB47
  TOP w0.109: 136.5,24.95 136.57,24.87 136.57,23.66 137.23,23 RH615.2
GPP_H15: length 4.1
  TOP w0.109: RH601.2 135.66,23.57 135.66,24.78 135.66,24.78 135.66,24.91 134.98,25.59 134.98,25.67 134.98,25.67 134.98,25.78 134.9,25.85 UH1.AC47
GPP_J1: length 5
  TOP w0.102: UH1.AY3 126.71,47.7 126.71,48.02 126.53,48.2 126.53,49.95 126.35,50.13
  TOP w0.109: RH616.2 125.05,51.62 125.04,51.6 125.04,51.44 126.35,50.13
GPPJ_RCOMP: length 9
  TOP w0.109: v1(118.18,53.04) 119.23,52 RH609.2
  TOP w0.254: UH1.BD1 UH1.BE1 ; UH1.BE1 123.75,48.58 122.64,49.7 120.74,49.7 119.48,50.95 119.48,51.45 RH609.2 ; UH1.BE1 123.75,48.37 UH1.BE2
GPS_DISABLE#: length 71.2
  TOP w0.109: UE1.H5 v2(135.67,73.28) ; RE12.1 128.34,73.8 v2(128.71,74.16)
  IN1 w0.102: v2(143.58,118) 142.34,116.75 142.34,111.57 143.54,110.37 143.54,106.66 144.19,106.01 144.19,101.7 144.66,101.23 145.15,101.23 145.39,101 145.39,100.66 144.45,99.72 144.45,98.8 142.36,96.72 142.36,92.01 136.85,86.49 136.85,86.01 134.93,84.09 134.93,83.09 135.18,82.84 135.27,82.84 135.51,82.6 135.51,78.48 135.29,78.26 135.29,75.34 136.04,74.59 136.04,73.65 v2(135.67,73.28)
  BOTTOM w0.109: v2(135.67,73.28) 135.67,73.54 135.28,73.93 135.28,74.35 135.14,74.49 133.94,74.49 133.66,74.77 132.72,74.77 132.31,75.18 131.27,75.18 130.98,75.47 128.52,75.47 128.03,74.98 128.03,74.58 128.44,74.16 v2(128.71,74.16) ; DZ6.1 148.85,118.44 v1(148.32,118.98) 148.17,119.13 143.84,119.13 143.58,118.87 v2(143.58,118)
GPU_DP1_AUXN: length 210.1
  TOP w0.109: v2(230.67,89.93) 230.8,89.8 231.37,89.8 JDGFF1.F5
  IN3 w0.089: v2(230.67,89.93) 230.8,89.8 231.21,89.8 231.47,89.55 231.47,88.92 231.05,88.5 230.59,88.5 229.55,88.93 229.19,89.28 227.96,90.51 227.96,91.26 227.27,91.95 224.46,91.95 223.94,92.47 184.36,92.47 179.09,97.74 166.18,97.74 165.75,97.3 159.29,97.3 153.46,91.47 142.11,91.47 140.38,89.74 130.82,89.74 130.2,89.13 129.6,89.13 128.93,88.47 127.99,88.47 126.77,87.24 122.55,87.24 118.41,83.11 116.89,83.11 113.33,79.56 111.91,79.56 100.98,68.62 100.98,67.48 94.26,60.76 94.26,60.13 88.65,54.52 83.7,54.52 82.76,53.58 80.6,53.58 79.92,52.9 69.96,52.9 67.23,50.17 64.6,50.17 64.26,50.51 64.26,51.97 64.62,52.32 64.62,52.89 64.09,53.42 61.75,53.42 58.69,56.48 57.09,56.48 56.08,57.49 56.08,57.93 v2(55.89,58.13)
  BOTTOM w0.109: v2(55.89,58.13) 56.14,57.88 56.14,57.59 55.89,57.34 55.89,57.14 CV946.1
GPU_DP1_AUXP: length 210.1
  TOP w0.109: v2(230.68,89.18) 230.68,89.42 230.8,89.54 231.27,89.54 JDGFF1.F4
  IN3 w0.089: v2(230.68,89.18) 230.68,89.38 230.9,89.6 231.13,89.6 231.26,89.47 231.26,89 230.96,88.7 230.64,88.7 229.66,89.1 229.34,89.43 228.17,90.6 228.17,91.35 227.36,92.15 224.55,92.15 224.03,92.67 184.44,92.67 179.18,97.94 166.1,97.94 165.66,97.5 159.2,97.5 153.37,91.67 142.02,91.67 140.3,89.95 130.73,89.95 130.12,89.33 129.51,89.33 128.85,88.67 127.91,88.67 126.68,87.45 122.46,87.45 118.33,83.31 116.8,83.31 113.25,79.76 111.82,79.76 100.77,68.71 100.77,67.57 94.05,60.85 94.05,60.21 88.57,54.73 83.61,54.73 82.67,53.79 80.52,53.79 79.83,53.1 69.88,53.1 67.14,50.37 64.68,50.37 64.46,50.59 64.46,51.88 64.82,52.24 64.82,52.97 64.17,53.62 61.83,53.62 58.77,56.68 57.17,56.68 56.29,57.57 56.29,58.14 56.4,58.24 56.59,58.24 v2(56.71,58.12)
  BOTTOM w0.109: v2(56.71,58.12) 56.4,57.81 56.4,57.48 56.15,57.23 56.15,57.13 CV945.1
GPU_DP1_C_AUXN: length 1.8
  BOTTOM w0.109: CV946.2 55.89,56.18 55.89,55.94 55.67,55.72 55.67,55.23 55.6,55.16 UV66.61
GPU_DP1_C_AUXP: length 1.8
  BOTTOM w0.109: CV945.2 56.15,56.18 56.15,55.84 55.93,55.61 55.93,55.29 56,55.22 UV66.62
GPU_DP1_HPD: length 290
  TOP w0.109: v2(59.19,48.12) 59.24,48.07 RV898.1
  VCC w0.086: v2(269.9,82.72) 269.31,82.72 268.15,81.56 264.17,81.56 263.47,80.86 255.6,80.86 253.05,78.31 241.46,78.31 239.64,80.14 235.42,80.14 231.95,83.61 223.4,83.61 216.53,90.48 195.87,90.48 195.23,89.84 185.24,89.84 184.97,90.11 183.79,90.11 181.03,92.87 177.54,92.87 177.09,93.31 169.39,93.31 168.85,93.85 167.6,93.85 166.17,92.42 166.17,90.02 161.99,85.83 161.99,79.83 160.86,78.7 160.86,76.88 161.52,76.22 161.52,73.09 160.86,72.43 160.86,70.3 160.41,69.86 160.41,67.38 159.87,66.83 v2(157.37,66.83)
  IN3 w0.081: v2(288.16,79.82) 287.53,80.46 280.51,80.46 279.77,81.2 271.37,81.2 269.9,82.66 v2(269.9,82.72) ; v2(157.37,66.83) 155.61,66.83 155.2,66.42 153.07,66.42 152.65,66 151.74,66 149.44,63.7 149.44,63.06 147.96,61.58 145.39,61.58 140.04,56.23 133.59,56.23 133.53,56.3 125.37,56.3 124.69,55.62 122.71,55.62 120.8,53.71 120.8,51.42 116.31,46.93 116.31,46.31 115.96,45.96 115.75,45.96 115.05,45.27 114.62,45.27 v2(114.45,45.1)
  IN4 w0.102: v2(59.19,48.12) 61.03,49.96 63.88,49.96 64.17,50.26 67.98,50.26 68.84,51.12 81.12,51.12 81.5,51.5 82.47,51.5 82.95,51.98 84.71,51.98 85.6,52.87 91.24,52.87 94.11,55.74 95.41,55.74 95.56,55.89 105.76,55.89 107.9,53.76 109.73,53.76 113.26,50.23 113.26,45.93 114.09,45.1 v2(114.45,45.1)
  BOTTOM w0.109: v2(59.19,48.12) 59.19,48.12 UV66.16 ; UV62.2 289.29,78.47 289.41,78.58 289.41,79.34 289.25,79.49 288.49,79.49 v2(288.16,79.82) 288.14,79.85 288.14,80.5 DV32.2 ; v2(269.9,82.72) v1(269.9,83.33)
GPU_DP1_HPD_GATE: length 84.4
  TOP w0.109: v2(289.48,85.67) v1(289.48,84.53) 289.48,81.5 290.19,80.79 v2(290.19,79.9) ; JDGFF1.C9 235.51,92.32 235.08,91.89 234.29,91.89 233.8,92.37 233.8,92.67 234.21,93.08 234.21,93.18 234.57,93.54 v2(234.57,93.61)
  IN3 w0.081: v2(289.48,85.67) 289.66,85.85 289.66,88.2 286.28,91.58 283.84,91.58 282.62,92.8 277.87,92.8 276.57,91.49 276.57,86.95 275.35,85.73 271.23,85.73 270.67,85.17 268.77,85.17 268.14,84.54 252.93,84.54 252.66,84.8 245.56,84.8 243.92,86.44 243.92,87.91 243.04,88.79 243.04,91.92 241.5,93.46 237.49,93.46 237.31,93.64 237.31,94.3 237.13,94.48 237.08,94.48 236.99,94.58 234.97,94.58 234.57,94.17 v2(234.57,93.61)
  BOTTOM w0.109: v2(290.19,79.9) 290.29,79.8 UV62.4
GPU_DP1_N0: length 197.2
  TOP w0.109: v2(230.76,91.82) 231.01,91.57 231.34,91.57 JDGFF1.F8
  IN3 w0.089: v2(230.76,91.82) 230.76,91.69 230.65,91.58 230.46,91.58 229.87,92.16 229.87,92.25 228,94.12 185.04,94.12 179.1,100.06 157.87,100.06 155.71,97.9 155.71,96.34 152.54,93.17 143.98,93.17 143.71,93.44 138.63,93.44 136.54,91.34 130.15,91.34 129.54,90.73 128.93,90.73 128.27,90.07 127.33,90.07 126.11,88.85 121.81,88.85 121.43,88.46 119.76,88.46 112.6,81.31 111.29,81.31 99.18,69.2 99.18,68.05 88.39,57.25 85.43,57.25 84.71,56.53 73.73,56.53 71.96,54.75 66.63,54.75 66.09,54.21 64.66,54.21 64.52,54.35 63.66,54.35 63.45,54.55 63.45,54.85 63.57,54.97 63.72,54.97 v2(63.89,54.9)
  BOTTOM w0.109: CV861.2 61.64,53.16 62.63,53.16 63.67,54.2 63.67,54.67 v2(63.89,54.9)
