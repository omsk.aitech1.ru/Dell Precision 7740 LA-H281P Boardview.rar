# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Nets (continued)
GND: C190.2 C191.2 C192.1 C193.1 C194.2 C195.2 C199.2 C200.2 C201.1 C202.1 C203.2 C206.2 C207.2 C209.2 CA1.1 CA4.1 CA10.2 CA12.2 CA13.2 CA19.2 CA22.2 CA23.2 CA24.2 CA31.1 CA33.2 CA41.2 CA45.2 CA46.2 CA47.2 CA48.2 CA53.1 CA54.2 CA55.2 CA56.2 CA59.2 CA60.2 CA61.2 CA63.2 CA64.2 CA65.2 CA66.2 CA67.2 CA68.2 CA69.2 CA73.2 CA74.2 CA76.2 CA226.2 CA227.2 CA228.2 CC28.2 CC29.2 CC32.2 CC33.2 CC81.2 CC82.2 CC83.2 CC84.2 CC161.2 CC163.2 CC164.2 CC165.2 CC166.2 CC167.2 CC168.2 CC170.2 CC171.2 CC172.2 CC185.2 CC186.1 CC187.2 CC188.2 CC189.2 CC191.1 CC192.1 CC193.1 CC194.1 CC195.1 CC209.1 CC210.1 CC269.2 CC272.2 CC300.2 CC301.2 CC302.2 CC303.2 CC304.2 CC305.2 CC306.2 CC307.2 CC308.2 CC310.2 CC311.2 CC318.2 CC319.2 CC320.2 CC322.2 CC323.2 CC324.2 CC325.2 CC327.2 CC328.2 CC329.2 CC330.2 CC331.2 CC332.2 CC333.2 CC334.2 CC335.1 CC336.2 CC337.2 CC338.2 CC568.2 CC569.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD21.2 CD22.2 CD23.2 CD24.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD31.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD49.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CD56.2 CD57.2 CD58.2 CD59.2 CD60.2 CD61.2 CD62.2 CD63.2 CD64.2 CD65.2 CD66.2 CD67.2 CD68.2 CD69.2 CD70.2 CD71.2 CD72.2 CD73.2 CD74.2 CD75.2 CD76.2 CD77.2 CD78.2 CD79.2 CD80.2 CD81.2 CD82.2 CD83.2 CD84.2 CD85.2 CD86.2 CD88.2 CD89.2 CD90.2 CD91.2 CD92.2 CD93.2 CD94.2 CD95.2 CD96.2 CD97.2 CD98.2 CD99.2 CD100.2 CD101.2 CD102.2 CD103.2 CD104.2 CD105.2 CD106.2 CD107.2 CD108.2 CD109.2 CD110.2 CD111.2 CD112.2 CD113.2 CD114.2 CD115.2 CD116.2 CD117.2 CD118.2 CD119.2 CD120.2 CD121.2 CD122.2 CD123.2 CD124.2 CD125.2 CD126.2 CD127.2 CD128.2 CE3.2 CE4.2 CE8.2 CE10.2 CE11.2 CE12.2 CE13.2 CE14.2 CE15.2 CE16.2 CE19.2 CE20.2 CE21.2 CE22.2 CE23.2 CE25.2 CE28.2 CE29.2 CE30.2 CE31.2 CE36.2 CE38.2 CE40.2 CE47.2 CE52.2 CE53.2 CE54.2 CE57.2 CE59.2 CE60.2 CE61.2 CE62.2 CE63.2 CE64.2 CE65.2 CE66.2 CE340.2 CE341.2 CE342.2 CE343.2 CH4.1 CH5.1 CH9.2 CH10.2 CH13.2 CH14.2 CH20.2 CH21.2 CH22.2 CH29.2 CH30.2 CH31.2 CH32.2 CH33.2 CH34.2 CH35.2 CH36.2 CH37.2 CH38.2 CH40.1 CH41.1 CH44.2 CH45.1 CH46.2 CH47.2 CH62.2 CH63.2 CH64.2 CH65.2 CH66.2 CH67.2 CH68.2 CH266.2 CH267.2 CH268.1 CH270.2 CH321.2 CH322.2 CH323.2 CH324.2 CH340.2 CH341.2 CH342.2 CH343.2 CH344.2 CH345.2 CH346.2 CH347.2 CH348.2 CH349.2 CH350.2 CH555.2 CH559.2 CH560.2 CI1.2 CI3.2 CI14.2 CI32.2 CI60.2 CI61.2 CI68.2 CI69.2 CI76.2 CI77.2 CL3.2 CL4.2 CL7.2 CL8.2 CL9.2 CL10.2 CL11.2 CL12.2 CL13.2 CL14.2 CL15.2 CL16.2 CL17.2 CL18.2 CL19.2 CL20.2 CL21.2 CL22.1 CL28.2 CL199.2 CL280.2 CLIP1.1(P1) CLIP2.1(P1) CMOS1.1 CN1.2 CN2.2 CN174.2 CN175.2 CN176.2 CN177.2 CN178.2 CN179.2 CN188.2 CN189.2 CN190.2 CN191.2 CN192.2 CN193.2 CN202.2 CN203.2 CN204.2 CN205.2 CN206.2 CN207.2 CN216.2 CN217.2 CN218.2 CN219.2 CN220.2 CN221.2 CN276.2 CN277.2 CN279.2 CN280.2 CN281.2 CN282.2 CN283.2 CN285.2 CN286.2 CN287.2 CN288.2 CN289.2 CN295.2 CN297.2 CN298.2 CN299.2 CN300.2 CN301.2 CN306.2 CN309.2 CN310.2 CN311.2 CN312.2 CN313.2 CR200.2 CR214.1 CR215.2 CR217.2 CR218.2 CR219.1 CR220.1 CR221.2 CR222.2 CR223.1 CR224.1 CR225.1 CR227.1 CR228.1 CR229.1 CR230.2 CR234.2 CR235.2 CR236.1 CR237.1 CR238.1 CR239.2 CR240.1 CR241.1 CR242.2 CR244.1 CR245.1 CR246.1 CR247.2 CR248.1 CR249.1 CR250.1 CR251.2 CR252.1 CR253.1 CR254.2 CR255.2 CR256.1 CT1.2 CT20.2 CT21.2 CT67.2 CT68.2 CT69.2 CT91.2 CT101.2 CT102.2 CT109.2 CT189.2 CT190.2 CT237.2 CT300.2 CT301.2 CT302.2 CT303.2 CT305.2 CT306.2 CT307.2 CT308.2 CT309.2 CT310.2 CT311.2 CT314.2 CT315.2 CT316.1 CT317.1 CT318.1 CT319.1 CT320.1 CT321.1 CT322.1 CT323.2 CT324.2 CT325.2 CT326.2 CT327.2 CT328.2 CT329.2 CT330.2 CT331.2 CT332.2 CT333.2 CT334.2 CT335.2 CT336.2 CT337.2 CT338.2 CT339.2 CT340.2 CT341.2 CT342.2 CT343.2 CT344.2 CT345.2 CT346.2 CT347.2 CT348.1 CT349.2 CT350.1 CT351.1 CT352.2 CT353.1 CT354.2 CT355.2 CT356.2 CT357.2 CT358.2 CT361.2 CT362.2 CT363.2 CT364.2 CT367.2 CT368.2 CT370.1 CT371.1 CT372.2 CT373.2 CT374.2 CT376.2 CT377.2 CT378.1 CT379.2 CT380.1 CT383.1 CT384.1 CT389.2 CV14.2 CV15.2 CV16.2 CV20.2 CV60.2 CV61.2 CV62.2 CV63.2 CV64.2 CV75.2 CV805.2 CV806.2 CV809.2 CV810.2 CV811.2 CV812.2 CV813.2 CV814.2 CV815.2 CV816.2 CV817.2 CV818.1 CV839.1 CV840.2 CV841.2 CV842.2 CV843.2 CV844.2 CV849.1 CV851.1 CV852.2 CV853.2 CV854.2 CV855.2 CV856.2 CV857.2 CV858.2 CV878.2 CV879.2 CV880.2 CV881.2 CV882.2 CV901.2 CV902.2 CV903.2 CV908.2 CV909.2 CV910.2 CV911.2 CV912.2 CV913.2 CV914.2 CV915.2 CV916.2 CV917.2 CV918.2 CV919.2 CV920.2 CV921.2 CV922.2 CV923.2 CV924.2 CV925.2 CV926.2 CV927.2 CV928.2 CV929.2 CV930.2 CV931.2 CV932.2 CV933.2 CV934.2 CV935.2 CV936.2 CV937.2 CV938.2 CV939.2 CV940.2 CV941.2 CV942.2 CV947.2 CV948.2 CV949.2 CV950.2 CV951.2 CV952.2 CV954.2 CV955.2 CV956.2 CV957.2 CZ17.2 CZ18.2 CZ19.2 CZ20.2 CZ21.2 CZ37.2 CZ38.2 CZ39.2 CZ40.2 CZ50.2 CZ51.2 CZ52.2 CZ53.2 CZ54.2 CZ55.2 CZ56.2 CZ57.2 CZ58.2 CZ59.2 CZ60.2 CZ61.2 CZ62.2 CZ63.2 CZ64.2 CZ66.2 CZ67.2 CZ68.2 CZ69.2 CZ71.2 CZ72.2 CZ73.2 CZ75.2 CZ80.2 CZ81.2 CZ82.2 CZ90.2 CZ91.2 CZ92.2 CZ93.2 CZ100.2 CZ101.2 CZ102.1 CZ105.2 CZ106.2 CZ120.2 CZ121.2 CZ129.2 CZ130.2 CZ157.2 CZ164.2 CZ198.2 CZ199.2 CZ200.2 CZ218.2 CZ505.2 CZ506.2 CZ507.2 CZ508.2 CZ509.2 CZ510.2 CZ511.2 CZ512.1 CZ513.2 CZ514.2 CZ515.1 CZ516.1 CZ517.1 CZ518.2 CZ519.2 CZ520.2 CZ521.1 CZ522.1 CZ523.1 CZ524.2 CZ525.2 CZ527.2 CZ528.2 CZ529.2 CZ530.2 CZ531.2 CZ532.2 CZ533.2 CZ534.2 CZ535.2 CZ540.2 CZ541.2 CZ542.2 CZ543.2 CZ544.2 CZ545.2 DA1.1 DA2.1 DA3.1 DA6.1 DA7.1 DI1.3 DI2.1 DI3.1 DI4.3 DI5.1 DI6.3 DT1.1(P) DT2.1(P) DT3.1(P) DT4.1(3) DT5.2 DT6.2 DT7.3 DT8.3 DT9.2 DT10.2 DT11.3 DT12.3 DT13.2 DT14.2 DT16.1(P) DT17.2 DT18.2 DT43.2 DT44.2 DT45.2 DT48.2 DT51.2 DT52.2 DT53.2 DT54.2 DT59.1(3) DT2001.2 DT2002.2 DT2003.2 DT2004.2 DT2005.2 DT2006.2 DT2007.2 DT2008.2 DV4.1 DV41.1 DZ20.2 DZ21.2 H1.1 H3.1 H4.1 H5.1 H6.1 H7.1 H8.1 H9.1 H11.1 H12.1 H13.1 H14.1 H15.1 H16.1 H17.1 H18.1 H19.1 H21.1 H22.1 JAPS1.8 JAPS1.10 JAPS1.12 JAPS1.14 JAPS1.19(GND1) JAPS1.20(GND2) JCCG1.10 JCCG1.11(GND1) JCCG1.12(GND2) JDEG1.10 JDEG1.11(GND1) JDEG1.12(GND2) JDG1.4 JDG1.5 JDG1.6(GND1) JDG1.7(GND2) JDG1.8(GND3) JDG1.9(GND4) JDGFF1.A3 JDGFF1.A6 JDGFF1.A9 JDGFF1.B1 JDGFF1.B4 JDGFF1.B7 JDGFF1.B10 JDGFF1.C3 JDGFF1.C6 JDGFF1.F1 JDGFF1.F3 JDGFF1.F6 JDGFF1.G1 JDGFF1.G4 JDGFF1.G7 JDGFF1.G10 JDGFF1.H3 JDGFF1.H6 JDGFF1.H9 JDGFF2.A3 JDGFF2.A6 JDGFF2.A9 JDGFF2.B1 JDGFF2.B4 JDGFF2.B7 JDGFF2.B10 JDGFF2.C3 JDGFF2.C6 JDGFF2.F3 JDGFF2.F6 JDGFF2.G1 JDGFF2.G4 JDGFF2.G7 JDGFF2.G10 JDGFF2.H3 JDGFF2.H6 JDGFF2.H9 JDGFF3.A3 JDGFF3.A6 JDGFF3.A9 JDGFF3.A10 JDGFF3.B1 JDGFF3.B4 JDGFF3.B7 JDGFF3.B10 JDGFF3.C1 JDGFF3.C2 JDGFF3.C3 JDGFF3.C6 JDGFF3.C9 JDGFF3.C10 JDGFF3.D1 JDGFF3.D2 JDGFF3.D9 JDGFF3.D10 JDGFF3.E1 JDGFF3.E2 JDGFF3.E9 JDGFF3.E10 JDGFF3.F1 JDGFF3.F2 JDGFF3.F3 JDGFF3.F6 JDGFF3.F9 JDGFF3.F10 JDGFF3.G1 JDGFF3.G4 JDGFF3.G7 JDGFF3.G10 JDGFF3.H3 JDGFF3.H6 JDGFF3.H9 JDGFF3.H10 JDGFF4.A3 JDGFF4.A6 JDGFF4.A9 JDGFF4.B1 JDGFF4.B4 JDGFF4.B7 JDGFF4.B10 JDGFF4.C3 JDGFF4.F3 JDGFF4.F6 JDGFF4.G1 JDGFF4.G4 JDGFF4.G7 JDGFF4.G10 JDGFF4.H3 JDGFF4.H6 JDGFF4.H9 JDIMM1.1(VSS1) JDIMM1.2(VSS2) JDIMM1.5(VSS3) JDIMM1.6(VSS4) JDIMM1.9(VSS5) JDIMM1.10(VSS6) JDIMM1.14(VSS7) JDIMM1.15(VSS8) JDIMM1.18(VSS9) JDIMM1.19(VSS10) JDIMM1.22(VSS11) JDIMM1.23(VSS12) JDIMM1.26(VSS13) JDIMM1.27(VSS14) JDIMM1.30(VSS15) JDIMM1.31(VSS16) JDIMM1.35(VSS17) JDIMM1.36(VSS18) JDIMM1.39(VSS19) JDIMM1.40(VSS20) JDIMM1.43(VSS21) JDIMM1.44(VSS22) JDIMM1.47(VSS23) JDIMM1.48(VSS24) JDIMM1.51(VSS25) JDIMM1.52(VSS26) JDIMM1.56(VSS27) JDIMM1.57(VSS28) JDIMM1.60(VSS29) JDIMM1.61(VSS30) JDIMM1.64(VSS31) JDIMM1.65(VSS32) JDIMM1.68(VSS33) JDIMM1.69(VSS34) JDIMM1.72(VSS35) JDIMM1.73(VSS36) JDIMM1.77(VSS37) JDIMM1.78(VSS38) JDIMM1.81(VSS39) JDIMM1.82(VSS40) JDIMM1.85(VSS41) JDIMM1.86(VSS42) JDIMM1.89(VSS43) JDIMM1.90(VSS44) JDIMM1.93(VSS45) JDIMM1.94(VSS46) JDIMM1.98(VSS47) JDIMM1.99(VSS48) JDIMM1.102(VSS49) JDIMM1.103(VSS50) JDIMM1.106(VSS51) JDIMM1.107(VSS52) JDIMM1.167(VSS53) JDIMM1.168(VSS54) JDIMM1.171(VSS55) JDIMM1.172(VSS56) JDIMM1.175(VSS57) JDIMM1.176(VSS58) JDIMM1.180(VSS59) JDIMM1.181(VSS60) JDIMM1.184(VSS61) JDIMM1.185(VSS62) JDIMM1.188(VSS63) JDIMM1.189(VSS64) JDIMM1.192(VSS65) JDIMM1.193(VSS66) JDIMM1.196(VSS67) JDIMM1.197(VSS68) JDIMM1.201(VSS69) JDIMM1.202(VSS70) JDIMM1.205(VSS71) JDIMM1.206(VSS72) JDIMM1.209(VSS73) JDIMM1.210(VSS74) JDIMM1.213(VSS75) JDIMM1.214(VSS76) JDIMM1.217(VSS77) JDIMM1.218(VSS78) JDIMM1.222(VSS79) JDIMM1.223(VSS80) JDIMM1.226(VSS81) JDIMM1.227(VSS82) JDIMM1.230(VSS83) JDIMM1.231(VSS84) JDIMM1.234(VSS85) JDIMM1.235(VSS86) JDIMM1.238(VSS87) JDIMM1.239(VSS88) JDIMM1.243(VSS89) JDIMM1.244(VSS90) JDIMM1.247(VSS91) JDIMM1.248(VSS92) JDIMM1.251(VSS93) JDIMM1.252(VSS94) JDIMM1.261(GND1) JDIMM1.262(GND2) JDIMM2.1(VSS1) JDIMM2.2(VSS2) JDIMM2.5(VSS3) JDIMM2.6(VSS4) JDIMM2.9(VSS5) JDIMM2.10(VSS6) JDIMM2.14(VSS7) JDIMM2.15(VSS8) JDIMM2.18(VSS9) JDIMM2.19(VSS10) JDIMM2.22(VSS11) JDIMM2.23(VSS12) JDIMM2.26(VSS13) JDIMM2.27(VSS14) JDIMM2.30(VSS15) JDIMM2.31(VSS16) JDIMM2.35(VSS17) JDIMM2.36(VSS18) JDIMM2.39(VSS19) JDIMM2.40(VSS20) JDIMM2.43(VSS21) JDIMM2.44(VSS22) JDIMM2.47(VSS23) JDIMM2.48(VSS24) JDIMM2.51(VSS25) JDIMM2.52(VSS26) JDIMM2.56(VSS27) JDIMM2.57(VSS28) JDIMM2.60(VSS29) JDIMM2.61(VSS30) JDIMM2.64(VSS31) JDIMM2.65(VSS32) JDIMM2.68(VSS33) JDIMM2.69(VSS34) JDIMM2.72(VSS35) JDIMM2.73(VSS36) JDIMM2.77(VSS37) JDIMM2.78(VSS38) JDIMM2.81(VSS39) JDIMM2.82(VSS40) JDIMM2.85(VSS41) JDIMM2.86(VSS42) JDIMM2.89(VSS43) JDIMM2.90(VSS44) JDIMM2.93(VSS45) JDIMM2.94(VSS46) JDIMM2.98(VSS47) JDIMM2.99(VSS48) JDIMM2.102(VSS49) JDIMM2.103(VSS50) JDIMM2.106(VSS51) JDIMM2.107(VSS52) JDIMM2.167(VSS53) JDIMM2.168(VSS54) JDIMM2.171(VSS55) JDIMM2.172(VSS56) JDIMM2.175(VSS57) JDIMM2.176(VSS58) JDIMM2.180(VSS59) JDIMM2.181(VSS60) JDIMM2.184(VSS61) JDIMM2.185(VSS62) JDIMM2.188(VSS63) JDIMM2.189(VSS64) JDIMM2.192(VSS65) JDIMM2.193(VSS66) JDIMM2.196(VSS67) JDIMM2.197(VSS68) JDIMM2.201(VSS69) JDIMM2.202(VSS70) JDIMM2.205(VSS71) JDIMM2.206(VSS72) JDIMM2.209(VSS73) JDIMM2.210(VSS74) JDIMM2.213(VSS75) JDIMM2.214(VSS76) JDIMM2.217(VSS77) JDIMM2.218(VSS78) JDIMM2.222(VSS79) JDIMM2.223(VSS80) JDIMM2.226(VSS81) JDIMM2.227(VSS82) JDIMM2.230(VSS83) JDIMM2.231(VSS84) JDIMM2.234(VSS85) JDIMM2.235(VSS86) JDIMM2.238(VSS87) JDIMM2.239(VSS88) JDIMM2.243(VSS89) JDIMM2.244(VSS90) JDIMM2.247(VSS91) JDIMM2.248(VSS92) JDIMM2.251(VSS93) JDIMM2.252(VSS94) JDIMM2.261(GND1) JDIMM2.262(GND2) JDIMM3.1(VSS1) JDIMM3.2(VSS2) JDIMM3.5(VSS3) JDIMM3.6(VSS4) JDIMM3.9(VSS5) JDIMM3.10(VSS6) JDIMM3.14(VSS7) JDIMM3.15(VSS8) JDIMM3.18(VSS9) JDIMM3.19(VSS10) JDIMM3.22(VSS11) JDIMM3.23(VSS12) JDIMM3.26(VSS13) JDIMM3.27(VSS14) JDIMM3.30(VSS15) JDIMM3.31(VSS16) JDIMM3.35(VSS17) JDIMM3.36(VSS18) JDIMM3.39(VSS19) JDIMM3.40(VSS20) JDIMM3.43(VSS21) JDIMM3.44(VSS22) JDIMM3.47(VSS23) JDIMM3.48(VSS24) JDIMM3.51(VSS25) JDIMM3.52(VSS26) JDIMM3.56(VSS27) JDIMM3.57(VSS28) JDIMM3.60(VSS29) JDIMM3.61(VSS30) JDIMM3.64(VSS31) JDIMM3.65(VSS32) JDIMM3.68(VSS33) JDIMM3.69(VSS34) JDIMM3.72(VSS35) JDIMM3.73(VSS36) JDIMM3.77(VSS37) JDIMM3.78(VSS38) JDIMM3.81(VSS39) JDIMM3.82(VSS40) JDIMM3.85(VSS41) JDIMM3.86(VSS42) JDIMM3.89(VSS43) JDIMM3.90(VSS44) JDIMM3.93(VSS45) JDIMM3.94(VSS46) JDIMM3.98(VSS47) JDIMM3.99(VSS48) JDIMM3.102(VSS49) JDIMM3.103(VSS50) JDIMM3.106(VSS51) JDIMM3.107(VSS52) JDIMM3.167(VSS53) JDIMM3.168(VSS54) JDIMM3.171(VSS55) JDIMM3.172(VSS56) JDIMM3.175(VSS57) JDIMM3.176(VSS58) JDIMM3.180(VSS59) JDIMM3.181(VSS60) JDIMM3.184(VSS61) JDIMM3.185(VSS62) JDIMM3.188(VSS63) JDIMM3.189(VSS64) JDIMM3.192(VSS65) JDIMM3.193(VSS66) JDIMM3.196(VSS67) JDIMM3.197(VSS68) JDIMM3.201(VSS69) JDIMM3.202(VSS70) JDIMM3.205(VSS71) JDIMM3.206(VSS72) JDIMM3.209(VSS73) JDIMM3.210(VSS74) JDIMM3.213(VSS75) JDIMM3.214(VSS76) JDIMM3.217(VSS77) JDIMM3.218(VSS78) JDIMM3.222(VSS79) JDIMM3.223(VSS80) JDIMM3.226(VSS81) JDIMM3.227(VSS82) JDIMM3.230(VSS83) JDIMM3.231(VSS84) JDIMM3.234(VSS85) JDIMM3.235(VSS86) JDIMM3.238(VSS87) JDIMM3.239(VSS88) JDIMM3.243(VSS89) JDIMM3.244(VSS90) JDIMM3.247(VSS91) JDIMM3.248(VSS92) JDIMM3.251(VSS93) JDIMM3.252(VSS94) JDIMM3.261(GND1) JDIMM3.262(GND2) JDIMM4.1(VSS1) JDIMM4.2(VSS2) JDIMM4.5(VSS3) JDIMM4.6(VSS4) JDIMM4.9(VSS5) JDIMM4.10(VSS6) JDIMM4.14(VSS7) JDIMM4.15(VSS8) JDIMM4.18(VSS9) JDIMM4.19(VSS10) JDIMM4.22(VSS11) JDIMM4.23(VSS12) JDIMM4.26(VSS13) JDIMM4.27(VSS14) JDIMM4.30(VSS15) JDIMM4.31(VSS16) JDIMM4.35(VSS17) JDIMM4.36(VSS18) JDIMM4.39(VSS19) JDIMM4.40(VSS20) JDIMM4.43(VSS21) JDIMM4.44(VSS22) JDIMM4.47(VSS23) JDIMM4.48(VSS24) JDIMM4.51(VSS25) JDIMM4.52(VSS26) JDIMM4.56(VSS27) JDIMM4.57(VSS28) JDIMM4.60(VSS29) JDIMM4.61(VSS30) JDIMM4.64(VSS31) JDIMM4.65(VSS32) JDIMM4.68(VSS33) JDIMM4.69(VSS34) JDIMM4.72(VSS35) JDIMM4.73(VSS36) JDIMM4.77(VSS37) JDIMM4.78(VSS38) JDIMM4.81(VSS39) JDIMM4.82(VSS40) JDIMM4.85(VSS41) JDIMM4.86(VSS42) JDIMM4.89(VSS43) JDIMM4.90(VSS44) JDIMM4.93(VSS45) JDIMM4.94(VSS46) JDIMM4.98(VSS47) JDIMM4.99(VSS48) JDIMM4.102(VSS49) JDIMM4.103(VSS50) JDIMM4.106(VSS51) JDIMM4.107(VSS52) JDIMM4.167(VSS53) JDIMM4.168(VSS54) JDIMM4.171(VSS55) JDIMM4.172(VSS56) JDIMM4.175(VSS57) JDIMM4.176(VSS58) JDIMM4.180(VSS59) JDIMM4.181(VSS60) JDIMM4.184(VSS61) JDIMM4.185(VSS62) JDIMM4.188(VSS63) JDIMM4.189(VSS64) JDIMM4.192(VSS65) JDIMM4.193(VSS66) JDIMM4.196(VSS67) JDIMM4.197(VSS68) JDIMM4.201(VSS69) JDIMM4.202(VSS70) JDIMM4.205(VSS71) JDIMM4.206(VSS72) JDIMM4.209(VSS73) JDIMM4.210(VSS74) JDIMM4.213(VSS75) JDIMM4.214(VSS76) JDIMM4.217(VSS77) JDIMM4.218(VSS78) JDIMM4.222(VSS79) JDIMM4.223(VSS80) JDIMM4.226(VSS81) JDIMM4.227(VSS82) JDIMM4.230(VSS83) JDIMM4.231(VSS84) JDIMM4.234(VSS85) JDIMM4.235(VSS86) JDIMM4.238(VSS87) JDIMM4.239(VSS88) JDIMM4.243(VSS89) JDIMM4.244(VSS90) JDIMM4.247(VSS91) JDIMM4.248(VSS92) JDIMM4.251(VSS93) JDIMM4.252(VSS94) JDIMM4.261(GND1) JDIMM4.262(GND2) JEDP1.12 JEDP1.14 JEDP1.21 JEDP1.22 JEDP1.23 JEDP1.30 JEDP1.31 JEDP1.40 JEDP1.41(G1) JEDP1.42(G2) JEDP1.43(G3) JEDP1.44(G4) JEDP1.45(G5) JESPI.9 JESPI.11(GND1) JESPI.12(GND2) JFAN1.1 JFAN1.5(GND1) JFAN1.6(GND2) JFAN2.1 JFAN2.5(GND1) JFAN2.6(GND2) JIR1.2 JIR1.3 JIR1.7(GND1) JIR1.8(GND2) JKBTP1.2(2        2) JKBTP1.3 JKBTP1.9 JKBTP1.15 JKBTP1.17 JKBTP1.20(20     20) JKBTP1.21(G1) JKBTP1.22(G2) JKBTP1.23(G3) JKBTP1.24(G4) JLED1.4(4        4) JLED1.7(G1) JLED1.8(G2) JLED1.9(G3) JLED1.10(G4) JLOM1.9(GND2) JLOM1.10(GND1) JNGFF1.1 JNGFF1.7 JNGFF1.10 JNGFF1.15 JNGFF1.16 JNGFF1.21 JNGFF1.22 JNGFF1.25 JNGFF1.28 JNGFF1.31 JNGFF1.37 JNGFF1.43 JNGFF1.49 JNGFF1.55 JNGFF1.61 JNGFF1.67 JNGFF1.68(GND1) JNGFF1.69(GND2) JNGFF2.3 JNGFF2.5 JNGFF2.11 JNGFF2.19 JNGFF2.25 JNGFF2.31 JNGFF2.37 JNGFF2.43 JNGFF2.49 JNGFF2.63 JNGFF2.65 JNGFF2.68(GND1) JNGFF2.69(GND2) JNGFF3.1(GND1) JNGFF3.3(GND2) JNGFF3.9(GND3) JNGFF3.15(GND4) JNGFF3.21(GND5) JNGFF3.27(GND6) JNGFF3.33(GND7) JNGFF3.39(GND8) JNGFF3.45(GND9) JNGFF3.51(GND10) JNGFF3.57(GND11) JNGFF3.63(GND12) JNGFF3.65(GND13) JNGFF3.67(GND14) JNGFF3.68(GND15) JNGFF3.69(GND16) JNGFF4.1(GND3) JNGFF4.3(GND4) JNGFF4.9(GND5) JNGFF4.15(GND6) JNGFF4.21(GND7) JNGFF4.27(GND8) JNGFF4.33(GND9) JNGFF4.39(GND10) JNGFF4.45(GND11) JNGFF4.51(GND12) JNGFF4.57(GND13) JNGFF4.71(GND14) JNGFF4.73(GND15) JNGFF4.76(GND1) JNGFF4.77(GND2) JNGFF5.1(GND1) JNGFF5.3(GND2) JNGFF5.9(GND3) JNGFF5.15(GND4) JNGFF5.21(GND5) JNGFF5.27(GND6) JNGFF5.33(GND7) JNGFF5.39(GND8) JNGFF5.45(GND9) JNGFF5.51(GND10) JNGFF5.57(GND11) JNGFF5.63(GND12) JNGFF5.65(GND13) JNGFF5.67(GND14) JNGFF5.68(GND15) JNGFF5.69(GND16) JNGFF6.1(GND1) JNGFF6.3(GND2) JNGFF6.9(GND3) JNGFF6.15(GND4) JNGFF6.21(GND5) JNGFF6.27(GND6) JNGFF6.33(GND7) JNGFF6.39(GND8) JNGFF6.45(GND9) JNGFF6.51(GND10) JNGFF6.57(GND11) JNGFF6.63(GND12) JNGFF6.65(GND13) JNGFF6.67(GND14) JNGFF6.68(GND15) JNGFF6.69(GND16) JPB1.5 JPB1.7(GND1) JPB1.8(GND2) JRTC1.2 JRTC1.3(GND#3) JRTC1.4(GND#4) JSD1.3(VSS1) JSD1.6(VSS2) JSD1.10(VSS3) JSD1.13(VSS4) JSD1.19(GND1) JSD1.20(GND2) JSD1.21(GND3) JSD1.22(GND4) JSD1.23(GND5) JSD1.24(GND6) JSD1.25(GND7) JSIM1.7(GND1) JSIM1.9(GND2) JSIM1.10(GND4) JSIM1.11(GND3) JSIM1.12(GND5) JSPI1.17 JSPI1.18(18     18) JSPI1.19 JSPI1.20(20     20) JSPI1.21(G1) JSPI1.22(G2) JSPI1.23(G3) JSPI1.24(G4) JSPK1.6 JSPK1.7(G1) JSPK1.8(G2) JTAG1.2 JUSB1.4(GND6) JUSB1.7(GND5) JUSB1.10(GND1) JUSB1.11(GND2) JUSB1.12(GND3) JUSB1.13(GND4) JUSB2.4(GND6) JUSB2.7(GND5) JUSB2.10(GND1) JUSB2.11(GND2) JUSB2.12(GND3) JUSB2.13(GND4) JUSB3.4(GND6) JUSB3.7(GND5) JUSB3.10(GND1) JUSB3.11(GND2) JUSB3.12(GND3) JUSB3.13(GND4) JUSBC1.1(GND6) JUSBC1.1A1(GND2) JUSBC1.1A12(GND4) JUSBC1.1B1(GND3) JUSBC1.1B12(GND1) JUSBC1.2(GND8) JUSBC1.3(GND9) JUSBC1.4(GND5) JUSBC1.5(GND7) JUSBC1.6(GND6) JUSBC1.7(GND8) JUSBC1.8(GND9) JUSBC1.9(GND5) JUSBC1.10(GND7) JUSBC1.A1(GND2) JUSBC1.A12(GND4) JUSBC1.B1(GND3) JUSBC1.B12(GND1) JUSH1.3 JUSH1.17 JUSH1.20 JUSH1.21 JUSH1.27(GND1) JUSH1.28(GND2) JXDP1.2 JXDP1.7 JXDP1.8 JXDP1.13 JXDP1.14 JXDP1.19 JXDP1.20 JXDP1.25 JXDP1.26 JXDP1.31 JXDP1.32 JXDP1.37 JXDP1.38 JXDP1.49 JXDP1.50 JXDP1.59 JXDP1.61 JXDP1.62(GND#62) JXDP1.63(GND#63) LGA1.5(RES) LGA1.6(GND1) LGA1.7(GND2) LGA1.8(GND3) PBATT1.7 PBATT1.8 PBATT1.9 PBATT1.10 PC2.2 PC4.2 PC5.1 PC6.2 PC7.2 PC8.2 PC9.2 PC10.2 PC13.2 PC14.2 PC15.2 PC16.2 PC17.2 PC20.2 PC21.2 PC22.2 PC23.2(G) PC24.2 PC25.2 PC30.2 PC100.2 PC101.2 PC102.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC111.2 PC113.2 PC114.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC127.2 PC129.2 PC138.2 PC200.2 PC202.2 PC203.2 PC204.2 PC205.2 PC206.2 PC207.2(G) PC208.2 PC209.2 PC210.2 PC212.2 PC213.2 PC300.2 PC301.2 PC302.2 PC303.2 PC304.2 PC307.2 PC308.2 PC309.2 PC310.2 PC312.2 PC313.2 PC314.2 PC400.2 PC401.2 PC403.2 PC404.2 PC405.2 PC406.2 PC500.2 PC502.2 PC503.2 PC504.2 PC505.2 PC506.2 PC507.2 PC508.2 PC509.2 PC510.2 PC511.2 PC512.2 PC513.2 PC515.2 PC520.2 PC521.2 PC522.2 PC523.2 PC524.2 PC525.2 PC527.2 PC528.2 PC529.2 PC530.2 PC532.2 PC533.2 PC700.1 PC702.2 PC703.2 PC704.2 PC705.2 PC706.2 PC707.2 PC710.2 PC713.2 PC714.2 PC715.2 PC716.2 PC717.2 PC800.2 PC801.2 PC802.2 PC803.2 PC805.2 PC806.2(G) PC807.2 PC808.2 PC900.2 PC901.2 PC902.2 PC903.2 PC905.2 PC906.2 PC1100.1 PC1101.1 PC1106.1 PC1108.1 PC1118.1 PC1120.2 PC1123.1 PC1126.2 PC1127.2 PC1128.1 PC1129.2 PC1130.2 PC1137.2 PC1204.2(G) PC1205.2(G) PC1206.2 PC1207.2 PC1208.2 PC1209.2 PC1210.2 PC1211.2 PC1213.1 PC1215.2 PC1217.2 PC1218.2 PC1219.2 PC1220.2 PC1221.2 PC1222.2 PC1223.1 PC1225.2 PC1227.2 PC1228.2 PC1229.2 PC1230.2 PC1231.2 PC1232.2 PC1234.1 PC1235.2 PC1237.2 PC1238.2 PC1239.2 PC1240.2 PC1241.2 PC1242.2 PC1244.1 PC1245.2 PC1300.2 PC1301.2 PC1302.2 PC1303.2 PC1304.2 PC1305.2 PC1306.2 PC1307.2 PC1308.2 PC1309.2 PC1310.2 PC1311.2 PC1312.2 PC1313.2 PC1314.2 PC1315.2 PC1316.2 PC1317.2 PC1318.2 PC1319.2 PC1320.2 PC1321.2 PC1322.2 PC1323.2 PC1324.2 PC1325.2 PC1326.2 PC1327.2 PC1328.2 PC1329.2 PC1330.2 PC1331.2 PC1332.2 PC1333.2 PC1334.2 PC1335.2 PC1336.2 PC1337.2 PC1338.2 PC1339.2 PC1340.2 PC1341.2 PC1342.2 PC1343.2 PC1344.2 PC1345.2 PC1346.2 PC1347.2 PC1348.2 PC1349.2 PC1350.2 PC1351.2 PC1352.2 PC1353.2 PC1354.2 PC1355.2 PC1356.2 PC1357.2 PC1358.2 PC1359.2 PC1360.2 PC1361.2 PC1362.2 PC1363.2 PC1364.2 PC1365.2 PC1366.2 PC1367.2 PC1368.2 PC1369.2 PC1370.2 PC1371.2 PC1372.2 PC1373.2 PC1374.2 PC1375.2 PC1376.2 PC1377.2 PC1378.2 PC1379.2 PC1380.2 PC1381.2 PC1382.2 PC1383.2 PC1384.2 PC1385.2 PC1386.2 PC1387.2 PC1388.2 PC1389.2 PC1390.2 PC1391.2 PC1392.2 PC1393.2 PC1394.2 PC1395.2 PC1396.2 PC1397.2 PC1398.2 PC1399.2 PC1400.2 PC1401.2 PC1402.2 PC1403.2 PC1404.2 PC1405.2 PC1406.2 PC1407.2 PC1408.2 PC1409.2 PC1410.2 PC1411.2 PC1412.2 PC1413.2 PC1414.2 PC1415.2 PC1416.2 PC1417.2 PC1418.2 PC1419.2 PC1420.2 PC1421.2 PC1500.2(G) PC1502.2 PC1503.2 PC1504.2 PC1505.2 PC1506.2 PC1507.2 PC1508.2 PC1509.2 PC1510.2 PC1511.2 PC1512.2 PC1513.2 PC1514.2 PC1515.2 PC1516.2 PC1517.2 PC1518.2 PC1519.2 PC1520.2 PC1521.2 PC1522.2 PC1523.2 PC1524.2 PC1525.2 PC1526.2 PC1527.2 PC1528.2 PC1529.2 PC1530.2 PC1531.2 PC1532.2 PC1533.2 PC1534.2 PC1535.2 PC1536.2 PC1600.2 PC1601.2 PC1602.2 PC1603.2 PC1604.2 PC1605.2 PC1606.2 PC1607.2 PC1608.2 PC1609.2 PC1610.2 PC1611.2 PC1612.2 PC1613.2 PC1614.2 PC1615.2 PC1616.2 PC1617.2 PC1700.2 PC1701.2 PC1702.2 PC1703.2 PC1704.2 PC1705.2 PC1707.1 PC1708.2 PC1710.2 PC1711.2 PC1712.2 PC1713.2 PC1800.2 PC1801.2 PC1802.2 PC1803.2 PC1804.2 PC1805.2 PC1807.1 PC1808.2 PC2003.1 PC2007.2 PC2008.2 PC2009.2 PC2010.2 PC2011.2 PC2012.2 PC2013.2 PC2014.2 PC2015.2 PC2016.2 PC2017.2 PC2018.2 PC2019.2 PC2020.2 PC2021.2 PC2022.2 PC2023.2 PC2024.2 PC2025.2 PC2026.2 PC2103.2 PC2104.2 PC2105.2 PC2106.2 PD2.2 PD3.1 PD9.1 PD10.1 PD200.2 PD702.2 PH1103.2 PH1104.2 PJP19.2 PJP701.2 PJPDC1.3 PJPDC1.4 PJPDC1.5 PJPDC1.6 PJPDC1.11 PQ1.1(S1) PQ2.1(S1) PQ2.4(S2) PQ3.1(S1) PQ3.4(S2) PQ4.1(S1) PQ5.1(S1) PQ5.4(S2) PQ6.1(S1) PQ6.4(S2) PQ7.1(S1) PQ8.1(S1) PQ8.4(S2) PQ9.1(S1) PQ9.4(S2) PQ16.3(EMITTER) PQ26.3(S) PQ201.1(S1) PQ201.2(S2) PQ201.3(S3) PQ703.1(S1) PQ703.2(S2) PQ703.3(S3) PQ801.1(S1) PQ801.2(S2) PQ801.3(S3) PQ2001.1(S1) PQ2001.4(S1) PQ2003.1(S1) PQ2003.4(S1) PQ2004.4(S1) PQ2005.4(S1) PQ2006.1(S1) PQ2006.4(S1) PQ2007.1(S1) PQ2007.4(S2) PQ2008.1(S1) PQ2008.4(S2) PQ2009.1(S1) PQ2009.4(S2) PQ2010.3(S) PQ2012.1(S1) PQ2012.4(S1) PQ2102.1(S1) PQ2106.1(S1) PQ2109.1(S1) PQ2109.4(S2) PQ2110.1(S1) PQ2110.4(S2) PQ2111.1(S1) PQ2111.4(S2) PQ2112.1(S1) PQ2112.4(S2) PR18.1 PR27.2 PR42.1 PR45.2 PR58.1 PR64.2 PR74.2 PR75.2 PR76.2 PR108.2 PR115.2 PR209.2 PR307.2 PR308.2 PR310.1 PR312.1 PR314.2 PR402.2 PR405.2 PR507.2 PR512.2 PR726.2 PR729.2 PR732.2 PR801.1 PR804.2 PR808.2 PR811.1 PR902.2 PR905.2 PR1100.1 PR1112.1 PR1116.1 PR1118.1 PR1120.2 PR1125.1 PR1129.2 PR1132.1 PR1135.2 PR1152.2 PR1153.2 PR1155.2 PR1156.2 PR1157.2 PR1158.2 PR1167.2 PR1168.2 PR1171.2 PR1202.2 PR1206.2 PR1210.2 PR1213.2 PR1702.2 PR1802.2 PR2032.2 PR2033.2 PR2034.2 PR2035.2 PR2053.2 PR2056.2 PR2059.2 PR2060.2 PR2061.2 PR2062.2 PR2108.2 PR2109.2 PR2144.2 PR2146.2 PR2161.1 PR2163.1 PU1.3(G) PU100.7(GND1) PU100.8(GND2) PU100.18(GND3) PU100.21(GND4) PU101.7(GND1) PU101.8(GND2) PU101.18(GND3) PU101.21(GND4) PU200.1(VTTGND) PU200.3(GND) PU200.14(PGND) PU200.21(PAD) PU300.2(PGND) PU300.11(AGND) PU400.4(GND1) PU400.8(GND2) PU400.9(TP) PU500.7(GND1) PU500.8(GND2) PU500.18(GND3) PU500.21(GND4) PU501.7(GND1) PU501.8(GND2) PU501.18(GND3) PU501.21(GND4) PU700.22(GND) PU800.11(TP) PU900.4(GND1) PU900.8(GND2) PU900.9(TP) PU1100.53(TAB) PU1200.4(CGND) PU1200.10(PGND1) PU1200.14(PGND2) PU1200.18(AGND) PU1201.4(CGND) PU1201.10(PGND1) PU1201.14(PGND2) PU1201.18(AGND) PU1202.4(CGND) PU1202.10(PGND1) PU1202.14(PGND2) PU1202.18(AGND) PU1203.4(CGND) PU1203.10(PGND1) PU1203.14(PGND2) PU1203.18(AGND) PU1700.4(CGND) PU1700.10(PGND1) PU1700.14(PGND2) PU1700.18(AGND) PU1800.2(SMOD#) PU1800.4(CGND) PU1800.10(PGND1) PU1800.14(PGND2) PU1800.18(AGND) PU2001.4(G) PU2003.4(G) PU2004.4(G) PWRSW1.2 QA10.3(S) QE2.1(S) QE2.4(S) QE12.3(S) QE17.3(S) QH6.3(S) QN1.1(S) QN1.4(S) QT1.3(S) QT4.1(S) QT4.4(S) QT5.3(S) QT6.3(S) QT7.3(S) QT8.3(S) QT9.3(S) QV2.3(S) QV23.1(S) QV23.4(S) QV43.3(S) QV44.4(S) QZ17.1(S) QZ17.4(S) QZ18.1(S) QZ18.4(S) QZ20.3(S) QZ21.3(S) R127.2 R128.2 R129.2 RA52.1 RA209.2 RA220.2 RA221.1 RA222.1 RA223.1 RA225.2 RA226.1 RA227.1 RA228.1 RC5.1 RC6.1 RC7.1 RC75.2 RC114.2 RC122.2 RC136.2 RC139.2 RC171.1 RC178.2 RC179.2 RC181.2 RC219.1 RC319.1 RC321.2 RC322.2 RC323.2 RC324.2 RC325.2 RC436.2 RC437.2 RC438.2 RC440.2 RC441.2 RC442.2 RC443.2 RD11.2 RD12.2 RD18.2 RD32.2 RD33.2 RD37.2 RD42.2 RD43.2 RD51.2 RD79.1 RD80.1 RD81.1 RD82.1 RD83.1 RD87.1 RD89.1 RD90.1 RE20.2 RE55.2 RE56.2 RE58.2 RE65.2 RE77.2 RE86.2 RE93.2 RE95.1 RE313.2 RE342.2 RE541.1 RE550.2 RE567.2 RE568.2 RE702.2 RE736.1 RE737.1 RE738.1 RH1.1 RH65.2 RH70.2 RH74.2 RH83.2 RH110.1 RH193.2 RH268.2 RH308.2 RH313.2 RH325.1 RH326.1 RH334.1 RH349.2 RH364.2 RH365.2 RH372.2 RH379.2 RH401.2 RH424.2 RH435.1 RH554.2 RH556.2 RH603.2 RH606.2 RH608.2 RH609.1 RH610.1 RH611.1 RH612.1 RH617.2 RH629.2 RH630.1 RH631.2 RH632.2 RH633.2 RH634.2 RH635.2 RH636.1 RH637.1 RH638.2 RH639.2 RH640.2 RH641.2 RH718.2 RH719.2 RH720.2 RH721.2 RH733.2 RI14.1 RI71.1 RI75.1 RI76.1 RI77.1 RI79.1 RI91.1 RI92.1 RI93.1 RL3.2 RL9.2 RL12.2 RL13.2 RR205.2 RR232.2 RR239.1 RT23.2 RT26.2 RT27.2 RT33.2 RT34.2 RT36.2 RT41.1 RT42.1 RT184.2 RT440.1 RT447.1 RT505.2 RT506.2 RT507.2 RT508.2 RT509.2 RT523.2 RT524.2 RT527.2 RT536.2 RT537.2 RT544.2 RT553.2 RT554.1 RT567.2 RT568.2 RT571.1 RT573.1 RT575.1 RT577.1 RT583.1 RT584.1 RT585.2 RT587.2 RT610.1 RT611.1 RT614.2 RT616.1 RT617.2 RT618.2 RV3.2 RV50.2 RV56.2 RV58.2 RV60.2 RV62.2 RV64.2 RV66.2 RV130.1 RV131.1 RV812.2 RV813.2 RV818.2 RV829.2 RV830.2 RV831.2 RV832.2 RV833.2 RV834.2 RV835.1 RV836.2 RV839.2 RV842.1 RV856.2 RV857.2 RV858.2 RV861.1 RV863.2 RV868.2 RV870.1 RV871.2 RV872.2 RV873.2 RV874.2 RV875.2 RV876.2 RV880.2 RV881.2 RV882.2 RV883.2 RV884.2 RV889.2 RV890.2 RV892.2 RV894.2 RV895.2 RV896.1 RV897.2 RV898.2 RV902.2 RV903.2 RV905.2 RV908.2 RV911.2 RZ10.1 RZ25.2 RZ62.2 RZ513.2 RZ537.2 RZ538.2 RZ539.2 RZ540.2 RZ541.2 RZ547.2 SW1.4(G1) SW1.5(G2) SW3.1 SW3.3 UA1.49(G) UC1.A3(VSS_A3) UC1.A4(VSS_A4) UC1.A6(VSS_11) UC1.A9(VSS_12) UC1.A10(VSS_1) UC1.A12(VSS_2) UC1.A14(VSS_154) UC1.A16(VSS_3) UC1.A18(VSS_4) UC1.A20(VSS_5) UC1.A22(VSS_6) UC1.A24(VSS_7) UC1.A26(VSS_8) UC1.A28(VSS_9) UC1.A30(VSS_10) UC1.A34(VSS_A34) UC1.AA12(VSS_13) UC1.AA29(VSS_14) UC1.AA30(VSS_15) UC1.AB6(VSS_18) UC1.AB33(VSS_16) UC1.AB34(VSS_17) UC1.AC1(VSS_19) UC1.AC2(VSS_21) UC1.AC3(VSS_22) UC1.AC4(VSS_25) UC1.AC5(VSS_26) UC1.AC6(VSS_27) UC1.AC12(VSS_20) UC1.AC37(VSS_23) UC1.AC38(VSS_24) UC1.AD6(VSS_33) UC1.AD7(VSS_155) UC1.AD8(VSS_34) UC1.AD9(VSS_35) UC1.AD10(VSS_28) UC1.AD11(VSS_29) UC1.AD12(VSS_30) UC1.AD29(VSS_31) UC1.AD30(VSS_32) UC1.AE6(VSS_38) UC1.AE33(VSS_36) UC1.AE34(VSS_37) UC1.AF1(VSS_39) UC1.AF2(VSS_43) UC1.AF3(VSS_44) UC1.AF4(VSS_45) UC1.AF12(VSS_40) UC1.AF13(VSS_41) UC1.AF14(VSS_42) UC1.AG6(VSS_51) UC1.AG7(VSS_52) UC1.AG8(VSS_53) UC1.AG10(VSS_46) UC1.AG11(VSS_47) UC1.AG13(VSS_48) UC1.AG29(VSS_49) UC1.AG30(VSS_50) UC1.AH6(VSS_59) UC1.AH12(VSS_54) UC1.AH33(VSS_55) UC1.AH34(VSS_56) UC1.AH35(VSS_57) UC1.AH36(VSS_58) UC1.AJ1(VSS_60) UC1.AJ2(VSS_62) UC1.AJ3(VSS_63) UC1.AJ4(VSS_66) UC1.AJ5(VSS_67) UC1.AJ6(VSS_68) UC1.AJ13(VSS_61) UC1.AJ37(VSS_64) UC1.AJ38(VSS_65) UC1.AK4(VSS_82) UC1.AK29(VSS_80) UC1.AK30(VSS_81) UC1.AL4(VSS_88) UC1.AL7(VSS_89) UC1.AL8(VSS_90) UC1.AL9(VSS_91) UC1.AL10(VSS_83) UC1.AL12(VSS_84) UC1.AL14(VSS_85) UC1.AL33(VSS_86) UC1.AL34(VSS_87) UC1.AM1(VSS_92) UC1.AM2(VSS_94) UC1.AM3(VSS_95) UC1.AM4(VSS_98) UC1.AM5(VSS_99) UC1.AM12(VSS_93) UC1.AM37(VSS_96) UC1.AM38(VSS_97) UC1.AN5(VSS_103) UC1.AN6(VSS_104) UC1.AN12(VSS_100) UC1.AN29(VSS_101) UC1.AN30(VSS_102) UC1.AP8(VSS_110) UC1.AP9(VSS_111) UC1.AP10(VSS_105) UC1.AP11(VSS_106) UC1.AP12(VSS_107) UC1.AP33(VSS_108) UC1.AP34(VSS_109) UC1.AR1(VSS_112) UC1.AR2(VSS_115) UC1.AR3(VSS_117) UC1.AR4(VSS_127) UC1.AR5(VSS_128) UC1.AR13(VSS_113) UC1.AR14(VSS_114) UC1.AR29(VSS_116) UC1.AR30(VSS_118) UC1.AR31(VSS_119) UC1.AR32(VSS_120) UC1.AR33(VSS_121) UC1.AR34(VSS_122) UC1.AR35(VSS_123) UC1.AR36(VSS_124) UC1.AR37(VSS_125) UC1.AR38(VSS_126) UC1.AT6(VSS_131) UC1.AT29(VSS_129) UC1.AT30(VSS_130) UC1.AU6(VSS_137) UC1.AU7(VSS_138) UC1.AU8(VSS_139) UC1.AU9(VSS_140) UC1.AU10(VSS_132) UC1.AU11(VSS_133) UC1.AU12(VSS_134) UC1.AU33(VSS_135) UC1.AU34(VSS_136) UC1.AV37(VSS_141) UC1.AV38(VSS_142) UC1.AW1(VSS_143) UC1.AW2(VSS_145) UC1.AW3(VSS_147) UC1.AW4(VSS_149) UC1.AW5(VSS_163) UC1.AW12(VSS_144) UC1.AW29(VSS_146) UC1.AW30(VSS_148) UC1.AY12(VSS_164) UC1.AY14(VSS_316) UC1.AY33(VSS_165) UC1.AY34(VSS_166) UC1.B3(VSS_B3) UC1.B9(VSS_167) UC1.B37(VSS_B37) UC1.BA6(VSS_173) UC1.BA7(VSS_174) UC1.BA8(VSS_175) UC1.BA9(VSS_176) UC1.BA10(VSS_168) UC1.BA11(VSS_169) UC1.BA12(VSS_170) UC1.BA37(VSS_171) UC1.BA38(VSS_172) UC1.BB1(VSS_177) UC1.BB2(VSS_179) UC1.BB3(VSS_181) UC1.BB4(VSS_183) UC1.BB5(VSS_184) UC1.BB6(VSS_185) UC1.BB12(VSS_178) UC1.BB29(VSS_180) UC1.BB30(VSS_182) UC1.BC6(VSS_191) UC1.BC12(VSS_186) UC1.BC13(VSS_187) UC1.BC14(VSS_188) UC1.BC33(VSS_189) UC1.BC34(VSS_190) UC1.BD6(VSS_196) UC1.BD7(VSS_197) UC1.BD8(VSS_198) UC1.BD9(VSS_199) UC1.BD10(VSS_192) UC1.BD11(VSS_193) UC1.BD12(VSS_194) UC1.BD37(VSS_195) UC1.BD38(VSS_317) UC1.BE1(VSS_200) UC1.BE2(VSS_201) UC1.BE3(VSS_203) UC1.BE4(VSS_205) UC1.BE5(VSS_206) UC1.BE6(VSS_207) UC1.BE29(VSS_202) UC1.BE30(VSS_204) UC1.BF6(VSS_211) UC1.BF12(VSS_208) UC1.BF33(VSS_209) UC1.BF34(VSS_210) UC1.BG6(VSS_217) UC1.BG12(VSS_212) UC1.BG13(VSS_213) UC1.BG14(VSS_214) UC1.BG37(VSS_215) UC1.BG38(VSS_216) UC1.BH1(VSS_218) UC1.BH2(VSS_223) UC1.BH3(VSS_224) UC1.BH4(VSS_225) UC1.BH5(VSS_226) UC1.BH6(VSS_227) UC1.BH7(VSS_228) UC1.BH8(VSS_229) UC1.BH9(VSS_230) UC1.BH10(VSS_219) UC1.BH11(VSS_220) UC1.BH12(VSS_221) UC1.BH14(VSS_222) UC1.BJ12(VSS_242) UC1.BJ14(VSS_243) UC1.BJ15(VSS_244) UC1.BJ18(VSS_245) UC1.BJ22(VSS_246) UC1.BJ25(VSS_247) UC1.BJ29(VSS_248) UC1.BJ30(VSS_249) UC1.BJ31(VSS_250) UC1.BJ32(VSS_251) UC1.BJ33(VSS_252) UC1.BJ34(VSS_253) UC1.BJ35(VSS_254) UC1.BJ36(VSS_255) UC1.BK6(VSS_263) UC1.BK13(VSS_256) UC1.BK14(VSS_257) UC1.BK15(VSS_258) UC1.BK18(VSS_259) UC1.BK22(VSS_260) UC1.BK25(VSS_261) UC1.BK29(VSS_262) UC1.BL6(VSS_275) UC1.BL13(VSS_264) UC1.BL14(VSS_265) UC1.BL18(VSS_266) UC1.BL19(VSS_267) UC1.BL20(VSS_268) UC1.BL21(VSS_269) UC1.BL22(VSS_270) UC1.BL29(VSS_271) UC1.BL33(VSS_272) UC1.BL35(VSS_273) UC1.BL38(VSS_274) UC1.BM2(VSS_281) UC1.BM3(VSS_291) UC1.BM5(VSS_295) UC1.BM6(VSS_296) UC1.BM7(VSS_297) UC1.BM8(VSS_298) UC1.BM9(VSS_299) UC1.BM11(VSS_276) UC1.BM12(VSS_277) UC1.BM13(VSS_278) UC1.BM14(VSS_279) UC1.BM18(VSS_280) UC1.BM21(VSS_282) UC1.BM22(VSS_283) UC1.BM23(VSS_284) UC1.BM24(VSS_285) UC1.BM25(VSS_286) UC1.BM26(VSS_287) UC1.BM27(VSS_288) UC1.BM28(VSS_289) UC1.BM29(VSS_290) UC1.BM33(VSS_292) UC1.BM35(VSS_293) UC1.BM38(VSS_294) UC1.BN2(VSS_304) UC1.BN4(VSS_325) UC1.BN7(VSS_326) UC1.BN12(VSS_300) UC1.BN14(VSS_301) UC1.BN18(VSS_302) UC1.BN19(VSS_303) UC1.BN20(VSS_305) UC1.BN21(VSS_306) UC1.BN24(VSS_307) UC1.BN29(VSS_308) UC1.BN30(VSS_309) UC1.BN31(VSS_310) UC1.BN34(VSS_311) UC1.BP7(VSS_337) UC1.BP12(VSS_327) UC1.BP14(VSS_328) UC1.BP18(VSS_329) UC1.BP21(VSS_330) UC1.BP24(VSS_331) UC1.BP25(VSS_332) UC1.BP26(VSS_333) UC1.BP29(VSS_334) UC1.BP33(VSS_335) UC1.BP34(VSS_336) UC1.BR7(VSS_348) UC1.BR9(VSS_479) UC1.BR12(VSS_338) UC1.BR14(VSS_339) UC1.BR18(VSS_340) UC1.BR21(VSS_341) UC1.BR24(VSS_342) UC1.BR25(VSS_343) UC1.BR26(VSS_344) UC1.BR29(VSS_345) UC1.BR34(VSS_346) UC1.BR36(VSS_347) UC1.BR38(VSS_BR38) UC1.BT3(VSS_BT3) UC1.BT4(VSS_BT4) UC1.BT5(VSS_357) UC1.BT8(VSS_478) UC1.BT12(VSS_349) UC1.BT14(VSS_350) UC1.BT18(VSS_351) UC1.BT21(VSS_352) UC1.BT24(VSS_353) UC1.BT26(VSS_354) UC1.BT29(VSS_355) UC1.BT32(VSS_356) UC1.BT35(VSS_BT35) UC1.BT36(VSS_BT36) UC1.C2(VSS_C2) UC1.C5(VSS_370) UC1.C8(VSS_371) UC1.C9(VSS_372) UC1.C11(VSS_358) UC1.C13(VSS_359) UC1.C15(VSS_360) UC1.C17(VSS_361) UC1.C19(VSS_362) UC1.C21(VSS_363) UC1.C23(VSS_364) UC1.C25(VSS_365) UC1.C27(VSS_366) UC1.C29(VSS_367) UC1.C31(VSS_368) UC1.C37(VSS_369) UC1.D3(VSS_383) UC1.D6(VSS_386) UC1.D9(VSS_387) UC1.D10(VSS_373) UC1.D12(VSS_374) UC1.D14(VSS_375) UC1.D16(VSS_376) UC1.D18(VSS_377) UC1.D20(VSS_378) UC1.D22(VSS_379) UC1.D24(VSS_380) UC1.D26(VSS_381) UC1.D28(VSS_382) UC1.D30(VSS_384) UC1.D33(VSS_385) UC1.D38(VSS_D38) UC1.E4(VSS_391) UC1.E9(VSS_392) UC1.E34(VSS_388) UC1.E35(VSS_389) UC1.E38(VSS_390) UC1.F2(VSS_412) UC1.F3(VSS_418) UC1.F4(VSS_421) UC1.F5(VSS_422) UC1.F8(VSS_423) UC1.F9(VSS_424) UC1.F11(VSS_407) UC1.F13(VSS_408) UC1.F15(VSS_409) UC1.F17(VSS_410) UC1.F19(VSS_411) UC1.F21(VSS_413) UC1.F23(VSS_414) UC1.F25(VSS_415) UC1.F27(VSS_416) UC1.F29(VSS_417) UC1.F31(VSS_419) UC1.F36(VSS_420) UC1.G4(VSS_436) UC1.G5(VSS_437) UC1.G6(VSS_438) UC1.G8(VSS_439) UC1.G9(VSS_440) UC1.G10(VSS_425) UC1.G12(VSS_426) UC1.G14(VSS_427) UC1.G16(VSS_428) UC1.G18(VSS_429) UC1.G20(VSS_430) UC1.G22(VSS_431) UC1.G23(VSS_432) UC1.G24(VSS_433) UC1.G26(VSS_434) UC1.G28(VSS_435) UC1.H11(VSS_441) UC1.H12(VSS_442) UC1.H18(VSS_443) UC1.H22(VSS_444) UC1.H25(VSS_445) UC1.H32(VSS_446) UC1.H35(VSS_447) UC1.J4(VSS_455) UC1.J7(VSS_456) UC1.J10(VSS_448) UC1.J18(VSS_449) UC1.J22(VSS_450) UC1.J25(VSS_451) UC1.J32(VSS_452) UC1.J33(VSS_453) UC1.J36(VSS_454) UC1.K1(VSS_457) UC1.K2(VSS_460) UC1.K3(VSS_461) UC1.K4(VSS_463) UC1.K5(VSS_464) UC1.K7(VSS_465) UC1.K8(VSS_466) UC1.K9(VSS_467) UC1.K10(VSS_458) UC1.K11(VSS_459) UC1.K38(VSS_462) UC1.L29(VSS_468) UC1.L30(VSS_469) UC1.L33(VSS_470) UC1.L34(VSS_471) UC1.M6(VSS_405) UC1.M12(VSS_472) UC1.M13(VSS_473) UC1.M14(VSS_404) UC1.N1(VSS_406) UC1.N2(VSS_477) UC1.N3(VSS_393) UC1.N4(VSS_396) UC1.N5(VSS_397) UC1.N6(VSS_398) UC1.N7(VSS_399) UC1.N8(VSS_400) UC1.N9(VSS_401) UC1.N10(VSS_474) UC1.N11(VSS_475) UC1.N12(VSS_476) UC1.N33(VSS_394) UC1.N34(VSS_395) UC1.P6(VSS_313) UC1.P12(VSS_402) UC1.P37(VSS_403) UC1.P38(VSS_312) UC1.R12(VSS_314) UC1.R29(VSS_315) UC1.R30(VSS_318) UC1.T1(VSS_319) UC1.T2(VSS_231) UC1.T3(VSS_232) UC1.T4(VSS_235) UC1.T5(VSS_236) UC1.T7(VSS_237) UC1.T8(VSS_238) UC1.T9(VSS_239) UC1.T10(VSS_320) UC1.T11(VSS_321) UC1.T12(VSS_322) UC1.T13(VSS_323) UC1.T14(VSS_324) UC1.T33(VSS_233) UC1.T34(VSS_234) UC1.U6(VSS_150) UC1.U37(VSS_240) UC1.U38(VSS_241) UC1.V6(VSS_156) UC1.V12(VSS_151) UC1.V29(VSS_152) UC1.V30(VSS_153) UC1.W1(VSS_157) UC1.W2(VSS_159) UC1.W3(VSS_160) UC1.W4(VSS_69) UC1.W5(VSS_70) UC1.W12(VSS_158) UC1.W33(VSS_161) UC1.W34(VSS_162) UC1.Y7(VSS_77) UC1.Y8(VSS_78) UC1.Y9(VSS_79) UC1.Y10(VSS_71) UC1.Y11(VSS_72) UC1.Y13(VSS_73) UC1.Y14(VSS_74) UC1.Y37(VSS_75) UC1.Y38(VSS_76) UC3.3(GND) UC5.4(GND) UC5.9(THEMALPAD) UC6.4(GND) UD1.3(GND) UE1.A6(VSS1) UE1.A13(VSS2) UE1.C4(VSS_ANALOG) UE1.E6(VSS3) UE1.H4(VSS_ADC) UE3.3(GND) UE4.3(GND) UE5.3(GND) UE11.3(GND) UE12.15(VSS) UE12.29(EPAD) UH1.A2(VSS1) UH1.A3(VSS3) UH1.A4(VSS6) UH1.A5(VSS11) UH1.A8(VSS12) UH1.A28(VSS2) UH1.A33(VSS4) UH1.A37(VSS5) UH1.A45(VSS7) UH1.A46(VSS8) UH1.A47(VSS9) UH1.A48(VSS10) UH1.AA5(VSS21) UH1.AA19(VSS13) UH1.AA20(VSS14) UH1.AA25(VSS15) UH1.AA27(VSS16) UH1.AA28(VSS17) UH1.AA30(VSS18) UH1.AA31(VSS19) UH1.AA49(VSS20) UH1.AB19(VSS22) UH1.AB25(VSS23) UH1.AB31(VSS24) UH1.AC4(VSS29) UH1.AC12(VSS25) UH1.AC17(VSS26) UH1.AC33(VSS27) UH1.AC38(VSS28) UH1.AC46(VSS30) UH1.AD1(VSS31) UH1.AD2(VSS33) UH1.AD19(VSS32) UH1.AD22(VSS34) UH1.AD25(VSS35) UH1.AD49(VSS36) UH1.AE4(VSS40) UH1.AE12(VSS37) UH1.AE33(VSS38) UH1.AE38(VSS39) UH1.AE46(VSS41) UH1.AF22(VSS42) UH1.AF25(VSS43) UH1.AF28(VSS44) UH1.AG1(VSS45) UH1.AG22(VSS46) UH1.AG23(VSS47) UH1.AG25(VSS48) UH1.AG27(VSS49) UH1.AG28(VSS50) UH1.AG30(VSS51) UH1.AG49(VSS52) UH1.AH12(VSS53) UH1.AH17(VSS54) UH1.AH33(VSS55) UH1.AH38(VSS56) UH1.AJ19(VSS57) UH1.AJ20(VSS58) UH1.AJ25(VSS59) UH1.AJ27(VSS60) UH1.AJ28(VSS61) UH1.AJ30(VSS62) UH1.AJ31(VSS63) UH1.AK4(VSS71) UH1.AK19(VSS64) UH1.AK20(VSS65) UH1.AK25(VSS66) UH1.AK27(VSS67) UH1.AK28(VSS68) UH1.AK30(VSS69) UH1.AK31(VSS70) UH1.AK46(VSS72) UH1.AL12(VSS73) UH1.AL17(VSS74) UH1.AL21(VSS75) UH1.AL24(VSS76) UH1.AL26(VSS77) UH1.AL29(VSS78) UH1.AL33(VSS79) UH1.AL38(VSS80) UH1.AM1(VSS81) UH1.AM18(VSS82) UH1.AM32(VSS83) UH1.AM49(VSS84) UH1.AN12(VSS85) UH1.AN16(VSS86) UH1.AN34(VSS87) UH1.AN38(VSS88) UH1.AP4(VSS89) UH1.AP46(VSS90) UH1.AR12(VSS91) UH1.AR16(VSS92) UH1.AR34(VSS93) UH1.AR38(VSS94) UH1.AT1(VSS95) UH1.AT16(VSS96) UH1.AT18(VSS97) UH1.AT21(VSS98) UH1.AT24(VSS99) UH1.AT26(VSS100) UH1.AT29(VSS101) UH1.AT32(VSS102) UH1.AT34(VSS103) UH1.AT45(VSS104) UH1.AV11(VSS105) UH1.AV39(VSS106) UH1.AW4(VSS108) UH1.AW10(VSS107) UH1.AW40(VSS109) UH1.AW46(VSS110) UH1.B47(VSS111) UH1.B48(VSS112) UH1.B49(VSS113) UH1.BA5(VSS117) UH1.BA6(VSS118) UH1.BA12(VSS114) UH1.BA14(VSS115) UH1.BA44(VSS116) UH1.BB9(VSS121) UH1.BB41(VSS119) UH1.BB43(VSS120) UH1.BC8(VSS132) UH1.BC10(VSS122) UH1.BC13(VSS123) UH1.BC15(VSS124) UH1.BC19(VSS125) UH1.BC24(VSS126) UH1.BC26(VSS127) UH1.BC31(VSS128) UH1.BC35(VSS129) UH1.BC40(VSS130) UH1.BC45(VSS131) UH1.BD43(VSS133) UH1.BE44(VSS134) UH1.BF1(VSS135) UH1.BF2(VSS136) UH1.BF3(VSS137) UH1.BF48(VSS138) UH1.BF49(VSS139) UH1.BG2(VSS141) UH1.BG3(VSS145) UH1.BG4(VSS148) UH1.BG17(VSS140) UH1.BG22(VSS142) UH1.BG25(VSS143) UH1.BG28(VSS144) UH1.BG33(VSS146) UH1.BG37(VSS147) UH1.BG48(VSS149) UH1.C4(VSS153) UH1.C5(VSS155) UH1.C12(VSS150) UH1.C25(VSS151) UH1.C30(VSS152) UH1.C48(VSS154) UH1.D8(VSS161) UH1.D12(VSS156) UH1.D16(VSS157) UH1.D17(VSS158) UH1.D30(VSS159) UH1.D33(VSS160) UH1.E8(VSS175) UH1.E10(VSS162) UH1.E13(VSS163) UH1.E15(VSS164) UH1.E17(VSS165) UH1.E19(VSS166) UH1.E22(VSS167) UH1.E24(VSS168) UH1.E26(VSS169) UH1.E31(VSS170) UH1.E33(VSS171) UH1.E35(VSS172) UH1.E40(VSS173) UH1.E42(VSS174) UH1.F41(VSS176) UH1.F43(VSS177) UH1.F47(VSS178) UH1.G6(VSS180) UH1.G44(VSS179) UH1.H8(VSS181) UH1.J4(VSS185) UH1.J9(VSS190) UH1.J10(VSS182) UH1.J26(VSS183) UH1.J29(VSS184) UH1.J40(VSS186) UH1.J46(VSS187) UH1.J47(VSS188) UH1.J48(VSS189) UH1.K11(VSS191) UH1.K39(VSS192) UH1.M5(VSS200) UH1.M16(VSS193) UH1.M18(VSS194) UH1.M21(VSS195) UH1.M24(VSS196) UH1.M32(VSS197) UH1.M34(VSS198) UH1.M49(VSS199) UH1.N12(VSS201) UH1.N16(VSS202) UH1.N34(VSS203) UH1.N35(VSS204) UH1.N37(VSS205) UH1.N38(VSS206) UH1.P4(VSS209) UH1.P26(VSS207) UH1.P29(VSS208) UH1.P46(VSS210) UH1.R3(VSS215) UH1.R4(VSS218) UH1.R12(VSS211) UH1.R16(VSS212) UH1.R26(VSS213) UH1.R29(VSS214) UH1.R34(VSS216) UH1.R38(VSS217) UH1.T4(VSS222) UH1.T5(VSS224) UH1.T7(VSS225) UH1.T17(VSS219) UH1.T18(VSS220) UH1.T32(VSS221) UH1.T49(VSS223) UH1.U12(VSS226) UH1.U15(VSS227) UH1.U17(VSS228) UH1.U21(VSS229) UH1.U24(VSS230) UH1.U33(VSS231) UH1.U38(VSS232) UH1.V4(VSS235) UH1.V20(VSS233) UH1.V22(VSS234) UH1.V46(VSS236) UH1.W25(VSS237) UH1.W27(VSS238) UH1.W28(VSS239) UH1.W30(VSS240) UH1.Y9(VSS246) UH1.Y10(VSS241) UH1.Y12(VSS242) UH1.Y17(VSS243) UH1.Y33(VSS244) UH1.Y38(VSS245) UH7.3(GND) UI1.14(GND) UI1.17(THERMAL PAD) UI2.14(GND) UI2.17(THERMAL PAD) UI3.14(GND) UI3.17(THERMAL PAD) UI4.10(GND1) UI4.21(GND2) UI4.25(GPAD) UI5.10(GND1) UI5.21(GND2) UI5.25(GPAD) UL1.49(VSS_EPAD) UL2.3(G) UR1.13(GND) UR1.35(HG_SWREG_1) UR1.36(HG_SWREG_2) UR1.49(E-PAD) UR3.4(GND) UR4.5(GND) UT1.A1(PB_MONDC) UT1.A2(VSS_ANA87) UT1.A4(VSS_ANA53) UT1.A6(VSS_ANA1) UT1.A8(VSS_ANA2) UT1.A10(VSS_ANA3) UT1.A12(VSS_ANA4) UT1.A14(VSS_ANA5) UT1.A16(VSS_ANA6) UT1.A18(VSS_ANA7) UT1.A20(VSS_ANA8) UT1.A22(VSS_ANA9) UT1.A23(PA_MONDC) UT1.AA22(VSS_ANA114) UT1.AA23(VSS_ANA115) UT1.AB1(VSS_ANA65) UT1.AB2(VSS_ANA52) UT1.AB4(VSS_ANA60) UT1.AB6(VSS_ANA116) UT1.AB8(VSS_ANA117) UT1.AB10(VSS_ANA118) UT1.AB12(VSS_ANA119) UT1.AB14(VSS_ANA120) UT1.AB16(VSS_ANA121) UT1.AB18(VSS_ANA67) UT1.AB20(VSS_ANA68) UT1.AB22(VSS_ANA69) UT1.AC1(USB_MONDC) UT1.AC2(VSS_ANA66) UT1.AC4(VSS_ANA59) UT1.AC6(VSS_ANA70) UT1.AC8(VSS_ANA71) UT1.AC10(VSS_ANA72) UT1.AC12(VSS_ANA73) UT1.AC14(VSS_ANA74) UT1.AC16(VSS_ANA75) UT1.AC18(VSS_ANA76) UT1.AC20(VSS_ANA77) UT1.AC22(VSS_ANA78) UT1.AC23(PC_MONDC) UT1.B1(VSS_ANA85) UT1.B2(VSS_ANA84) UT1.B4(VSS_ANA54) UT1.B6(VSS_ANA10) UT1.B8(VSS_ANA11) UT1.B10(VSS_ANA12) UT1.B12(VSS_ANA13) UT1.B14(VSS_ANA14) UT1.B16(VSS_ANA15) UT1.B18(VSS_ANA16) UT1.B20(VSS_ANA17) UT1.B22(VSS_ANA18) UT1.C22(VSS_ANA49) UT1.C23(VSS_ANA103) UT1.D1(VSS_ANA86) UT1.D2(VSS_ANA57) UT1.D4(TEST_EDM) UT1.D5(MONDC_SVR) UT1.D6(VSS_ANA64) UT1.D8(VSS_ANA19) UT1.D9(VSS_ANA20) UT1.D11(VSS_ANA21) UT1.D12(VSS_ANA22) UT1.D13(VSS_ANA23) UT1.D15(VSS_ANA24) UT1.D16(VSS_ANA25) UT1.D18(VSS_ANA26) UT1.E4(VSS_ANA79) UT1.E9(VSS_ANA27) UT1.E11(VSS_ANA28) UT1.E12(VSS_ANA129) UT1.E13(VSS_ANA128) UT1.E15(VSS_ANA29) UT1.E18(VSS_ANA50) UT1.E22(VSS_ANA31) UT1.E23(VSS_ANA32) UT1.F1(VSS_ANA58) UT1.F2(VSS_ANA56) UT1.F4(VSS9) UT1.F5(VSS_ANA80) UT1.F6(VSS_ANA82) UT1.F8(VSS_ANA124) UT1.F9(VSS_ANA33) UT1.F11(VSS_ANA127) UT1.F12(VSS_ANA126) UT1.F13(VSS_ANA125) UT1.F15(VSS_ANA104) UT1.F16(VSS_ANA34) UT1.F20(VSS_ANA35) UT1.G22(VSS_ANA36) UT1.G23(VSS_ANA37) UT1.H1(SVR_VSS1) UT1.H20(VSS_ANA30) UT1.J1(SVR_VSS2) UT1.J2(SVR_VSS3) UT1.J12(VSS_ANA81) UT1.J15(VSS_ANA83) UT1.J16(VSS_ANA88) UT1.J19(VSS_ANA41) UT1.J20(VSS_ANA42) UT1.J22(VSS_ANA43) UT1.J23(VSS_ANA44) UT1.L8(FUSE_VQPS_64) UT1.L9(VSS7) UT1.L12(VSS3) UT1.L15(VSS11) UT1.L20(VSS_ANA38) UT1.L22(VSS_ANA39) UT1.L23(VSS_ANA40) UT1.M1(VSS13) UT1.M2(VSS14) UT1.M6(VSS_ANA92) UT1.M9(VSS8) UT1.M12(VSS19) UT1.M15(VSS1) UT1.M20(VSS_ANA45) UT1.N9(VSS18) UT1.N12(VSS15) UT1.N15(VSS12) UT1.N18(VSS_ANA123) UT1.N19(VSS_ANA122) UT1.N20(VSS_ANA46) UT1.N22(VSS_ANA47) UT1.N23(VSS_ANA48) UT1.R4(TEST_EN) UT1.R9(VSS5) UT1.R12(VSS6) UT1.R15(VSS4) UT1.R18(VSS_ANA100) UT1.R19(VSS_ANA99) UT1.R20(VSS_ANA98) UT1.R22(VSS_ANA97) UT1.R23(VSS_ANA96) UT1.T6(VSS16) UT1.T18(VSS17) UT1.T20(VSS_ANA95) UT1.U22(VSS_ANA94) UT1.U23(VSS_ANA93) UT1.V9(VSS_ANA105) UT1.V11(VSS_ANA91) UT1.V12(VSS_ANA90) UT1.V13(VSS_ANA89) UT1.V15(VSS_ANA106) UT1.V16(VSS2) UT1.V18(VSS10) UT1.V20(VSS_ANA107) UT1.W8(VSS_ANA108) UT1.W9(VSS_ANA109) UT1.W11(VSS_ANA101) UT1.W12(VSS_ANA63) UT1.W13(VSS_ANA51) UT1.W15(VSS_ANA130) UT1.W22(VSS_ANA110) UT1.W23(VSS_ANA111) UT1.Y5(VSS_ANA61) UT1.Y8(VSS_ANA55) UT1.Y9(VSS_ANA112) UT1.Y11(VSS_ANA102) UT1.Y12(VSS_ANA62) UT1.Y13(VSS_ANA113) UT1.Y15(VSS_ANA131) UT2.4(GND) UT5.D5(GND1) UT5.D6(GND2) UT5.D7(GND3) UT5.D8(GND4) UT5.E4(GND5) UT5.E5(GND6) UT5.E6(GND7) UT5.E7(GND8) UT5.E8(GND9) UT5.F4(GND10) UT5.F5(GND11) UT5.F6(GND12) UT5.F7(GND13) UT5.F8(GND14) UT5.G4(CSP_GND_P1) UT5.G5(CSP_GND_P2) UT5.G6(GND17) UT5.G7(GND18) UT5.H7(GND19) UT7.2(GND) UT9.4(GND) UT10.3(G) UT11.4(GND) UT12.3(G) UT32.2(GND) UT34.3(GND) UV8.11(GND1) UV8.19(GND2) UV8.52(GND3) UV8.61(PAD(GND)) UV24.2(GND) UV60.3(G) UV61.3(G) UV62.3(G) UV63.3(G) UV64.8(GND1) UV64.18(GND2) UV64.33(GND3) UV64.41(GND4) UV64.57(GND5) UV64.61(EPAD) UV65.3(GND) UV66.67(EPAD(GND)) UV67.67(EPAD(GND)) UV68.3(GND) UV69.3(GND) UZ6.3(GND) UZ7.5(GND1) UZ7.9(GND2) UZ9.11(GND) UZ9.15(GPAD) UZ10.3(GND) UZ12.9(GND1) UZ12.16(GND2) UZ12.23(GND3) UZ12.32(GND4) UZ12.33(PGND) UZ19.5(GND) UZ21.5(GND) UZ23.5(GND1) UZ23.9(GND2) UZ26.5(GND) UZ34.3(GND) UZ35.3(GND) UZ40.11(GND) UZ40.15(GPAD) UZ41.11(GND) UZ41.15(GPAD) UZ42.5(GND1) UZ42.9(GND2) UZ43.5(GND1) UZ43.9(GND2) UZ44.11(GND) UZ44.15(GPAD) UZ45.5(GND1) UZ45.9(GND2) UZ58.5(GND1) UZ58.9(GND2) UZ59.5(GND1) UZ59.9(GND2) UZ60.3(G) UZ61.3(GND) Y1.2(GND1) Y1.4(GND2) YH2.2(GND2) YH2.4(GND4) YT1.2(GND1) YT1.4(GND2)
GND_CHASSIS: CL22.2 RL15.2 RL16.2 RL17.2 RL18.2
GNDA: CA2.2 CA3.2 CA8.2 CA9.2 CA25.1 CA35.1 CA49.1 CA51.1 CA52.1 CA57.2 CA58.2 CA224.2 CA225.2 CA233.1 JHP1.7(GND1) JHP1.8(GND2) PJP19.1 RA44.1 RA221.2 RA222.2 RA223.2 RA226.2 RA227.2 RA228.2 UA1.22(AVSS2) UA1.37(AVSS1)
GNDA_CHG: PC709.2 PC711.1 PC712.1 PC718.1 PC720.2 PJP701.1 PR709.2 PR716.2 PR723.2 PU700.29(PWPD)
VBUS1_ACOK: PC2011.1 PQ2006.5(G1) PQ2006.6(D1) PR2024.1 PR2030.2 PU2001.1(O)
VBUS1_ACOK#: PQ2004.5(G1) PQ2006.3(D1) PR2025.1
VBUS1_ECOK: PQ2002.2(G1) PR17.2 PR74.1 PR2003.1 UE1.M6(GPIO016/GPTP-IN7/SHD_IO3/ICT3)
VBUS2_ACOK: PC2014.1 PQ2012.5(G1) PQ2012.6(D1) PR2028.1 PR2031.2 PU2001.7(O)
VBUS2_ACOK#: PQ2005.5(G1) PQ2012.3(D1) PR2029.1
VBUS2_ECOK: PQ2004.2(G1) PR38.2 PR75.1 PR2010.1 UE1.N3(GPIO021/LPCPD#)
VBUS3_ECOK: PQ2005.2(G1) PR53.2 PR76.1 PR2018.1 UE1.F13(GPIO121/PVT_IO0)
VBUS_C_CTRL_P1: PQ2008.6(D1) PR2063.2 PR2065.2
VBUS_C_CTRL_P1#: PD14.3(1) PQ2006.2(G1) PQ2008.2(G1) RT521.2 UT5.K4(VBUS_C_CTRL_P1)
VBUS_C_CTRL_P2: PQ2009.6(D1) PR2064.2 PR2066.2
VBUS_C_CTRL_P2#: PD15.3(1) PQ2009.2(G1) PQ2012.2(G1) RT522.2 UT5.B5(VBUS_C_CTRL_P2/ P4_1)
VCC_GT_SENSE: PR1124.1 PR1126.2 UC1.AH38(VCCGT_SENSE)
VCC_IO_SENSE: PR306.2 UC1.H14(VCCIO_SENSE)
VCC_SA_SENSE: PR1108.1 PR1111.2 UC1.M38(VCCSA_SENSE)
VCC_SENSE: PR1119.2 PR1121.1 RC221.2 UC1.AG37(VCC_SENSE)
VCCDSW_EN: CE66.1 RH445.1 UE1.M7(GPIO012/SMB07_DATA/TOUT3)
VCCDSW_EN_GPIO: DH1.2 QH6.2(G) RH431.1 RH445.2
VCCDSW_EN_Q: DH1.1 DH2.2 RH442.1
VCCMPHY_SENSE: PR810.2 T76.1 UH1.K47(VCCMPHY_SENSE)
VCCST_PWRGD: CC301.1 RC71.2 RC78.1 UE4.4(Y)
VCCST_PWRGD_CPU: RC78.2 UC1.H13(VCCST_PWRGD)
VCCST_PWRGD_EC: RE552.1 UE1.K10(GPIO114/PS2_CLK0A/NEC_SCI)
VCCSTG_EN: RZ120.1 UZ19.4(ON) UZ35.4(OUT)
VDD12_A: CV901.1 CV947.1 CV948.1 CV950.1 CV951.1 LV5.1 UV66.32(VDD12_1) UV66.56(VDD12_2)
VDD12_B: CV920.1 CV921.1 CV922.1 CV923.1 CV924.1 LV10.1 UV67.32(VDD12_1) UV67.56(VDD12_2)
VDD33_A: LV4.1 UV66.2(VDD33_1) UV66.29(VDD33_2)
VDD33_B: LV9.1 UV67.2(VDD33_1) UV67.29(VDD33_2)
VDD_1.2V: PC209.1 PR201.1 PR203.2 PU200.11(VDD)
VDDA12_A: CV916.1 CV917.1 CV918.1 CV919.1 LV8.1 UV66.43(VDDA12)
VDDA12_B: CV935.1 CV936.1 CV937.1 CV938.1 LV13.1 UV67.43(VDDA12)
VDDP_1.2V: PC206.1 PD200.1 PR204.1 PU200.12(VDDP)
VDDRX12_A: CV908.1 CV909.1 CV910.1 CV949.1 CV952.1 LV6.1 UV66.3(VDDRX12_1) UV66.24(VDDRX12_2)
VDDRX12_B: CV925.1 CV926.1 CV927.1 CV928.1 CV929.1 LV11.1 UV67.3(VDDRX12_1) UV67.24(VDDRX12_2)
VDDTX12_A: CV911.1 CV912.1 CV913.1 CV914.1 CV915.1 LV7.1 UV66.42(VDDTX12_1) UV66.55(VDDTX12_2)
VDDTX12_B: CV930.1 CV931.1 CV932.1 CV933.1 CV934.1 LV12.1 UV67.42(VDDTX12_1) UV67.55(VDDTX12_2)
VSS_A36: RC178.1 UC1.A36(VSS_A36)
VSS_A37: RC179.1 UC1.A37(VSS_A37)
VSS_GT_SENSE: PR1128.2 PR1129.1 UC1.AH37(VSSGT_SENSE)
VSS_IO_SENSE: PR310.2 UC1.J14(VSSIO_SENSE)
VSS_SA_SENSE: PR1100.2 PR1106.1 UC1.M37(VSSSA_SENSE)
VSS_SENSE: PR1122.1 PR1125.2 RC221.1 UC1.AG38(VSS_SENSE)
VSSMPHY_SENSE: PR811.2 T77.1 UH1.K46(VSSMPHY_SENSE)
32KHZ_OUT: CE54.1 UE1.F3(GPIO221/GPTP-IN3/32KHZ_OUT)
81215_ALERT: PR1115.1 PU1100.41(ALERT#)
81215_SCLK: PR1117.1 PU1100.42(SCLK)
81215_SDIO: PR1113.1 PU1100.40(SDIO)
81215_VR_HOT: PR1110.1 PU1100.39(VRHOT#)
+BL_PWR_SRC: CV840.1 CV841.1 CV849.2 FV1.2 JEDP1.1 JEDP1.2 JEDP1.3 JEDP1.4 RV907.1
+BL_PWR_SRC_F: CV15.1 CV839.2 FV1.1 QV1.1(D1) QV1.2(D2) QV1.5(D3) QV1.6(D4)
+CAMERA_VDD: CZ510.1 CZ511.1 CZ512.2 JEDP1.9 RZ550.2
+CAMERA_VDD_F: QZ1.1(D) RZ550.1
+COINCELL: JRTC1.1 PR61.1
+DCIN: PC707.1 PR705.2 PU700.28(VCC)
+DDR_VREF_B_DQ: CD87.1 RD31.1 UC1.BR13(DDR1_VREF_DQ)
+DDR_VREF_CA: CD25.1 RD9.1 RD10.1 UC1.BN13(DDR_VREF_CA)
+DGFF_PWR: PJP67.1 QZ19.5(D1) QZ19.6(D2) QZ19.7(D3) QZ19.8(D4)
+DGFF_PWR_SRC: CZ525.1 CZ545.1 JDG1.1 JDG1.2 JDG1.3 PJP67.2 RZ513.1
+DGFF_SRC_EN#: CZ526.2 QZ19.4(G) RZ512.2 RZ514.1
+DIMM_DQ_R_VREF_B: CD88.1 CD89.1 CD90.1 RD30.2 RD31.2 RD32.1 RD84.2
+EC_DEBUG_VCC: JDEG1.1 RE71.2
+EDP_VDD: PJP12.2 UV24.1(VOUT)
+IR_F: FZ2.1 JIR1.5 JIR1.6
+LCDVDD: CV16.1 CV20.1 CV851.2 CV852.1 CV853.1 JEDP1.6 JEDP1.7 JEDP1.8 PJP12.1 RV7.1 RV843.1 RV910.1
+MIC2-VREFO-L: RA5.1 UA1.28(MIC2-VREFO-L)
+MIC2-VREFO-R: RA6.1 UA1.29(MIC2-VREFO-R)
+PECI_VREF: CE25.1 RE59.2 UE1.J11(GPIO044/VREF_VTT)
+PWR_SRC_R: JUSH1.26 RZ85.2
+REGCTL_PNP10: LL1.1 UL1.7(CTRL0P9)
+RSVD_VCC3P3_2: RL6.2 UL1.1(RSVD1_VCC3P3)
+RTC_CELL: PC24.1 PD8.1 QE15.3(S) RA213.2 RE31.1 RE32.2 RE507.2 RE508.2 RE551.2 RE750.2
+RTC_CELL_PCH: CE63.1 QE15.1(D) RE546.1 RE551.1 RH198.1 RH200.1 RH201.1 RH297.1
+RTC_CELL_VBAT: CE11.1 RE32.1 UE1.A2(VBAT)
+SIM_PWR: CZ37.1 JNGFF2.28 JSIM1.8(VCC)
+TBT_SVR_IND: LT10.1 UT1.K1(SVR_IND1) UT1.K2(SVR_IND2) UT1.L1(SVR_IND3) UT1.L2(SVR_IND4)
+TRM_CT1: CL16.1 TL1.3(TDCT1)
+TRM_CT2: CL17.1 TL1.4(TDCT2)
+TRM_CT3: CL20.1 TL1.9(TDCT3)
+TRM_CT4: CL21.1 TL1.10(TDCT4)
+USB2_REPEATER_VDD: CI60.1 CI61.1 PJP27.1 RI62.1 RI63.1 RI64.1 RI65.1 RI66.1 RI69.1 RI72.1 RI73.1 RI74.1 RI94.1 UI4.1(VDD1) UI4.13(VDD2)
+USB3_REPEATER_VDD: CI68.1 CI69.1 PJP28.1 RI78.1 RI80.1 RI81.1 RI83.1 RI85.1 RI86.1 RI88.1 RI89.1 RI90.1 RI95.1 UI5.1(VDD1) UI5.13(VDD2)
+UZ12_TPM: CZ50.1 CZ75.1 RZ89.2 RZ367.2 UZ12.8(VDD1)
+UZ12_VHIO: CZ53.1 CZ54.1 CZ55.1 RZ365.1 RZ366.1 UZ12.14(VHIO1) UZ12.22(VHIO2)
+V_DDR_REF: PC208.1 PU200.4(VTTREF)
+V_DDR_REFCA_A: CD26.1 CD28.1 CD29.1 CD60.1 CD61.1 JDIMM1.164(VREFCA) JDIMM2.164(VREFCA) RD8.2 RD10.2 RD11.1
+V_DDR_REFCA_B: CD94.1 CD95.1 CD97.1 CD125.1 CD126.1 JDIMM3.164(VREFCA) JDIMM4.164(VREFCA) RD9.2 RD36.1 RD84.1
+VR_CAP: CE31.1 UE1.C10(VIN) UE1.J1(VR_CAP)
+VSYS: CT347.1 CT349.1 RT512.1 RT569.1 UT5.A5(VSYS)
A_CHIP_ID0: RE566.2 RE568.1 UE12.10(CHIP_ID0)
A_CHIP_ID1: RE565.2 RE567.1 UE12.23(CHIP_ID1)
AC_DIS: PD14.2 PD15.2 PQ1.2(G1) PR2163.2 RE83.1 UE1.H12(GPIO134/PWM10/UART1_RTS#)
AC_DISC#: PC2003.2 PQ2.5(G2) PQ5.2(G1) PQ8.2(G1) PQ2002.6(D1) PQ2003.5(G1) PQ2003.6(D1) PQ2004.6(D1) PQ2005.6(D1) PR2005.1 UE1.E13(GPIO124/GPTP-OUT6/PVT_CS#)
AC_PRESENT: RH243.1 UE1.K8(GPIO233) UH1.BG42(GPD1/ACPRESENT)
ACAV_IN: DZ12.1 PR713.1 UE1.C7(GPIO164/VCI_OVRD_IN) UV68.1(\\O\E)
ACDET_CHG: PC709.1 PR706.1 PR709.1 PU700.6(ACDET)
ACOK_CHG: PR712.2 PR713.2 PR716.1 PU700.5(ACOK)
ALW_PWRGD_3V_5V: DH2.1 PR102.2 PR103.2 QT1.2(G) RT550.1 UZ6.2(IN2)
ALW_PWRGD_3VR_5VR: PR508.2 PR509.2
ALWON: PR113.1 PR505.1 UE1.A5(VCI_OUT)
AR_DET#: RH400.1 RH401.1 UH1.BB16(GPP_D11/ISH_SPI_MISO/GP_BSSB_CL)
AUD_AZACPU_SCLK: RH38.1 UC1.G27(PROC_AUDIO_CLK)
AUD_AZACPU_SCLK_R: RH38.2 UH1.AM3(HDACPU_SCLK)
AUD_AZACPU_SDI: RC66.1 UC1.G29(PROC_AUDIO_SDO)
AUD_AZACPU_SDI_R: RC66.2 UH1.AN3(HDACPU_SDI)
AUD_AZACPU_SDO: RH39.1 UC1.G25(PROC_AUDIO_SDI)
AUD_AZACPU_SDO_R: RH39.2 UH1.AM2(HDACPU_SDO)
AUD_HP_NB_SENSE: CA41.1 DA2.3 JHP1.6 QA10.2(G) RA220.1
AUD_HP_OUT_L: LA15.1 RA7.1
AUD_HP_OUT_L1: CA3.1 DA1.3 JHP1.1 LA15.2
AUD_HP_OUT_R: LA16.1 RA8.1
AUD_HP_OUT_R1: CA2.1 DA1.2 JHP1.2 LA16.2
AUD_PC_BEEP: CA27.2 CA28.2 UA1.34(PCBEEP)
AUD_SENSE_A: QA10.1(D) UA1.48(JD1)
AUX_EN_WOWL: DZ9.2 RZ70.1 RZ379.2 UE1.D3(GPIO210/ADC08)
BARREL_DISC: PC2106.1 PR2148.2 PR2149.2 PU2004.1(O) UE1.E7(GPIO003/SMB00_DATA/SPI0_CS#)
BAT1_LED#: RZ28.1 UE1.D10(GPIO157/LED1)
BAT1_LED#_R: QZ3.2(B) QZ22.1(COLLECTOR)
BAT2_LED#: RZ361.1 UE1.D11(GPIO153/LED2)
BATDRV: PR701.1 PU700.18(BATDRV)
BATDRV_GATE: PC725.1 PD11.3(1) PD12.3(1) PD13.3(1) PQ701.4(G) PR701.2
BATSRC: PR735.1 PU700.17(BATSRC)
BATT_WHITE#: JLED1.3 RZ361.2
BATT_YELLOW#: JLED1.2(2        2) QZ3.3(E) RZ28.2
BBS_BIT6: RH311.2 UH1.BA26(GPP_B22/GSPI1_MOSI)
BC_CLK_ECE1117: JKBTP1.10(10     10) UE1.D13(GPIO047/BCM1_CLK)
BC_DAT_ECE1117: JKBTP1.8(8        8) RE365.1 UE1.D12(GPIO046/BCM1_DAT)
BC_INT#_ECE1117: JKBTP1.7 UE1.E2(GPIO212/ADC10)
BCM5882_ALERT#: JUSH1.14 RE532.2 UE1.G10(GPIO135/UART1_CTS#)
BEEP: RA13.2 UE1.H11(GPIO035/PWM8/CTOUT1)
BEEP_R: CA28.1 CA227.1 RA13.1 RA209.1
BGPO0: RE749.1 UE1.D6(BGPO0)
BIA_PWM: DV38.1 DV39.1 DV40.1 LV1.2 RV839.1
BIA_PWM_EC: DV40.2 UE1.N1(GPIO001/PWM4)
BIA_PWM_PCH: DV38.2 UH1.AU48(GPP_F21/EDP_BKLTCTL)
BIOS_REC: RH76.2 UH1.AR42(GPP_F10/SATA_SCLOCK)
BL_PWR_SRC_ON: CV13.2 CV14.1 QV1.3(G) RV4.2 RV5.1
BOARD_ID: CE40.1 RE79.2 UE1.J13(GPIO036/RC_ID2/SPI0_MISO)
BQ24780_REGN: PC706.1 PD702.1 PR712.1 PU700.24(REGN)
BREATH_LED#: QZ7.3(S) UE1.C11(GPIO156/LED0)
BREATH_LED#_Q: QZ7.1(D) RZ32.1
BREATH_LED#_R: JPB1.4 RZ32.2
BST_1.2V: PR200.2 PU200.18(BOOT)
BST_1.2V_R: PC201.2 PR200.1
BST_3V: PR101.1 PU100.1(BS)
BST_3VR: PR514.1 PU501.1(BS)
BST_5V: PR111.1 PU101.1(BS)
