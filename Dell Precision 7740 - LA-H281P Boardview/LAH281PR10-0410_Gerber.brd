# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 250.96,43.63 250.96,42.86 251.15,42.67 252,42.67 252.01,42.67 252.75,42.67 253,42.42 253,40.83 252.86,40.7 251.86,40.7 251.62,40.94 251.38,40.94 251.37,40.94 250.58,40.94 249.57,39.93 249.57,38.25 249.61,38.21 251.47,38.21 251.68,38.42 251.68,38.71 251.78,38.82 252.41,38.82 252.41,38.82 252.64,38.82 252.64,38.83 253.03,38.83 253.06,38.79 253.06,37.8 252.97,37.71 252.01,37.71 252,37.7 251.95,37.7 251.95,37.66 251.3,37 249.8,37 249.48,37.32 241.02,37.32 240.97,37.26 240.76,37.26 240.67,37.3 240.63,37.38 240.59,37.52 240.49,37.63 240.49,37.77 240.7,37.98 240.89,37.98 241.01,38.1 241.04,38.1 241.27,38.22 241.34,38.47 241.37,38.57 241.46,38.61 241.56,38.61 241.98,39.03 241.98,39.83 242.22,40.07 244.5,40.07 244.61,39.96 244.61,38.93 244.86,38.68 246.97,38.68 247.24,38.94 247.24,42.74 247.22,42.76 247.22,43.85 247.39,44.02 250.57,44.02
GND on BOTTOM (solid shape): 28.73,60.59 28.73,58.99 29.03,58.69 32.08,58.69 32.2,58.56 32.2,57.77 32.17,57.71 32.1,57.72 32.02,57.8 31.32,57.8 31.13,57.75 30.99,57.62 30.15,57.62 30.15,57.55 29.16,57.55 28.9,57.29 28.9,55.61 28.64,55.61 28.63,55.66 28.1,55.83 28.06,55.27 28.1,55.17 28.06,55.08 28.02,55.05 28,55.01 27.93,54.96 27.85,54.96 27.66,54.98 27.48,54.89 27.12,54.89 26.83,55.18 26.83,55.91 26.9,55.98 26.91,55.99 26.93,56.01 26.93,56.03 27.18,56.28 27.18,60.64 27.43,60.9 28.22,60.9 28.22,60.9 28.42,60.9
GND on BOTTOM (solid shape): 69.26,45.35 72.04,45.35 72.13,45.26 72.13,44.78 71.88,44.52 71.88,44.22 71.82,44.12 71.7,44.11 71.3,44.03 71.23,43.63 71.22,43.51 71.12,43.45 71.01,43.45 70.95,43.49 70.96,43.55 70.73,44.13 70.36,43.63 70.36,43.51 70.25,43.45 68.53,43.45 68.02,43.96 68.02,44.21 68.53,44.72 68.53,45.48 68.65,45.61 69,45.61
GND on BOTTOM (solid shape): 190.29,48.8 190.4,48.73 190.38,48.59 190.3,48.51 190.28,48.52 190.04,47.97 190.58,48.21 190.58,48.24 190.73,48.39 191.01,48.39 191.11,48.34 191.13,48.23 191.19,47.94 191.45,47.82 191.48,47.82 192.01,47.3 192.02,47.22 191.94,47.19 191.92,47.2 189.14,47.2 188.57,47.42 188.51,47.42 188.45,47.46 188.46,47.53 188.51,47.58 188.51,47.89 188.41,47.99 189.22,48.8
GND on BOTTOM (solid shape): 191.8,53.1 191.92,53.02 191.89,52.89 191.75,52.75 191.75,52.29 192.05,51.99 192.56,51.99 193.05,52.48 194.3,52.48 194.43,52.34 194.43,51.56 194.6,51.39 194.63,51.34 194.65,51.3 194.68,51.22 194.59,50.98 194.65,50.8 194.68,50.76 194.6,50.67 194.1,51.18 190.91,51.18 190.59,51.5 190.58,51.56 190.64,51.6 190.74,51.6 190.85,51.71 190.86,51.71 191.08,52.17 190.58,52.26 190.49,52.22 190.4,52.26 190.35,52.29 190.3,52.32 190.22,52.41 190.25,52.53 190.41,52.68 190.41,53.1
GND on BOTTOM (solid shape): outline of 93 points within 391.18,13.67 399.07,20.89
GND on BOTTOM (solid shape): 191.67,38.74 192.51,38.74 192.63,38.66 192.6,38.52 192.57,38.49 192.55,38.45 192.46,38.39 192.35,38.43 192.33,38.45 192.17,38.45 191.75,38.58 191.6,38.17 191.59,38.05 191.48,37.99 191.11,37.99 191.01,38.04 190.99,38.16 190.96,38.44 190.72,38.59 190.62,38.67 190.65,38.8 190.78,38.93 190.78,39.28 190.65,39.41 190.62,39.55 190.72,39.63 190.77,39.64
GND on BOTTOM (solid shape): outline of 100 points within 138.32,94.23 143.46,101.1
GND on BOTTOM (solid shape): 180.59,53.79 180.95,53.79 181.04,53.73 181.15,53.7 182.24,53.7 182.36,53.63 182.33,53.49 182.22,53.38 182.22,52.05 182.29,51.98 182.32,51.84 182.2,51.76 181.13,51.76 181.13,52.04 181.5,52.41 181.5,52.97 180.86,53.6 180.41,53.6 179.91,53.11 178.81,53.11 178.36,53.55 178.36,53.67 178.47,53.82 178.47,54.02 178.49,54.13 178.59,54.18 179.08,54.18 179.25,54.02 179.24,53.99 179.79,53.76 179.55,54.3 179.52,54.3 179.43,54.39 179.42,54.46 179.47,54.5 179.89,54.5
GND on BOTTOM (solid shape): 191.67,38.74 192.51,38.74 192.63,38.66 192.6,38.52 192.58,38.49 192.56,38.46 192.46,38.4 192.36,38.44 192.34,38.46 192.16,38.46 191.75,38.57 191.59,38.17 191.58,38.05 191.48,38 191.11,38 191.01,38.05 190.99,38.17 190.96,38.44 190.72,38.59 190.62,38.67 190.65,38.8 190.73,38.88 190.76,38.94 190.78,39 190.78,39.28 190.65,39.41 190.62,39.55 190.72,39.63 190.77,39.64
GND on BOTTOM (solid shape): 175.95,28.13 177.95,28.13 178.17,27.91 178.17,27.68 178.15,27.67 178.06,27.67 178.04,27.69 177.64,27.78 177.49,27.39 177.47,27.28 177.37,27.22 177.11,27.22 176.9,27.43 176.9,27.47 176.66,27.82 176.29,27.61 176.2,27.53 176.08,27.57 175.74,27.9 174.62,27.9 174.52,27.98 174.39,28.01 172.94,28.01 172.85,28.05 172.81,28.14 172.81,28.33 172.85,28.42 172.94,28.46 172.95,28.45 174.39,28.45 174.59,28.53 174.67,28.72 174.67,28.74 174.72,28.79 175.29,28.79
GND on BOTTOM (solid shape): outline of 106 points within 144.03,96.45 151.93,99.53
GND on BOTTOM (solid shape): 175.96,59.32 176.07,59.35 176.17,59.29 176.23,59.2 176.33,59.14 176.34,59.13 177.11,58.37 178.96,58.37 179.04,58.29 179.05,58.22 178.99,58.18 178.1,58.18 177.84,57.92 177.84,57.49 178.04,57.29 178.07,57.2 178.03,57.11 177.99,57.07 177.96,57.03 177.71,56.78 177.71,56.22 177.8,56.14 177.81,56.07 177.75,56.03 175.76,56.03 175.76,56.52 175.41,56.87 175.41,57.23 175.69,57.5 176.35,57.5 176.51,57.35 176.51,57.3 176.47,57.21 176.37,57.18 176.03,56.74 176.58,56.67 176.58,56.67 176.9,56.99 176.9,57.51 176.51,57.89 175.72,57.89 175.61,57.97 175.63,58.11 175.93,58.4 175.93,59.28
GND on BOTTOM (solid shape): 4.15,13.4 4.45,13.14 4.83,13.05 5.23,13.14 5.54,13.4 11.75,13.4 11.75,0.2 11.55,0.2 10.28,0.73 9.75,2 9.75,4.3 9.4,5.15 8.55,5.5 6.55,5.5 5.99,5.74 5.75,6.3 5.75,7 5.41,7.84 4.57,8.2 2.7,8.2 2.7,13.4
GND on BOTTOM (solid shape): 159.01,120.92 159.01,117.77 158.96,117.72 158.86,117.72 158.82,117.68 158.82,116.95 158.48,116.61 158,116.41 158.49,116.24 158.66,116.24 158.78,116.12 158.78,115.6 158.63,115.46 158.56,115.46 158.49,115.47 158.42,115.46 158.06,115.46 157.99,115.47 157.92,115.46 157.56,115.46 157.49,115.47 157.42,115.46 157.06,115.46 156.99,115.47 156.92,115.46 156.56,115.46 156.49,115.47 156.42,115.46 156.06,115.46 155.99,115.47 155.92,115.46 155.56,115.46 155.49,115.47 155.42,115.46 155.06,115.46 154.99,115.47 154.92,115.46 154.56,115.46 154.49,115.47 154.42,115.46 154.27,115.46 154.27,115.58 154.16,115.69 154.16,116.12 154.21,116.13 154.3,116.17 154.37,116.23 154.8,116.66 156.76,116.66 157.5,117.41 157.5,120.87 157.74,121.11 158.82,121.11
GND on BOTTOM (solid shape): outline of 121 points within 166.67,25.75 172.53,39.16
GND on BOTTOM (solid shape): 193.63,68.17 193.73,68.1 193.94,67.67 194.17,67.44 194.17,67.07 194.18,67.06 194.2,66.92 194.09,66.84 193.58,66.84 193.18,66.97 192.99,66.6 192.97,66.5 192.87,66.45 192.47,66.45 192.36,66.56 192.36,66.59 191.82,66.86 192.09,66.32 192.12,66.33 192.17,66.28 192.18,66.22 192.12,66.18 191.17,66.18 191.06,66.25 191.08,66.39 191.05,66.86 190.58,66.78 190.53,66.78 190.41,66.86 190.44,67 190.81,67.37 192.78,67.37 193.45,68.03 193.45,68.07 193.49,68.1 193.52,68.13
GND on BOTTOM (solid shape): outline of 142 points within 115.35,103.05 118.97,106.38
GND on BOTTOM (solid shape): 408.1,15.79 408.15,15.79 408.15,10.3 407.62,9.03 406.35,8.5 398.86,8.5 397.3,7.86 396.66,6.3 396.66,2 396.13,0.73 394.86,0.2 391.54,0.2 390.68,0.55 390.24,0.83 389.91,1.18 389.74,1.59 389.58,1.92 389.07,2.28 388.34,2.22 388.01,2.15 387.12,1.49 385.81,1.5 385.81,6.03 385.87,6.09 386.34,6.09 387.34,5.09 391.01,5.09 392.25,4.73 393.49,5.09 395.42,5.09 396.15,5.82 396.15,6.3 396.94,8.22 398.86,9.01 405.89,9.01 407.65,11.14 407.65,15.8 408.1,15.8
GND on BOTTOM (solid shape): 176.18,32.94 176.61,32.94 176.72,32.88 176.73,32.44 177.01,32.28 177.05,32.26 177.07,32.22 177.07,32.02 177.49,31.6 179.25,31.6 180.11,32.46 180.25,32.49 180.32,32.37 180.32,32.21 179.22,31.1 179.18,31.13 178.77,31.08 178.76,30.67 178.77,30.54 178.65,30.47 178.36,30.47 178.04,30.79 178.04,30.82 177.5,31.09 177.77,30.55 177.8,30.55 178.06,30.3 178.08,30.16 177.97,30.08 176.88,30.08 176.57,30.39 176.54,30.5 176.6,30.59 176.76,30.97 176.41,31.19 176.38,31.18 175.16,32.4 174.62,32.4 174.52,32.48 174.39,32.51 172.95,32.51 172.94,32.51 172.85,32.55 172.81,32.64 172.81,32.83 172.85,32.92 172.94,32.96 174.39,32.96 174.6,33.04 174.67,33.26 174.67,33.29 174.94,33.55 175.57,33.55
GND on BOTTOM (solid shape): outline of 186 points within 163.08,117.08 166.64,121.65
GND on BOTTOM (solid shape): outline of 185 points within 187.96,49.61 191.56,53.08
GND on BOTTOM (solid shape): 180.87,28.05 180.87,27.98 180.87,27.91 179.34,26.37 179.34,26.04 179.3,26.01 179.26,25.97 179.16,25.92 179.06,25.97 178.52,25.88 178.86,25.45 178.89,25.46 178.95,25.4 178.98,25.26 178.86,25.18 177.81,25.18 177.12,24.49 177.09,24.5 176.89,24.46 176.75,24.3 176.73,24.26 176.63,24.26 176.63,24.27 176.63,24.44 175.17,25.9 174.62,25.9 174.52,25.98 174.39,26.01 172.94,26.01 172.85,26.05 172.81,26.14 172.81,26.33 172.85,26.42 172.94,26.46 172.95,26.45 174.39,26.45 174.52,26.49 174.62,26.57 175.21,26.57 175.8,25.97 175.78,25.93 176.13,25.46 176.2,26.05 176.2,26.05 175.35,26.9 174.62,26.9 174.52,26.98 174.39,27.01 172.95,27.01 172.94,27.01 172.85,27.05 172.81,27.14 172.81,27.33 172.85,27.42 172.94,27.46 174.39,27.46 174.52,27.49 174.62,27.57 175.61,27.57 177.2,25.97 177.17,25.93 177.53,25.46 177.6,26.05 177.59,26.05 176.51,27.13 176.58,27.19 176.66,27.2 176.97,26.89 179.59,26.89 180.8,28.11
GND on BOTTOM (solid shape): 180.82,43.79 180.88,43.75 180.86,43.68 180.82,43.64 180.82,43.36 180.97,43.21 180.91,43.14 180.54,42.78 178.9,42.78 177.57,41.45 177.54,41.45 177.18,41.16 177.48,40.82 177.51,40.82 177.57,40.76 177.51,40.69 176.52,40.69 176.5,40.68 176.47,40.68 176.41,40.69 176.35,40.68 176.28,40.72 176.31,40.8 176.13,41.4 176.11,40.77 176.2,40.69 176.18,40.57 176.15,40.52 176.05,40.45 175.94,40.48 175.19,41.24 175.16,41.38 175.28,41.46 175.72,41.46 176.09,41.83 176.12,41.82 176.44,42.04 176.31,42.41 176.26,42.5 176.29,42.6 176.38,42.69 176.38,43.13 176.23,43.28 176.2,43.41 176.32,43.49 176.73,43.49 177.43,42.79 177.43,42.53 177.41,42.48 177.37,42.46 177.19,41.91 177.72,42.16 177.72,42.19 177.82,42.29 177.82,42.95 177.65,43.12 177.62,43.26 177.74,43.34 180.15,43.34 180.6,43.79
GND on BOTTOM (solid shape): 20.66,34.47 20.75,34.44 20.76,34.43 20.81,34.36 20.8,34.28 20.79,34.14 20.84,34.01 20.88,33.93 20.84,33.84 21.04,33.42 21.23,33.84 21.2,33.93 21.23,34.01 21.26,34.04 21.28,34.09 21.34,34.16 21.44,34.16 21.55,34.13 21.67,34.14 21.75,34.13 21.81,34.07 21.83,34.02 21.83,33.83 21.82,33.81 21.78,33.67 21.82,33.54 21.83,33.52 21.83,33.33 21.82,33.31 21.78,33.17 21.82,33.04 21.83,33.02 21.83,32.83 21.82,32.81 21.8,32.76 21.78,32.7 21.73,32.61 21.63,32.6 21.23,32.43 21.28,32 21.3,31.96 21.28,31.91 21.2,31.77 21.19,31.6 21.16,31.5 21.06,31.45 19.21,31.45 18.87,31.78 18.87,31.8 18.78,31.95 18.62,32.04 18.61,32.05 18.26,32.4 18.26,32.55 18.26,32.56 18.29,32.67 18.26,32.79 18.26,32.8 18.26,33.05 18.26,33.06 18.28,33.11 18.29,33.17 18.34,33.27 18.45,33.29 18.8,33.4 18.87,33.76 18.89,33.88 19.01,33.92 19.11,33.93 19.2,33.98 19.29,34.01 19.54,33.92 19.79,34.01 19.87,33.98 20.13,33.94 20.29,34.15 20.29,34.18 20.5,34.38 20.54,34.41 20.58,34.44
GND on BOTTOM (solid shape): outline of 87 points within 124.51,102.66 131.7,107.24
GND on BOTTOM (solid shape): outline of 377 points within 222.53,29.87 230.7,36.08
GND on BOTTOM (solid shape): outline of 386 points within 222.87,61.04 232.8,65.92
GND on BOTTOM (solid shape): outline of 117 points within 174.58,48.68 181.11,54.18
GND on BOTTOM (solid shape): outline of 480 points within 108.85,103.71 119.9,115.01
GND on BOTTOM (solid shape): outline of 87 points within 153.03,28.31 408.16,176.9
GND on BOTTOM (solid shape): outline of 1028 points within 148.99,103.79 159.42,113.03
GND on BOTTOM (solid shape): outline of 240 points within 0.2,0 364.2,177.9
GND on BOTTOM (solid shape): outline of 3513 points within 31.16,41.59 43.28,52.82
GND on IN1 (solid shape): 289.09,38.35 289.09,35.3 288.43,34.64 286.19,34.64 285.25,35.58 285.25,38.55 285.89,39.19 288.24,39.19
GND on IN1 (solid shape): 129.45,175.35 138.44,175.35 138.44,169.09 137.88,168.53 137.17,168.53 136.77,168.92 130.24,168.92 128.95,167.63 128.95,164.98 127.25,163.29 125.83,163.29 125.36,163.76 125.36,165.46 125.6,165.7 126.53,165.7 127.22,166.28 126.77,167.06 126.73,167.07 126.73,177.9 129.45,177.9
GND on IN1 (solid shape): 408.1,15.79 408.15,15.79 408.15,10.3 407.62,9.03 406.35,8.5 398.86,8.5 397.3,7.86 396.66,6.3 396.66,2 396.13,0.73 394.86,0.2 391.54,0.2 390.68,0.55 390.24,0.83 389.91,1.18 389.74,1.59 389.58,1.92 389.07,2.28 388.34,2.22 388.01,2.15 387.12,1.49 385.81,1.5 385.81,6.03 385.87,6.09 386.34,6.09 387.34,5.09 391.01,5.09 392.25,4.73 393.49,5.09 395.42,5.09 396.15,5.82 396.15,6.3 396.94,8.22 398.86,9.01 405.89,9.01 407.65,11.14 407.65,15.8 408.1,15.8
GND on IN1 (solid shape): outline of 81 points within 152.89,28.32 408.16,176.9
GND on IN1 (solid shape): outline of 1082 points within 0.2,0.2 364.2,177.9
GND on IN2 (solid shape): 129.46,175.35 138.44,175.35 138.44,169.09 137.88,168.53 137.17,168.53 136.77,168.92 130.24,168.92 128.95,167.63 128.95,164.98 127.3,163.33 125.88,163.33 125.22,163.98 125.22,165.7 126.53,165.7 127.22,166.28 126.77,167.06 126.73,167.07 126.73,177.9 129.46,177.9
GND on IN2 (solid shape): 408.1,15.79 408.15,15.79 408.15,10.3 407.62,9.03 406.35,8.5 398.86,8.5 397.3,7.86 396.66,6.3 396.66,2 396.13,0.73 394.86,0.2 391.54,0.2 390.68,0.55 390.24,0.83 389.91,1.18 389.74,1.59 389.58,1.92 389.07,2.28 388.34,2.22 388.01,2.15 387.12,1.49 385.81,1.5 385.81,6.03 385.87,6.09 386.34,6.09 387.34,5.09 391.01,5.09 392.25,4.73 393.49,5.09 395.42,5.09 396.15,5.82 396.15,6.3 396.94,8.22 398.86,9.01 405.89,9.01 407.65,11.14 407.65,15.8 408.1,15.8
GND on IN2 (solid shape): outline of 83 points within 152.95,28.32 408.16,176.9
GND on IN2 (solid shape): outline of 211 points within 0.2,0.2 364.2,177.9
GND on IN3 (solid shape): 129.46,175.35 138.44,175.35 138.44,169.09 137.88,168.53 137.17,168.53 136.77,168.92 130.24,168.92 128.95,167.63 128.95,164.98 127.08,163.12 125.57,163.12 124.39,164.3 124.39,165.7 126.53,165.7 127.22,166.28 126.77,167.06 126.73,167.07 126.73,177.9 129.46,177.9
GND on IN3 (solid shape): 408.1,15.79 408.15,15.79 408.15,10.3 407.62,9.03 406.35,8.5 398.86,8.5 397.3,7.86 396.66,6.3 396.66,2 396.13,0.73 394.86,0.2 391.54,0.2 390.68,0.55 390.24,0.83 389.91,1.18 389.74,1.59 389.58,1.92 389.07,2.28 388.34,2.22 388.01,2.15 387.12,1.49 385.81,1.5 385.81,6.03 385.87,6.09 386.34,6.09 387.34,5.09 391.01,5.09 392.25,4.73 393.49,5.09 395.42,5.09 396.15,5.82 396.15,6.3 396.94,8.22 398.86,9.01 405.89,9.01 407.65,11.14 407.65,15.8 408.1,15.8
GND on IN3 (solid shape): outline of 84 points within 153.03,28.32 408.16,176.9
GND on IN3 (solid shape): outline of 204 points within 0.2,0.2 364.2,177.9
GND on IN4 (solid shape): 129.46,175.35 138.44,175.35 138.44,169.09 137.88,168.53 137.17,168.53 136.77,168.92 130.24,168.92 128.95,167.63 128.95,164.98 127.08,163.12 126.01,163.12 125.35,163.78 125.35,165.38 125.66,165.7 126.53,165.7 127.22,166.28 126.77,167.06 126.73,167.07 126.73,177.9 129.46,177.9
GND on IN4 (solid shape): 408.1,15.79 408.15,15.79 408.15,10.3 407.62,9.03 406.35,8.5 398.86,8.5 397.3,7.86 396.66,6.3 396.66,2 396.13,0.73 394.86,0.2 391.54,0.2 390.68,0.55 390.24,0.83 389.91,1.18 389.74,1.59 389.58,1.92 389.07,2.28 388.34,2.22 388.01,2.15 387.12,1.49 385.81,1.5 385.81,6.03 385.87,6.09 386.34,6.09 387.34,5.09 391.01,5.09 392.25,4.73 393.49,5.09 395.42,5.09 396.15,5.82 396.15,6.3 396.94,8.22 398.86,9.01 405.89,9.01 407.65,11.14 407.65,15.8 408.1,15.8
GND on IN4 (solid shape): outline of 84 points within 153.05,28.32 408.16,176.9
GND on IN4 (solid shape): outline of 1310 points within 0.2,0.2 364.2,177.9
GND on TOP: 112.06,40.32 111.92,40.46 111.92,41.25 111.68,41.49 111.68,44.44 111.86,44.62 114.88,44.62 115.19,44.31 115.19,44.12 115.18,44.11 115.15,43.96 115.18,43.81 115.19,43.8 115.19,42.72 115.05,42.45 115.19,42.17 115.19,41.48 114.96,41.26 114.96,41.19 114.17,40.4 113.82,40.4 113.49,40.57 113.19,40.36 113.17,40.32
GND on TOP: 262.04,70.64 261.81,70.41 261.81,68.38 261.85,68.34 264.19,68.34 264.58,68.73 264.58,70.38 264.33,70.64
GND on TOP: 274.42,68.67 275.37,68.67 275.7,69.01 275.7,71.09 274.53,72.26 271.97,72.26 270,70.28 270,67.58 270.02,67.56 270.02,66.15 270.23,65.94 271.69,65.94
GND on BOTTOM: 156.73,117.36 152.09,117.36 151.84,117.62 151.84,121.11 152.22,121.49 156.73,121.49 156.98,121.24 156.98,117.62
GND on BOTTOM: outline of 961 points within 172.81,14.1 200.67,53.78 ; 1 cut-out
GND on BOTTOM: outline of 209 points within 278.33,13.83 293.95,73.25
GND on BOTTOM: outline of 814 points within 172.06,53.84 201.84,82.76 ; 1 cut-out
GND on BOTTOM: 241.12,53.99 240.78,54.33 240.75,54.33 239.84,55.24 239.84,56.13 239.91,56.2 248.77,56.2 248.99,56.43 251.04,56.43 251.05,56.41 251.05,54.15 250.9,53.99
GND on GND1: outline of 249 points within 0.2,0.2 408.15,177.9 ; 3 cut-outs
GND on IN1: 14.31,76.07 6.34,76.07 4.19,73.92 4.19,67.06 6.53,64.72 6.53,61.23 4.55,59.25 4.55,50.97 8.2,47.33 20.78,47.33 25.93,42.18 29.11,42.18 29.82,41.47 31.96,41.47 32.38,41.89 32.38,49.67 30.94,51.11 28,51.11 25.82,53.3 25.82,57.39 20.2,63.01 20.2,70.19
GND on GND2, GND3, GND4: outline of 237 points within 0.2,0.2 408.15,177.9
GND on VCC: outline of 250 points within 0.2,0.2 364.2,177.9
GND on VCC: 391.34,0.2 390.26,0.57 389.62,1.51 388.67,2.2 387.77,1.45 385.81,1.45 385.8,1.5 385.8,6.51 385.64,6.97 385.21,7.2 385.21,8.16 385.33,8.27 387.92,8.27 392.25,12.6 392.25,13.81 392.68,14.24 397.94,14.24 399.57,15.88 408.15,15.88 408.15,10.3 407.62,9.03 406.35,8.5 398.85,8.5 397.97,8.32 397.24,7.8 396.8,7.11 396.65,6.3 396.65,2 396.12,0.73 394.85,0.2
GND on VCC: 380.63,63.52 380.63,63.99 386.79,67.86 392.22,72.72 392.83,73.38 393.43,74.06 394.56,75.42 395.63,76.82 406.35,76.82 407.62,76.3 408.15,75.03 408.15,67.25 406.4,67.25 405.55,66.9 405.2,66.05 405.2,57.95 405.55,57.1 406.4,56.75 408.15,56.75 408.15,54.6 404.78,54.6 404.78,53.47 396.4,53.47 396.4,45.57 404.78,45.57 404.78,44.45 408.15,44.45 408.15,42.3 406.4,42.3 405.55,41.95 405.2,41.1 405.2,33 405.55,32.15 406.4,31.8 408.15,31.8 408.15,28.33 393.88,28.33 392.25,29.96 392.25,59.55 388.3,63.5 388.28,63.52
GND on IN4: 14.5,76.47 6.4,76.47 4.14,74.21 4.14,51.42 6.17,49.39 14.32,49.39 15.54,48.18 19.17,48.18 24.03,43.32 28.93,43.32 30.61,41.64 31.74,41.64 32.55,42.45 32.56,42.45 33.07,42.96 33.07,50.18 32.7,50.55 32.07,50.55 30.78,51.83 28.92,51.83 26.64,54.11 25.3,54.11 24.48,54.92 24.48,56.86 20.52,60.82 20.52,63.9 19.46,64.96 19.46,71.51
GND on GND5: outline of 241 points within 0.2,0.2 408.15,177.9
GNDA on TOP (solid shape): 383.25,20.36 383.25,19.27 384.12,18.39 384.12,18.18 384.02,18.07 383.73,18.07 383.16,18.64 383.16,18.84 382.99,19.01 382.99,20.35 383.08,20.44 383.17,20.44
GNDA on TOP (solid shape): 384.63,27.15 384.76,27.12 384.9,27.13 385.05,26.98 385.05,26.74 384.05,25.73 384.05,25.69 383.98,25.63 383.88,25.63 383.83,25.68 383.83,26.46 384.52,27.15
GNDA on TOP (solid shape): 387.44,16 387.44,15.02 387.13,14.71 386.54,14.71 386.53,14.72 386.53,15.25 386.53,15.26 386.1,15.26 386.07,15.23 386.07,14.72 386.06,14.71 385.25,14.71 385.24,14.7 384.93,14.7 384.78,14.55 384.78,13.91 384.68,13.8 383.21,13.8 383.11,13.91 383.11,14.76 382.91,14.97 382.91,16.47 383.03,16.59 386.85,16.59
GNDA on GND1: 383.06,14.01 383.06,16.87 382.57,17.35 381.96,17.35 381.96,17.75 382.24,18.03 382.24,18.99 382.41,19.15 382.41,20.29 382.51,20.4 384.04,20.4 384.38,20.74 384.38,25.27 383.91,25.73 382.83,25.73 382.79,25.77 382.79,26.64 383.42,27.28 383.42,27.74 383.06,28.11 383.06,32.24 383.08,32.27 385.03,32.27 385.54,31.76 387.19,31.76 387.55,31.41 387.55,30.77 388.97,29.35 392.14,29.35 393.67,27.83 408.15,27.83 408.15,16.4 399.38,16.4 397.73,14.75 388.55,14.75 388.29,15 385.16,15 384.79,14.63 384.79,13.87 384.72,13.8 383.26,13.8
GNDA on GND2, GND3, GND4: 383.27,13.79 383.06,14.01 383.06,16.87 382.58,17.35 381.96,17.35 381.96,17.75 382.24,18.03 382.24,18.99 382.41,19.15 382.41,20.29 382.51,20.4 384.04,20.4 384.38,20.74 384.38,25.27 383.91,25.73 382.83,25.73 382.79,25.77 382.79,26.64 383.42,27.28 383.42,27.74 383.06,28.11 383.06,32.24 383.08,32.27 385.03,32.27 385.54,31.76 387.19,31.76 387.55,31.41 387.55,30.77 388.97,29.35 392.14,29.35 393.67,27.83 408.15,27.83 408.15,16.4 399.38,16.4 397.73,14.75 388.55,14.75 388.29,15 385.16,15 384.8,14.64 384.8,13.87 384.72,13.79
GNDA on VCC: 383.06,14 383.06,16.87 382.58,17.35 381.96,17.35 381.96,17.75 382.24,18.03 382.24,18.98 382.41,19.15 382.41,20.29 382.51,20.4 384.03,20.4 384.37,20.74 384.37,25.27 383.91,25.73 382.83,25.73 382.79,25.77 382.79,26.64 383.42,27.28 383.42,27.74 383.06,28.11 383.06,32.24 383.08,32.27 385.03,32.27 385.54,31.76 387.19,31.76 387.55,31.41 387.55,30.77 388.97,29.35 392.14,29.35 393.67,27.83 408.15,27.83 408.15,16.4 399.38,16.4 397.73,14.75 388.55,14.75 388.29,15 385.16,15 384.79,14.63 384.79,13.86 384.73,13.8 383.25,13.8
GNDA on GND5: 383.06,14.01 383.06,16.87 382.58,17.35 381.97,17.35 381.96,17.35 381.96,17.76 382.24,18.03 382.24,18.99 382.41,19.15 382.41,20.29 382.51,20.4 384.04,20.4 384.38,20.73 384.38,25.27 383.91,25.73 382.83,25.73 382.79,25.77 382.79,26.65 383.42,27.28 383.42,27.74 383.06,28.11 383.06,32.24 383.08,32.27 385.03,32.27 385.54,31.76 387.19,31.76 387.55,31.41 387.55,30.77 388.97,29.35 392.14,29.35 393.67,27.83 408.15,27.83 408.15,16.4 399.38,16.4 397.73,14.75 388.55,14.75 388.29,15 385.16,15 384.8,14.64 384.8,13.88 384.71,13.79 383.27,13.79
GNDA_CHG on TOP (solid shape): 68.11,29.29 68.11,28.43 68.02,28.34 67.86,28.34 67.85,28.34 67.33,28.34 67.1,28.11 67.1,26.91 66.83,26.64 66.26,26.64 66.15,26.64 66.05,26.54 66.05,25.94 65.95,25.84 64.75,25.84 64.45,25.54 64.45,25.08 64.36,24.98 63.84,24.98 63.67,25.14 63.67,25.96 64.39,26.67 65.44,26.67 65.84,27.07 65.84,27.53 65.86,27.55 66.37,27.55 66.4,27.58 66.4,28 66.38,28.01 65.97,28.01 65.97,28.01 65.87,28.01 65.85,28.03 65.85,28.29 65.86,28.3 65.86,28.58 66.21,28.93 66.86,28.93 67.27,29.34 68.07,29.34
GNDA_CHG on IN4 (solid shape): outline of 112 points within 66.68,19.14 72.59,29.95
VBUS2_ACOK on TOP (solid shape): 51.76,16.4 51.76,14.49 51.51,14.24 49.86,14.24 49.73,14.37 49.73,16.02 49.74,16.03 50.08,16.17 50.22,16.5 50.37,16.65 51.51,16.65
VBUS_C_CTRL_P1 on BOTTOM (solid shape): 39.93,23.03 39.93,22.77 39.93,22.75 39.89,22.73 39.7,22.42 39.89,22.1 39.93,22.08 39.93,22.07 39.98,22.06 40.03,22.06 40.13,22.07 40.22,22.1 40.29,22.05 40.32,21.98 40.32,21.71 40.26,21.62 40.23,21.51 40.2,21.48 39.24,21.48 39.01,21.25 38.68,21.25 38.56,21.36 38.56,22.12 39.04,22.6 39.11,22.6 39.15,22.63 39.15,23.34 39.19,23.38 39.57,23.38
VBUS_C_CTRL_P2 on BOTTOM (solid shape): 43.78,23.08 43.78,22.92 43.93,22.92 44.03,22.83 44.06,22.71 43.99,22.62 43.78,22.23 44.12,21.94 44.21,21.9 44.24,21.81 44.24,21.52 44.15,21.43 43.18,21.43 42.99,21.25 42.64,21.25 42.57,21.32 42.57,21.84 42.87,22.13 43.05,22.13 43.18,22.27 43.18,22.98 43.3,23.1 43.75,23.1
VDD12_A on BOTTOM (solid shape): 54.56,45.05 54.56,43.93 53.16,42.53 53.16,41.98 52.35,41.17 51.81,41.17 51.81,41.17 48.08,41.17 47.9,41.34 47.9,41.98 48.1,42.17 49.48,42.17 50.12,42.81 51.56,42.81 51.98,43.23 52.24,43.23 52.5,43.18 52.69,43.36 53.35,44.02 54.11,44.02 54.25,44.16 54.25,45.02 54.35,45.13 54.48,45.13
VDD12_A on BOTTOM (solid shape): 50.37,54.92 53.52,54.92 53.53,54.92 53.7,54.76 53.7,54.02 53.63,53.96 52.21,53.96 52.21,54.02 51.89,54.31 51.57,54.02 51.57,53.96 50.18,53.96 50.17,54 49.76,54.22 49.48,53.84 49.48,53.82 49.02,53.35 48.11,53.35 48.1,53.41 48.03,53.61 47.87,53.73 47.83,53.75 47.83,53.99 47.83,53.99 47.83,54.95 47.88,54.96 48.06,55.04 48.17,55.21 48.18,55.26 50.02,55.26
VDD12_B on TOP (solid shape): 87.45,56.78 87.45,56.02 87.32,55.89 86.31,55.89 86.05,55.64 86.05,55.13 85.04,54.12 83.64,54.12 83.26,53.74 83.26,52.59 82.62,51.96 80.88,51.96 80.85,51.99 80.85,52.16 80.92,52.23 81.88,52.23 81.9,52.26 81.91,52.26 81.99,52.34 81.99,54.62 82.75,55.39 83.54,55.39 85.07,56.91 87.32,56.91
VDDA12_A on TOP (solid shape): 51.64,48.66 51.64,48.19 51.46,47.91 51.57,47.6 51.64,47.53 51.64,47.39 52.14,46.88 52.78,46.88 53.03,46.62 53.03,44.97 53.16,44.85 53.16,43.83 53.18,43.81 53.18,43.18 53.2,43.16 53.2,42.9 53.29,42.9 53.29,41.54 53.16,41.42 52.17,41.42 52.17,41.44 51.97,41.64 51.97,45.78 50.9,46.85 50.9,48.7 51.12,48.91 51.38,48.91
VDDRX12_A on BOTTOM (solid shape): 57.9,44.99 57.9,44.5 58.86,43.55 61.9,43.55 62.1,43.35 62.1,42.58 62.05,42.53 62.05,41.8 61.8,41.54 61.54,41.54 60.76,42.32 58.73,42.32 57.44,43.62 57.44,45.09 57.48,45.13 57.76,45.13
VDDRX12_A on BOTTOM (solid shape): 64.15,56.86 64.15,56.04 64.03,55.92 64.03,55.92 63.84,55.73 63.84,55.48 63.7,55.34 62.3,55.34 61.19,54.22 60.45,54.22 60.02,53.79 59.79,53.79 59.6,53.6 59.6,53.61 59.18,53.19 57.87,53.19 57.81,53.24 57.81,53.38 57.86,53.43 58.83,53.43 59.65,54.25 59.65,55.01 60.55,55.91 60.55,56.48 60.73,56.66 63.19,56.66 63.19,56.67 63.33,56.67 63.36,56.7 63.36,56.95 63.4,56.99 64.02,56.99
VDDRX12_B on BOTTOM (solid shape): 72.34,46.88 72.34,45.73 72.21,45.61 69.41,45.61 69.11,45.91 69.11,46.05 69.09,46.11 69.1,46.17 68.78,46.68 68.46,46.17 68.45,46.05 68.34,45.99 67.26,45.99 67.13,46.12 67.13,47 67.26,47.13 72.08,47.13
VDDTX12_A on TOP (solid shape): 53.29,57.29 53.29,55.87 53.24,55.87 53.24,55.08 53.16,55.01 53.16,53.23 52.91,52.97 51.51,52.97 50.92,53.56 50.92,55.06 50.87,55.11 50.87,56.18 51.41,56.18 51.41,56.12 51.42,56.07 51.43,56.02 51.45,55.97 51.48,55.93 51.52,55.89 51.56,55.85 51.61,55.83 51.66,55.81 51.71,55.8 51.76,55.79 51.82,55.8 51.87,55.81 51.92,55.83 51.96,55.85 52.01,55.89 52.04,55.93 52.07,55.97 52.09,56.02 52.11,56.07 52.12,56.12 52.12,56.18 52.11,56.23 52.09,56.28 52.07,56.33 52.04,56.37 52.01,56.41 51.96,56.44 51.92,56.47 51.87,56.49 51.82,56.5 51.76,56.51 51.71,56.5 51.66,56.49 51.61,56.47 51.56,56.44 51.52,56.41 51.48,56.37 51.45,56.33 51.43,56.28 51.42,56.23 51.41,56.18 50.87,56.18 50.87,57.04 51.38,57.55 53.03,57.55
+BL_PWR_SRC on BOTTOM (solid shape): 135.71,122.82 135.71,118.42 135.65,118.37 132.42,118.37 132.22,118.57 132.22,122.4 132.98,123.17 135.37,123.17
+BL_PWR_SRC on IN3 (solid shape): 114.48,119.9 114.48,117.16 114.04,116.73 112.75,116.73 112.32,117.16 112.32,119.85 112.44,119.98 114.4,119.98
+BL_PWR_SRC on IN3 (solid shape): 131.26,121.3 134.31,121.3 134.44,121.17 134.44,119.65 134.06,119.27 130.19,119.27 129.17,120.28 129.17,121.49 129.87,122.19 130.38,122.19
+BL_PWR_SRC on TOP: 114.83,119.5 114.83,117.26 115.2,116.89 115.2,116.11 115.07,115.98 114.5,115.98 114.32,115.8 114.32,115.04 114.24,114.95 113.71,114.95 113.57,115.1 113.57,116.74 113.46,116.84 112.85,116.84 112.73,116.96 112.73,119.25 113.05,119.57 114.75,119.57
+BL_PWR_SRC_F on TOP (solid shape): 143.46,135.21 143.6,135.12 143.77,135.11 143.93,135.12 144.08,135.21 145.67,135.21 145.83,135.04 145.83,133.62 145.55,133.33 144.18,133.33 143.89,133.04 143.89,130.42 143.56,130.09 142.38,130.09 142.18,130.28 142.18,133.39 141.98,133.59 141.98,135.13 142.05,135.21
+BL_PWR_SRC_F on BOTTOM (solid shape): 137.09,125.26 137.09,123.77 136.84,123.52 132.49,123.52 132.42,123.59 132.42,125.37 132.48,125.43 136.92,125.43
+BL_PWR_SRC_F on IN1: 135.66,125.45 141.87,131.67 143.05,131.67 143.64,131.08 143.64,127.91 138.29,122.56 136.33,122.56 135.66,123.23
+CAMERA_VDD on TOP (solid shape): 117.4,119.55 117.4,118.05 117.93,117.52 117.93,117.01 117.92,116.92 117.93,116.83 117.93,115 117.52,114.59 116.34,114.59 116.2,114.73 116.2,116.8 116.66,117.26 116.66,117.74 117.02,118.1 117.02,118.27 117.01,118.28 117.01,119.01 117.07,119.06 117.07,119.6 117.35,119.6
+CAMERA_VDD_F on BOTTOM: 133.53,133.05 134.85,133.05 135.02,132.87 135.02,129.97 134.69,129.64 133.61,129.64 133.37,129.89 133.37,132.9
+DDR_VREF_CA on BOTTOM (solid shape): 169.79,58.05 169.79,56.99 170.25,56.53 170.25,56.15 170.13,56.02 168.35,56.02 167.46,56.91 167.46,58.04 167.58,58.16 167.98,58.16 168,58.18 169.67,58.18
+DGFF_PWR on TOP: 123.04,91.73 122.56,92.2 122.56,95.69 122.74,95.87 127.33,95.87 128.08,95.12 132.54,95.12 132.85,94.81 132.85,92.17 132.41,91.73 124.5,91.73 124.41,91.77 124.37,91.85 124.35,91.97 124.29,92.07 124.26,92.15 124.29,92.23 124.01,92.81 123.74,92.23 123.77,92.15 123.74,92.07 123.68,91.97 123.66,91.85 123.62,91.77 123.53,91.73
+DGFF_PWR_SRC on TOP (solid shape): outline of 2101 points within 109.45,95.3 133.68,108.84
+DIMM_DQ_R_VREF_B on BOTTOM (solid shape): 203.4,58.71 203.4,57.91 203.93,57.39 204.56,57.39 204.64,57.3 204.65,57.3 204.65,56.05 204.72,55.97 204.72,55.74 205.57,55.74 205.58,55.75 205.68,55.75 205.97,55.45 205.97,54.12 205.74,53.89 204.4,53.89 204.2,54.1 204.2,54.1 204.13,54.17 204.13,55.53 203.78,55.87 203.78,56.37 203.59,56.56 203.26,56.56 203.25,56.55 203,56.55 202.78,56.77 202.78,57.44 202.65,57.57 202.69,57.62 202.79,57.88 202.67,58.14 202.56,58.25 202.56,58.7 202.61,58.75 203.36,58.75
+EDP_VDD on TOP (solid shape): 110.3,147.11 110.3,146.76 110.14,146.6 109.16,146.6 108.76,146.2 108.76,144.21 108.56,144.01 107.53,144.01 107.3,144.24 107.3,146.41 107.71,146.82 108.02,146.92 108.12,147.23 108.21,147.33 110.09,147.33
+EDP_VDD on BOTTOM: 108.13,146.75 109.14,146.75 109.15,146.77 109.15,147.29 109.17,147.31 109.34,147.31 109.36,147.3 109.36,146.77 109.37,146.75 109.86,146.75 110.45,146.15 110.94,146.15 111.49,145.6 111.49,143.08 110.93,142.52 107.89,142.52 107.29,143.12 107.29,145.91
+IR_F on TOP (solid shape): 113.48,143.65 113.48,142.25 113.1,141.87 111.23,141.87 110.79,141.43 110.79,133.55 110.87,133.47 110.87,132.13 110.73,131.99 109.36,131.99 109.24,132.11 109.24,142.05 109.23,142.07 110.94,143.78 113.36,143.78
+LCDVDD on TOP (solid shape): 116.84,120.39 116.84,118.34 116.76,118.26 115.58,118.26 115.52,118.33 115.52,119.56 115.39,119.69 115.01,119.69 114.93,119.77 114.93,120.11 114.92,120.12 114.92,120.68 115.09,120.84 116.38,120.84
+LCDVDD on BOTTOM (solid shape): 111.37,149.41 111.37,147.29 111.28,147.2 110.6,147.2 110.29,146.88 109.49,146.88 109.49,146.89 109.49,147.43 109.47,147.45 109.03,147.45 109.02,147.43 109.02,146.89 109.01,146.88 107.48,146.88 107.36,147.01 107.36,149.64 107.44,149.72 111.06,149.72
+LCDVDD on IN4 (solid shape): 116.99,122.64 116.99,120.06 116.51,119.58 115.04,119.58 114.73,119.89 114.73,122.47 115.33,123.07 116.55,123.07
+LCDVDD on IN4 (solid shape): 110.55,147.12 110.55,146.23 109.64,145.32 109.26,145.32 108.87,145.71 108.77,145.89 108.59,145.98 107.34,147.23 107.34,149.18 107.45,149.29 108.38,149.29
+LCDVDD on BOTTOM: 116.91,118.76 113.28,118.76 113.1,118.94 113.1,122.54 113.44,122.87 117.27,122.87 117.42,122.72 117.42,119.27
+REGCTL_PNP10 on TOP (solid shape): 158.57,139.74 159.22,139.74 159.54,139.42 159.54,138.47 159.29,138.22 158.59,138.22 158.44,138.36 158.44,139 157.55,139.89 155.73,139.89 155.7,139.92 155.7,140.11 155.75,140.16 156.64,140.16 156.67,140.2 158.11,140.2
+TBT_SVR_IND on BOTTOM (solid shape): 36.21,57.65 36.31,57.58 36.42,57.55 36.65,57.32 36.65,56.4 36.55,56.19 36.6,55.97 36.61,55.95 36.61,55.87 36.6,55.87 36.6,54.68 36.56,54.66 36.37,54.32 36.61,54.01 36.65,53.99 36.65,53.91 36.94,53.63 36.94,53.55 37.03,53.46 37.03,51.99 36.44,51.99 36.39,52.04 36.39,52.76 36.35,52.8 36.35,52.9 36.13,53.12 36.12,53.13 36.04,53.28 35.89,53.37 35.87,53.37 35.17,54.07 35.14,54.19 35.23,54.28 35.47,54.72 35.03,54.97 34.92,54.99 34.87,55.09 34.87,55.3 34.9,55.7 34.55,55.88 34.51,55.87 34.49,55.89 33.41,55.89 33.4,55.9 33.25,55.93 33.1,55.9 33.09,55.89 32.71,55.89 32.59,56.02 32.59,57.39 32.84,57.65
+USB2_REPEATER_VDD on TOP (solid shape): 378.33,58.79 378.33,58.05 377.67,57.38 377.67,56.73 377.53,56.59 376.3,56.59 376.15,56.74 376.15,59.04 376.48,59.37 377.75,59.37
+USB2_REPEATER_VDD on BOTTOM (solid shape): 377.9,59.2 377.9,58.57 377.72,58.26 377.9,57.95 377.9,57.44 377.7,57.13 377.9,56.81 377.9,56.53 377.64,56.28 377.39,56.28 377.37,56.29 377.22,56.33 377.06,56.29 377.05,56.28 375.99,56.28 375.68,56.59 375.68,58.46 375.7,58.48 376.22,58.48 376.23,58.5 376.23,58.92 376.21,58.94 375.69,58.94 375.68,58.95 375.68,59.28 375.72,59.32 377.77,59.32
+USB2_REPEATER_VDD on IN1 (solid shape): outline of 1348 points within 376.76,48.66 387.17,60.85
+USB3_REPEATER_VDD on TOP (solid shape): 385.01,40.72 385.11,40.73 385.32,40.73 385.65,40.4 385.65,38.62 385.28,38.25 383.96,38.25 383.82,38.39 383.82,38.7 384.07,38.95 384.07,40.48 384.27,40.68 384.3,40.68 384.37,40.69 384.45,40.72 384.46,40.73 384.92,40.73
+USB3_REPEATER_VDD on BOTTOM (solid shape): 379.34,47.61 379.34,47.14 379.35,47.14 379.35,47.07 379.36,47.06 379.43,47.06 379.43,47.05 379.71,47.05 379.72,47.06 379.79,47.06 379.8,47.07 379.8,47.61 380.42,47.61 380.5,47.54 380.5,46.33 380.39,46.23 379.04,46.23 378.9,46.37 378.9,47.51 379.01,47.62 379.33,47.62
+USB3_REPEATER_VDD on IN1 (solid shape): outline of 1274 points within 377.14,37.86 389.07,49.8
+UZ12_TPM on BOTTOM (solid shape): 144.3,19.13 144.3,16.74 144.24,16.68 144.24,15.72 144.18,15.66 143.25,15.66 142.91,15.31 142.7,15.31 142.62,15.22 142.58,15.22 142.48,15.12 141.63,15.12 141.61,15.11 141.56,15.16 141.56,15.65 141.64,15.73 142.85,15.73 143.32,16.19 143.32,19.08 143.44,19.2 144.23,19.2
+UZ12_VHIO on TOP (solid shape): 138.2,19.74 138.2,19.27 138.14,19.2 137.78,19.2 137.67,19.09 137.67,18.11 137.63,18.07 137.08,18.07 137.01,18 137.01,16.86 136.95,16.8 136.52,16.8 135.71,17.62 135.71,18.53 135.98,18.8 136.06,18.8 136.42,19.15 136.43,19.16 136.57,19.25 136.65,19.4 136.66,19.45 137.08,19.45 137.12,19.48 137.15,19.48 137.39,19.57 137.52,19.79 138.15,19.79
+V_DDR_REFCA_A on BOTTOM (solid shape): 167.9,60.28 167.9,59.44 168.15,59.2 168.15,58.51 167.93,58.29 164.96,58.29 164.87,58.38 164.87,60.16 165.43,60.72 167.46,60.72
BQ24780_REGN on TOP (solid shape): 72.71,22.85 73.1,22.85 73.12,22.84 73.21,22.8 73.31,22.8 73.34,22.81 73.99,22.16 75.92,22.16 76.12,21.96 76.12,20.46 75.94,20.28 74.78,20.28 74.52,20.54 74.52,20.92 74.36,21.08 74.36,21.1 74.34,21.1 74.29,21.15 73.56,21.15 73.41,21.3 73.43,21.34 73.45,21.56 73.33,21.75 73.33,21.96 72.63,22.66 72.55,22.66 72.51,22.7 71.68,22.7 71.63,22.75 71.63,22.9 71.68,22.95 72.61,22.95
BST_3V on TOP (solid shape): 139.24,112.52 139.24,111.59 139.23,111.58 138.01,111.58 137.87,111.44 136.93,111.44 136.9,111.47 136.9,111.7 136.95,111.75 137.82,111.75 138.61,112.54 139.22,112.54
BST_3VR on TOP (solid shape): 323.87,9.61 323.87,7.58 323.7,7.42 323.55,7.42 323.46,7.51 323.46,8.78 323.24,9 322.99,9 322.96,9.03 322.83,9.03 322.82,9.04 322.82,9.67 322.86,9.7 323.77,9.7
BST_5V on BOTTOM (solid shape): 52.54,10.89 52.54,10.33 52.26,10.05 52.26,8.82 52.17,8.73 52.06,8.73 51.47,9.32 51.47,10.92 51.55,11 52.44,11
BST_5VR on TOP (solid shape): 356.12,45.54 356.12,44.68 356.05,44.62 356.05,44.46 356.06,44.46 356.06,43.38 355.96,43.27 355.79,43.27 355.74,43.33 355.74,44.32 355.38,44.68 355.18,44.68 354.92,44.94 354.92,45.44 355.05,45.58 356.08,45.58
BST_IO on TOP (solid shape): 309.09,57.99 309.09,57.84 309.04,57.79 308.63,57.79 308.58,57.74 308.58,55.18 308.48,55.08 307.67,55.08 307.53,55.22 307.53,57.96 307.64,58.07 309,58.07
BST_IO_R on TOP (solid shape): 308.58,54.59 308.58,53.66 308.5,53.58 306.62,53.58 306.54,53.67 306.54,54.59 306.61,54.66 308.51,54.66
CMPOUT on TOP (solid shape): 60.83,22.9 61.03,22.9 61.03,21.99 61.41,21.6 61.41,21.23 61.41,21.23 61.4,21.12 61.41,21.01 61.41,21 61.41,20.84 61.29,20.72 60.14,20.72 59.79,21.07 59.79,21.11 58.73,21.11 58.49,21.35 58.49,23 59,23.51 60.22,23.51
CORE_SW1 on TOP (solid shape): 285.42,58.84 285.42,55.06 285.54,54.93 286.76,54.93 286.92,54.78 286.92,54.06 286.64,54.06 286.44,53.86 281.81,53.86 281.2,54.47 281.2,56.83 281.28,56.91 282.09,56.91 282.17,56.99 282.17,57.7 282.12,57.75 281.28,57.75 281.1,57.93 281.1,59.04 281.23,59.17 285.09,59.17
CORE_SW2 on TOP (solid shape): 284.3,48.43 285.11,48.43 285.57,47.97 285.57,44.29 285.77,44.08 286.97,44.08 287.02,44.03 287.02,43.27 286.51,42.76 281.61,42.76 281.25,43.12 281.25,46.7 281.35,46.8 282.19,46.8 282.24,46.85 282.24,47.56 282.22,47.59 281.33,47.59 281.28,47.64 281.28,48.99 281.33,49.04 283.69,49.04
CORE_SW3 on TOP (solid shape): 285.47,38.22 285.47,34.76 285.87,34.36 286.97,34.36 287.07,34.25 287.07,33.54 287.02,33.49 285.42,33.49 285.04,33.87 282.14,33.87 281.25,34.76 281.25,37.12 281.33,37.2 282.14,37.2 282.22,37.28 282.22,37.99 282.17,38.04 281.33,38.04 281.15,38.22 281.15,39.33 281.28,39.46 284.22,39.46
CORE_SW4 on TOP (solid shape): 285.49,27.93 285.49,23.64 285.85,23.28 286.92,23.28 286.99,23.21 286.99,22.54 286.69,22.24 283.11,22.24 281.28,24.07 281.28,26.43 281.35,26.51 282.17,26.51 282.24,26.58 282.24,27.29 282.19,27.35 281.35,27.35 281.18,27.52 281.18,28.64 281.3,28.77 284.66,28.77
EN_2.5V on TOP (solid shape): 159.94,95.16 159.94,94.45 159.81,94.32 158.58,94.32 158.58,94.32 157.6,94.32 157.46,94.47 157.46,95.22 157.47,95.23 159.87,95.23
EN_IO on TOP (solid shape): 310.08,61.75 311,61.75 311.01,61.74 311.01,61.27 310.94,61.19 310.07,61.19 309.56,60.69 309.56,59.63 309.47,59.54 309.34,59.54 309.28,59.59 309.28,60.44 308.56,61.17 308.56,61.76 308.6,61.81 310.08,61.81
FB_2.5V on TOP (solid shape): 157.27,95.19 157.27,94.58 157.1,94.4 156.77,94.4 156.51,94.15 156.51,93.82 156.44,93.74 155.48,93.74 155.13,94.09 155.13,94.09 154.99,94.22 154.99,94.24 154.97,94.24 154.84,94.38 154.84,95.21 154.99,95.37 157.1,95.37
GT_SW1 on TOP (solid shape): 285.54,17.69 285.54,13.86 285.72,13.68 286.94,13.68 287.04,13.58 287.04,12.66 286.74,12.36 282.8,12.36 282.34,12.82 282.34,13.78 281.07,15.05 281.07,16.55 281.28,16.75 282.27,16.75 282.29,16.78 282.29,17.54 282.24,17.59 281.61,17.59 281.58,17.57 281.18,17.57 281.05,17.69 281.05,18.84 281.23,19.01 284.22,19.01
INT_SPK_L+ on TOP (solid shape): 346.87,23.34 346.87,22.53 346.62,22.28 346.62,20.79 346.49,20.67 345.93,20.67 345.86,20.74 345.86,22.97 345.86,23.15 346.14,23.43 346.78,23.43
INT_SPK_L+ on TOP (solid shape): 382.14,29.33 382.14,27.8 382.13,27.8 382.13,27.73 382.13,27.52 382.12,27.51 382.12,27.2 382.06,27.14 382.06,25.63 382.02,25.58 381.86,25.58 381.81,25.64 381.81,26.65 381.82,26.66 381.82,28.03 381.79,28.05 381.79,28.16 381.66,28.29 381.66,29.28 381.71,29.35 381.75,29.42 381.76,29.43 382.04,29.43
INT_SPK_L+ on IN4 (solid shape): 347.42,22.54 347.42,22.01 347.24,21.83 347.24,21.03 347.23,21.01 347.19,20.84 347.23,20.67 347.24,20.66 347.24,19.85 347.16,19.78 346.2,19.78 345.88,20.1 345.88,22.18 345.87,22.19 345.87,22.79 346.11,23.03 346.94,23.03
INT_SPK_L+ on IN4 (solid shape): 382.36,29.37 382.36,28.32 382.37,28.31 382.37,27.94 382.32,27.89 382.32,27.47 382.32,27.47 382.32,27.44 382.34,27.31 382.41,27.2 382.41,27 382.28,26.87 382.28,25.56 382.61,25.23 382.99,25.23 383.37,24.85 383.37,24.84 383.42,24.76 383.49,24.69 383.49,23.67 383.36,23.54 382.32,23.54 382.22,23.64 382.22,24.95 382.07,25.1 382.06,25.12 382,25.22 381.91,25.29 381.91,27.83 381.89,27.86 381.89,27.93 381.66,28.16 381.66,29.03 381.65,29.04 381.65,29.27 381.7,29.32 381.74,29.39 381.89,29.54 382.19,29.54
INT_SPK_L- on TOP (solid shape): 345.73,22.91 345.73,20.77 345.63,20.67 345.04,20.67 344.97,20.74 344.97,22.25 344.59,22.63 344.59,23.03 344.85,23.29 345.35,23.29
INT_SPK_L- on TOP (solid shape): 381.42,29.01 381.5,29.01 381.53,28.99 381.53,28.24 381.67,28.1 381.67,27.46 381.66,27.46 381.66,25.64 381.6,25.58 381.47,25.58 381.41,25.64 381.41,26.57 381.34,26.64 381.34,27.66 380.96,28.03 380.96,28.85 381.13,29.02 381.41,29.02
INT_SPK_L- on IN4 (solid shape): 345.96,23.51 345.96,23.18 345.72,22.94 345.72,22.21 345.44,21.94 344.61,21.94 344.32,22.23 344.32,22.9 344.34,22.9 344.34,23.62 344.8,24.08 345.39,24.08
INT_SPK_L- on IN4 (solid shape): 381.53,28.98 381.53,28.11 381.76,27.88 381.76,25.57 381.2,25.01 380.52,25.01 380.36,25.16 380.36,26.05 381.12,26.81 381.12,27.53 381.13,27.61 381.11,27.71 381.03,27.86 380.88,27.95 380.87,27.95 380.69,28.13 380.66,28.2 380.66,28.99 380.78,29.11 381.4,29.11
INT_SPK_R+ on TOP (solid shape): 351.1,24.14 351.16,24.08 351.24,24.03 351.26,24.03 351.3,23.99 351.3,23.9 351.31,23.89 351.31,23.46 350.49,22.65 350.49,20.74 350.41,20.66 349.83,20.66 349.68,20.8 349.68,22.91 350.91,24.14
INT_SPK_R+ on TOP (solid shape): 380.81,27.03 380.81,26.94 380.82,26.94 380.82,26.49 380.86,26.44 380.86,25.64 380.8,25.58 380.66,25.58 380.61,25.63 380.61,26.55 379.96,27.2 379.88,27.2 379.63,27.45 379.63,27.7 379.78,27.85 380,27.85
INT_SPK_R+ on IN2 (solid shape): 351.64,25.24 351.64,24.6 351.33,24.3 351.33,23.26 351.08,23 350.49,23 350.39,23.1 350.39,23.62 350.52,23.75 350.52,25.14 350.72,25.34 351.53,25.34
INT_SPK_R+ on IN2 (solid shape): outline of 105 points within 376.49,25.39 380.74,27.93
INT_SPK_R- on TOP (solid shape): 350.44,24.14 350.44,23.87 349.45,22.87 349.45,20.8 349.36,20.72 348.77,20.72 348.68,20.8 348.68,21.09 348.69,21.1 348.69,23.18 349.91,24.4 350.19,24.4
INT_SPK_R- on TOP (solid shape): 381.2,27.59 381.2,26.54 381.28,26.46 381.28,25.65 381.21,25.59 381.05,25.59 381,25.64 381,26.5 380.95,26.55 380.95,26.99 380.94,27 380.94,27.09 380.08,27.94 380.08,28.12 380.11,28.15 380.19,28.15 380.19,28.23 380.24,28.27 380.52,28.27
INT_SPK_R- on IN2 (solid shape): 350.59,25.89 350.59,25.5 350.34,25.25 350.34,23.76 349.53,22.95 349.27,22.95 349.17,23.05 349.17,25.59 349.53,25.95 350.53,25.95
INT_SPK_R- on IN2 (solid shape): 380.88,29.34 380.88,28.03 380.96,27.96 380.96,27.94 381.02,27.8 381.14,27.7 381.14,27.46 381,27.32 380.72,27.32 379.78,28.26 379.59,28.26 379.3,28.55 379.3,29.33 379.51,29.54 380.68,29.54
INT_SPKR_L+ on TOP (solid shape): 345.76,4.93 345.76,4.14 345.67,4.05 342.59,4.05 342.36,4.28 342.36,4.97 342.48,5.08 345.6,5.08
INT_SPKR_L+ on TOP (solid shape): 347.67,19.45 347.67,16.88 347.47,16.68 346.47,16.68 346.09,17.06 346.09,17.5 346.03,17.7 345.88,17.84 345.88,20.35 345.96,20.42 346.7,20.42
INT_SPKR_L+ on IN1 (solid shape): 347.72,17.48 347.72,15.92 347.58,15.78 346.53,15.78 346.4,15.9 346.4,17.49 346.5,17.59 347.61,17.59
INT_SPKR_L+ on IN1 (solid shape): 346.8,4.97 346.8,4.59 346.2,3.99 344.32,3.99 344.09,4.22 344.09,5.03 344.26,5.2 345.4,5.2 345.7,5.5 346.26,5.5
INT_SPKR_L- on TOP (solid shape): 345.62,6.2 345.62,5.41 345.54,5.34 344.23,5.34 344.08,5.49 342.57,5.49 342.31,5.74 342.31,6.09 342.57,6.34 345.48,6.34
INT_SPKR_L- on TOP (solid shape): 345.64,20.4 345.64,17.88 345.6,17.87 345.4,17.73 345.32,17.5 345.32,17.27 344.97,16.92 344.97,16.3 344.89,16.22 344.17,16.22 343.99,16.4 343.99,18.66 344.08,18.78 344.11,18.91 344.11,18.94 344.28,19.1 344.28,19.95 344.78,20.45 345.59,20.45
INT_SPKR_L- on IN1 (solid shape): 345.51,17.17 345.51,15.81 345.44,15.74 344.36,15.74 344.21,15.89 344.21,17.24 344.56,17.59 345.09,17.59
INT_SPKR_L- on IN1 (solid shape): 345.56,7.18 345.56,5.82 345.31,5.56 344.24,5.56 344.05,5.76 344.05,7.19 344.17,7.3 345.44,7.3
INT_SPKR_R+ on TOP (solid shape): 345.55,7.34 345.55,6.64 345.44,6.54 343.98,6.54 343.84,6.68 342.5,6.68 342.34,6.85 342.34,7.42 342.5,7.58 344.07,7.58 344.12,7.63 345.26,7.63
INT_SPKR_R+ on TOP (solid shape): 351.21,20.46 351.45,20.46 351.74,20.17 351.74,15.13 351.37,14.76 351.37,12.68 351.16,12.47 350.98,12.47 350.97,12.46 350.47,12.46 350.25,12.68 350.25,14.84 349.98,15.1 349.98,15.53 350.18,15.75 350.25,16.04 350.25,16.55 350.21,16.76 350.11,16.95 350.07,17 350.2,17.13 350.28,17.57 349.88,17.78 349.85,17.78 349.71,17.92 349.71,19.22 349.7,19.23 349.7,20.4 349.77,20.46 351.21,20.46
INT_SPKR_R- on TOP (solid shape): 345.79,8.65 345.79,8.4 345.38,7.99 342.52,7.99 342.35,8.16 342.35,8.61 342.55,8.82 344.71,8.82 345.11,9.21 345.23,9.21
INT_SPKR_R- on TOP (solid shape): 349.53,20.32 349.53,17.62 349.32,17.41 349.32,17.33 349.23,17.24 349.23,17.06 349.05,16.83 348.98,16.55 348.98,16.04 349.07,15.71 349.32,15.48 349.32,15.13 349.96,14.49 349.96,12.71 349.7,12.46 348.85,12.46 348.77,12.55 348.77,13.36 348.77,13.37 348.78,13.46 348.77,13.56 348.77,13.57 348.77,14 347.92,14.84 347.92,15.16 347.91,15.17 347.91,20.14 348.23,20.46 349.39,20.46
LG_1.2V on TOP (solid shape): 126.72,8.07 126.72,7.15 126.52,6.95 125.49,6.95 125.22,7.22 125.22,8.19 125.42,8.4 126.39,8.4
LG_1.2V on TOP (solid shape): 114.14,12.05 114.14,11.9 114.17,11.87 114.18,11.85 114.27,11.68 114.45,11.58 114.47,11.58 114.5,11.55 114.65,11.55 114.96,11.24 114.96,10.68 114.88,10.61 113.74,10.61 113.64,10.71 113.64,10.96 113.84,11.17 113.84,12.05 113.92,12.13 114.07,12.13
LG_1.2V on BOTTOM (solid shape): 115.75,11.32 115.75,10.56 115.59,10.4 113.89,10.4 113.64,10.66 113.64,11.42 113.69,11.47 115.59,11.47
LG_1.2V on BOTTOM (solid shape): 125.98,8.47 125.98,7.46 125.75,7.23 124.59,7.23 124.03,7.79 124.03,8.45 124.28,8.7 125.75,8.7
LG_+1VSP on TOP (solid shape): 108.4,39.84 108.4,39.31 109.25,38.46 109.29,38.39 109.34,38.33 109.4,38.27 109.48,38.24 109.67,38.04 109.67,32.86 109.64,32.84 109.45,32.53 109.64,32.21 109.67,32.19 109.67,31.84 108.63,30.8 108.1,30.8 108,30.9 108,31.54 108.76,32.3 108.76,35.04 108.48,35.32 108.48,38.17 107.64,39 107.64,39.79 107.8,39.94 108.3,39.94
LGATE_CHG on TOP (solid shape): 99.05,9.15 99.05,8.86 98.16,7.97 97.23,7.97 97.21,7.99 97.04,7.99 96.9,8.13 96.9,8.93 97.3,9.33 98.87,9.33
LGATE_CHG on IN4 (solid shape): 99.74,10.1 99.74,8.56 99.48,8.31 96.9,8.31 96.9,10.22 97.13,10.44 97.74,10.44 97.75,10.45 99.39,10.45
LP#_VCCIO on TOP (solid shape): 308.4,61.7 308.4,61.04 309.07,60.38 309.07,59.56 309.02,59.51 308.52,59.51 307.74,60.28 307.74,61.69 307.77,61.71 308.39,61.71
LX_1.2V on TOP (solid shape): 123.21,3.13 123.21,1.46 122.91,1.16 119.96,1.16 119.58,1.54 119.58,3.28 119.82,3.52 122.82,3.52
LX_1.2V on TOP (solid shape): 137.67,6.31 137.67,2.38 137.68,2.37 137.68,1.53 137.44,1.28 125.81,1.28 125.66,1.44 125.66,5.76 126.13,6.24 130.49,6.24 130.71,6.02 130.71,5.55 131.4,4.86 133.33,4.86 133.8,5.33 133.8,6.46 134.08,6.74 137.24,6.74
LX_1.2V on TOP (solid shape): 115.21,12.38 115.21,12.21 115.26,12.16 115.26,12.13 115.44,11.95 115.5,11.95 115.51,11.95 115.63,11.93 115.74,11.95 115.75,11.95 116.2,11.95 116.23,11.98 117.22,11.98 117.29,11.9 117.29,10.99 117.17,10.86 115.77,10.86 114.96,11.67 114.55,11.67 114.27,11.95 114.27,12.49 114.32,12.54 115.06,12.54
LX_1.2V on IN1 (solid shape): 121.18,4.26 121.18,3.14 121.03,2.99 119.73,2.99 119.53,3.19 119.53,4.31 119.63,4.41 121.03,4.41
LX_1.2V on IN1 (solid shape): 116.02,11.34 116.02,10.81 115.95,10.73 115.06,10.73 114.85,10.94 114.85,10.96 114.75,11.14 114.57,11.23 114.55,11.24 114.3,11.5 114.3,12 114.45,12.16 115.21,12.16
LX_1.2V on IN4 (solid shape): 132.53,3.32 132.53,1.92 132.03,1.41 129.99,1.41 129.36,2.05 123.52,2.05 122.63,1.16 120.09,1.16 120.08,1.16 119.79,1.16 119.7,1.26 119.7,3.94 120.34,4.59 131.26,4.59
LX_1.8V on TOP (solid shape): 103.99,22.93 103.99,21.96 104.25,21.7 105.38,21.7 105.66,21.42 105.66,19.54 105.48,19.37 105.38,19.33 105.28,19.39 104.89,19.56 104.62,19.22 104.58,19.13 104.49,19.09 102.59,19.09 102.49,18.99 100.78,18.99 100.69,19.08 100.69,19.23 100.78,19.32 101.87,19.32 101.93,19.38 103.02,20.47 103.02,22.98 103.09,23.05 103.87,23.05
LX_2.5V on TOP (solid shape): 160.86,93.74 160.86,90.91 160.07,90.12 160.07,89.97 160.08,89.96 160.08,89.19 159.92,89.03 159.13,89.03 158.98,89.18 158.98,89.48 158.99,89.56 158.98,89.65 158.98,90.06 158.99,90.15 158.98,90.23 158.98,90.65 158.99,90.73 158.98,90.81 158.98,92.47 158.74,92.72 157.8,92.72 157.75,92.77 157.75,92.77 157.75,93.02 157.83,93.1 159.08,93.1 159.25,93.26 159.24,93.27 159.24,93.76 159.25,93.76 159.3,93.82 160.78,93.82
LX_3V on TOP (solid shape): 136.85,114.42 136.85,113.66 136.77,113.59 136.77,111.42 136.94,111.25 138.01,111.25 138.21,111.45 139.12,111.45 139.41,111.16 139.41,110.52 139.75,110.18 141.42,110.18 141.69,109.91 141.69,109.65 141.69,109.65 141.69,109.13 141.08,108.52 139.14,108.52 138.78,108.17 138.78,107.11 138.62,106.95 136.34,106.95 136.21,107.08 136.21,107.34 136.1,107.45 136.1,111.38 136.57,111.85 136.57,114.43 136.64,114.49 136.78,114.49
LX_3V on BOTTOM (solid shape): 139.39,111.83 139.39,107.15 139.2,106.96 138.69,106.96 138.68,106.95 135.99,106.95 135.68,107.25 135.68,111.85 135.76,111.93 139.29,111.93
LX_3VR on TOP (solid shape): 328.32,11.88 328.32,4.61 328.01,4.31 326.06,4.31 325.6,4.76 325.6,6.57 325.4,6.77 324.71,6.77 324.64,6.7 323.92,6.7 323.75,6.87 323.75,7.28 324,7.53 324,9.59 324.28,9.87 325.07,9.87 325.35,10.15 325.35,11.47 326.21,12.33 327.86,12.33
LX_5V on TOP (solid shape): outline of 97 points within 47.53,4.98 53.58,13.3
LX_5V on BOTTOM (solid shape): 51.26,10.94 51.26,8.95 51.43,8.78 51.8,8.78 52.02,8.56 52.69,8.56 52.69,8.56 54,8.56 54.19,8.75 55,8.75 55.12,8.63 55.12,8.52 54.94,8.35 52.69,8.35 52.68,8.35 52.26,8.35 51.85,7.94 51.03,7.94 48.64,5.55 47.45,5.55 47.18,5.81 47.18,10.01 48.26,11.08 51.12,11.08
LX_5VR on TOP (solid shape): 360.02,48.68 360.02,45.46 360.7,44.77 360.7,41.29 360.58,41.16 358.19,41.16 358.01,41.34 358.01,42.26 357.58,42.69 357.2,42.69 356.94,42.43 356.16,42.43 356,42.59 356,43.12 356.21,43.32 356.21,44.44 356.33,44.57 356.33,45.58 356.36,45.61 358.39,45.61 358.8,46.01 358.8,48.73 358.9,48.83 359.86,48.83
LX_+1VSP on TOP (solid shape): 107.12,33.4 107.12,32.99 107.53,32.57 107.53,32.07 107.37,31.9 107.37,30.94 107.22,30.79 107.04,30.79 107.01,30.82 107.01,31.87 106.43,32.45 106.43,32.71 106.35,32.78 105.99,32.78 105.95,32.83 105.95,33.45 105.99,33.48 107.04,33.48
LX_+1VSP on TOP (solid shape): 105.48,48.53 105.48,46.01 107.01,44.49 109.4,44.49 110.89,42.99 110.89,41.87 110.61,41.59 108.99,41.59 108.63,41.24 108.63,40.5 108.28,40.15 105.31,40.15 105,40.45 105,41.44 104.65,41.8 102.49,41.8 102.36,41.92 102.36,43.27 101.5,44.13 101.5,48.73 101.65,48.88 105.13,48.88
LX_+1VSP on IN3 (solid shape): 107.62,33.26 107.62,32.08 107.48,31.94 107.09,31.94 106.56,32.47 106.56,33.59 106.73,33.77 107.12,33.77
LX_+1VSP on IN3 (solid shape): 107.71,43.6 107.71,42.42 107.34,42.06 105.85,42.06 105.62,42.3 105.62,43.78 105.81,43.97 107.34,43.97
LX_CHG on TOP (solid shape): 94.01,14.62 94.01,12.84 93.86,12.55 94.01,12.26 94.01,11.71 93.8,11.5 93.1,11.5 92.49,10.89 92.49,9.48 92.76,9.21 95.88,9.21 96.39,8.69 96.39,4.17 95.84,3.62 94.91,3.62 94.41,3.12 94.41,1.59 94.02,1.2 92.22,1.2 89.82,3.59 87.81,3.59 87.2,4.2 87.2,9.56 87.83,10.2 89.21,10.2 90.57,11.56 90.57,13.89 91.46,14.79 93.84,14.79
LX_CHG on IN4 (solid shape): 93.01,14.14 93.01,12.34 92.96,12.29 92.26,12.29 92.05,12.5 92.05,14.24 92.12,14.31 92.84,14.31
