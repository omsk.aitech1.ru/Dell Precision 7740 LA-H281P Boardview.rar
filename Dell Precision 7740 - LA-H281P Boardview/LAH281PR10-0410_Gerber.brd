# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_DRX_P18: length 269.5
  TOP w0.076: UH1.D42 144.39,28.69 145.14,28.69 145.37,28.91 146.52,28.91 147.56,27.87 148.58,27.87 148.6,27.89 148.62,27.89
  TOP w0.102: 148.62,27.89 152.18,27.89 154.68,25.39 154.68,23.25 154.81,23.12 154.91,23.12 v2(155.19,23.4)
  IN4 w0.102: v2(366.86,26.08) 367.13,25.81 367.13,25.66 367.02,25.55 366.68,25.55 365.53,26.71 359.58,26.71 359.24,27.04 342.16,27.04 337.99,22.87 331.86,22.87 325.82,16.83 317.49,16.83 311.17,10.52 308.17,10.52 304.78,7.12 294.95,7.12 293.91,6.09 257.49,6.09 253.9,9.68 247.15,9.68 242.46,4.99 169.27,4.99 156.36,17.9 156.36,22.42 155.64,23.13 155.45,23.13 v2(155.19,23.4)
  BOTTOM w0.102: CN185.1 375.43,13.15 375.43,13.34 375.33,13.44 374.51,13.44 372.45,15.5 371.81,15.5 370.58,16.73 369.71,16.73 366.96,19.47 366.96,21.82 367.39,22.24 367.39,25.69 367,26.08 v2(366.86,26.08)
PCIE_PTX_DRX_P19: length 273.4
  TOP w0.076: UH1.D43 144.56,28.03 144.96,28.03 145.14,27.86 145.91,27.86 146.4,27.37 146.44,27.37 146.45,27.36
  TOP w0.102: v2(151.35,21.84) 151.06,22.13 151.06,22.75 146.45,27.36
  IN4 w0.102: v2(368.66,23.41) 368.8,23.41 369.18,23.8 369.18,23.96 369.12,24.02 358.35,24.02 357.3,25.07 342.97,25.07 338.66,20.76 334.93,20.76 329.25,15.08 328.3,15.08 327.43,14.21 317.74,14.21 310.55,7.02 308.76,7.02 307.05,5.3 306.29,5.3 304.05,3.06 294.35,3.06 293.96,3.46 257.19,3.46 253.05,7.6 247.96,7.6 243.33,2.97 168.24,2.97 166.68,4.53 160.5,4.53 156.16,8.87 156.16,11.79 154.09,13.86 154.09,20.13 151.85,22.38 151.09,22.38 151,22.28 151,22.19 v2(151.35,21.84)
  BOTTOM w0.102: CN183.1 378.35,13.15 378.35,13.49 376.8,15.04 374.6,15.04 372.95,16.69 372.31,16.69 368.92,20.08 368.92,21.93 369.18,22.19 369.18,23.02 368.8,23.41 v2(368.66,23.41)
PCIE_PTX_DRX_P20: length 273.7
  TOP w0.076: 146.02,26.67 146,26.69 146,26.71 145.62,27.1 145.26,27.1 UH1.B44
  TOP w0.102: v2(148.81,22.17) 149,22.17 149.26,22.43 149.26,23.43 146.84,25.85 146.03,26.66 146.02,26.67
  IN4 w0.102: v2(148.81,22.17) 149.13,22.49 149.13,22.71 149.68,23.26 152.41,23.26 155.06,20.6 155.06,17.44 168.73,3.78 242.98,3.78 247.62,8.42 253.34,8.42 257.51,4.25 267.84,4.25 268.46,4.87 293.66,4.87 294.68,3.84 303.73,3.84 308.57,8.69 311.11,8.69 317.44,15.02 326.67,15.02 327.75,16.11 328.48,16.11 333.94,21.56 338.35,21.56 342.65,25.85 358.02,25.85 359.06,24.81 370.74,24.81 370.8,24.87 370.8,25.2 370.59,25.41 v2(370.43,25.41)
  BOTTOM w0.102: CN181.1 381.4,13.15 381.4,13.3 381.2,13.5 380.32,13.5 377.38,16.44 375.18,16.44 370.94,20.68 370.94,22.25 370.69,22.49 370.69,25.15 v2(370.43,25.41)
PCIE_PTX_DRX_P21: length 228.7
  TOP w0.076: 143.39,24.46 143.38,24.47 143.35,24.47 143.3,24.52 143.3,25.29 143.15,25.44 143.15,25.85 143.2,25.91 UH1.F46
  TOP w0.102: v2(145.53,22.46) 145.35,22.65 145.35,23.49 145.12,23.72 144.13,23.72 143.39,24.46
  IN4 w0.102: v2(314.7,45.2) 314.58,45.2 314.46,45.32 314.46,45.52 314.54,45.6 315.45,45.6 315.77,45.28 315.77,40.63 316.91,39.49 316.91,18.04 312.99,14.11 309.97,14.11 306.23,10.38 305.19,10.38 304.41,9.6 295.26,9.6 293,7.34 268.63,7.34 268.06,7.9 257.36,7.9 254.38,10.88 246.55,10.88 241.87,6.19 169.74,6.19 157.6,18.33 157.6,22.9 155.78,24.72 155.43,24.72 154.54,25.6 152.01,25.6 151.22,24.82 148.51,24.82 146.77,23.08 146.77,22.85 145.97,22.05 145.3,22.05 145.17,22.18 145.17,22.37 145.33,22.53 145.46,22.53 v2(145.53,22.46)
  BOTTOM w0.102: CN201.1 315.29,45.51 315.01,45.51 v2(314.7,45.2)
PCIE_PTX_DRX_P22: length 237.1
  TOP w0.076: 141.5,24.64 141.5,24.66 141.49,24.68 141.49,25.02 141.77,25.31 141.77,25.61 141.88,25.72 142.02,25.72 142.07,25.67 142.07,25.62 UH1.H48
  TOP w0.102: v2(141.72,23.46) 141.41,23.77 141.41,23.94 141.5,24.03 141.5,24.64
  IN4 w0.102: v2(141.72,23.46) 141.48,23.46 141.35,23.33 141.35,22.04 142.05,21.34 146.52,21.34 149.3,24.12 151.51,24.12 152.39,25 154.31,25 155.19,24.12 155.52,24.12 156.98,22.66 156.98,18.12 169.5,5.59 242.13,5.59 246.82,10.28 254.14,10.28 257.11,7.31 267.63,7.31 268.2,6.74 293.44,6.74 295.7,9.01 304.71,9.01 305.32,9.61 306.38,9.61 308.52,11.75 311.52,11.75 317.19,17.42 318.22,17.42 318.54,17.75 318.54,45.26 315.17,48.64 314.57,48.64 314.46,48.53 314.46,48.36 v2(314.7,48.13)
  BOTTOM w0.102: CN199.1 315.29,48.51 315.08,48.51 v2(314.7,48.13)
PCIE_PTX_DRX_P23: length 233.1
  TOP w0.102: UH1.G48 142.74,25.39 142.97,25.16 142.97,24.12 143.96,23.12 143.96,22.7 v2(144.23,22.43)
  IN4 w0.102: v2(144.23,22.43) 143.98,22.43 143.87,22.55 143.87,23.02 144.27,23.42 146.43,23.42 149.02,26.01 154.71,26.01 155.6,25.13 155.95,25.13 158.01,23.06 158.01,18.5 169.91,6.61 241.69,6.61 246.39,11.3 254.53,11.3 257.53,8.31 268.28,8.31 268.78,7.8 292.89,7.8 295.09,10.01 302.86,10.01 303.98,11.12 306.02,11.12 311.57,16.67 313.83,16.67 316.47,19.3 316.47,38.35 313.46,41.36 313.46,51.17 313.82,51.53 314.52,51.53 314.7,51.36 v2(314.7,51.24)
  BOTTOM w0.102: CN197.1 315.29,51.51 314.97,51.51 v2(314.7,51.24)
PCIE_PTX_DRX_P24: length 240.8
  TOP w0.076: 141.94,24.28 141.94,24.3 141.96,24.32 141.96,25.06 142.28,25.38 142.28,26.14 142.18,26.24 142.18,26.56 142.4,26.78 UH1.G45
  TOP w0.102: v2(142.02,22.67) 142.28,22.93 142.28,23.43 141.94,23.78 141.94,24.28
  IN4 w0.102: v2(314.7,54.15) 314.7,54.5 314.82,54.62 315.31,54.62 315.68,54.26 315.68,53.55 315.37,53.24 313.22,53.24 312.54,52.57 312.54,40.59 315.53,37.6 315.53,19.49 313.49,17.45 308.15,17.45 303.72,13.02 303.72,12.03 302.48,10.79 294.77,10.79 292.63,8.65 269.25,8.65 268.8,9.09 257.85,9.09 254.84,12.1 246.06,12.1 241.35,7.39 170.23,7.39 158.96,18.66 158.96,23.22 156.27,25.91 155.95,25.91 154.98,26.89 148.85,26.89 146.09,24.12 143.98,24.12 143.57,23.71 142.63,23.71 142.28,23.36 142.28,22.93 v2(142.02,22.67)
  BOTTOM w0.102: CN195.1 315.3,54.5 315.04,54.5 v2(314.7,54.15)
PCIE_PTX_TRX_N1: length 143.5
  TOP w0.076: UH1.A17 145.28,40.85 145.28,40.99 145.45,41.17 146.71,41.17 146.73,41.15 146.75,41.15
  TOP w0.102: 146.75,41.15 146.97,41.15 147.77,41.95 147.77,42.12 147.93,42.28 148.33,42.28 148.47,42.14 148.47,41.78 148.41,41.72 148.18,41.72 v2(148.13,41.77)
  IN4 w0.102: v2(45.15,37.68) 45.01,37.82 44.83,37.82 44.73,37.73 44.73,37.19 44.84,37.08 45.41,37.08 47.48,39.16 48.66,39.16 49.15,39.64 54.1,39.64 54.68,40.22 54.68,41.39 56.4,43.1 59.75,43.1 60.05,43.41 67.62,43.41 70.28,46.07 83.05,46.07 84.17,44.95 94.8,44.95 96.89,42.86 99.17,42.86 101.58,40.45 109.57,40.45 111.23,38.8 113.36,38.8 114.46,37.7 115.53,37.7 116.02,37.2 116.02,36.69 117.4,35.32 120.55,35.32 121.41,36.18 122.71,36.18 123.85,35.04 123.85,28.86 124.19,28.52 124.86,28.52 125.73,27.65 125.92,27.65 126.27,27.3 126.94,27.3 127.29,26.95 127.95,26.95 128.07,27.08 129.29,27.08 130.14,26.22 131.16,26.22 131.79,26.85 131.79,27.93 132.11,28.26 134.03,28.26 135.12,27.17 136.38,27.17 137.07,26.48 138.02,26.48 138.41,26.87 139.19,26.87 139.52,27.2 140.66,27.2 141.36,27.91 141.36,29.38 142.03,30.05 142.03,30.41 141.85,30.59 141.85,31.2 141.97,31.31 141.97,31.46 141.74,31.68 141.74,32.28 142.34,32.88 143.85,32.88 144.31,33.34 144.31,36.19 145.07,36.94 145.07,37.69 146.82,39.45 146.82,40.96 147.16,41.3 148.36,41.3 148.46,41.4 148.46,41.66 148.35,41.77 v2(148.13,41.77)
  BOTTOM w0.102: v2(45.15,37.68) 44.79,38.04 44.79,38.64 CT3.2
PCIE_PTX_TRX_N2: length 142.1
  TOP w0.076: 146.62,40.02 146.61,40.02 146.59,40 145.93,40 145.84,39.91 145,39.91 144.92,39.83 144.69,39.83 144.65,39.87 144.65,40.08 144.69,40.12 UH1.B18
  TOP w0.102: 146.62,40.02 148.05,40.02 148.33,40.3 148.33,40.65 148.26,40.72 147.96,40.72 v2(147.9,40.65)
  IN4 w0.102: v2(147.9,40.65) 148.24,40.65 148.34,40.55 148.34,40.35 147.89,39.9 147.89,37.54 146.72,36.36 145.64,36.36 144.8,35.52 144.8,29.39 143.93,28.51 143.41,28.51 142.67,29.25 142.24,29.25 141.88,28.89 141.88,27.18 140.84,26.14 138.68,26.14 138.34,25.8 136.43,25.8 136.07,26.16 132.15,26.16 131.65,25.67 129.87,25.67 129.43,26.11 128.08,26.11 127.91,26.28 125.78,26.28 124.26,27.8 123.76,27.8 123.19,28.37 123.19,29.31 119.83,32.67 119.83,33.33 118.64,34.52 117.31,34.52 116.58,35.24 115.49,35.24 113.69,37.05 112.14,37.05 109.42,39.77 101.34,39.77 99.02,42.09 96.8,42.09 94.54,44.35 83.93,44.35 82.81,45.47 70.52,45.47 67.82,42.76 60.45,42.76 60.14,42.46 56.91,42.46 56.03,41.58 56.03,40.35 54.68,39 49.52,39 49.04,38.53 47.7,38.53 45.2,36.03 42.55,36.03 42.23,36.34 42.23,37.47 42.3,37.53 v2(42.69,37.53)
  BOTTOM w0.102: v2(42.69,37.53) 42.35,37.88 42.35,38.66 CT5.2
PCIE_PTX_TRX_N3: length 146.8
  TOP w0.076: UH1.B19 144.81,39.38 144.86,39.33 144.98,39.33 145.18,39.53 146.3,39.53 146.37,39.6 147.57,39.6 147.59,39.62 147.61,39.62
  TOP w0.102: 147.61,39.62 149.2,39.62 149.88,40.3 149.88,40.79 149.76,40.91 149.43,40.91 149.35,40.83 v2(149.35,40.67)
  IN4 w0.102: v2(40.24,37.67) 39.94,37.67 39.83,37.56 39.83,36.97 41.36,35.43 45.46,35.43 47.92,37.89 54.86,37.89 56.94,39.97 56.94,41.2 57.59,41.85 60.7,41.85 61.13,41.43 62.44,41.43 63.09,42.08 68.68,42.08 69.52,42.92 73.05,42.92 73.28,42.69 73.78,42.69 74.01,42.92 78.88,42.92 79.11,43.14 80.86,43.14 81.43,42.57 86.08,42.57 87.24,43.74 94.31,43.74 96.87,41.17 97.79,41.17 99.83,39.13 108.14,39.13 112.14,35.13 112.14,34.43 112.42,34.15 114.15,34.15 114.61,34.62 116.28,34.62 117.29,33.61 117.29,32.92 118.08,32.13 119.2,32.13 122.74,28.6 122.74,27.59 122.99,27.34 122.99,26.48 123.14,26.33 123.51,26.33 124.32,25.52 127.6,25.52 127.72,25.4 128.99,25.4 129.29,25.1 132.3,25.1 132.87,25.68 135.29,25.68 135.88,25.08 138.7,25.08 139.22,25.59 141.88,25.59 145.3,29.01 145.3,33.9 148.46,37.06 148.46,38.46 149.91,39.9 149.91,40.52 149.76,40.67 v2(149.35,40.67)
  BOTTOM w0.102: v2(40.24,37.67) 39.85,38.07 39.85,38.7 CT124.2
PCIE_PTX_TRX_N4: length 154.8
  TOP w0.076: 146.86,39.01 146.85,39.01 146.83,39.02 145.34,39.02 145.18,38.86 144.22,38.86 144.22,38.87 UH1.D20
  TOP w0.102: v2(151.74,40.57) 151.45,40.28 151.45,39.93 151.14,39.61 150.87,39.34 150.43,39.34 150.1,39.01 146.86,39.01
  IN4 w0.102: v2(151.74,40.57) 151.42,40.25 151.42,38.17 146.53,33.28 146.53,31.07 146.64,30.96 146.64,27.57 144.17,25.1 143.31,25.1 142.94,24.73 139.67,24.73 138.14,23.2 131.98,23.2 131.68,22.9 131.16,22.9 130.7,23.35 129.78,23.35 129.26,23.87 127.44,23.87 126.62,24.69 123.87,24.69 123.43,25.13 123.08,25.13 122.31,25.9 122.31,26.89 121.96,27.24 120.67,27.24 120.23,27.69 120.23,28.2 120.65,28.62 120.65,28.98 119,30.63 117.7,30.63 117.06,31.27 116,31.27 115.8,31.46 115.6,31.46 114.06,33.01 109.78,33.01 107.89,34.89 105.98,34.89 104.67,36.2 98.13,36.2 97.03,37.29 97.03,39.91 94.02,42.92 87.64,42.92 86.38,41.66 81.1,41.66 80.46,42.3 79.55,42.3 79.38,42.13 75.49,42.13 73.6,40.24 62.92,40.24 61.96,39.28 61.6,38.93 59.43,38.93 58.24,37.73 57.22,37.73 56.58,37.09 48.36,37.09 45.92,34.65 40.99,34.65 39.56,36.08 37.48,36.08 37.03,36.54 37.03,37.5 36.78,37.75 v2(36.78,37.8)
  BOTTOM w0.102: CT126.2 37.06,38.66 37.06,38.11 36.78,37.83 v2(36.78,37.8)
PCIE_PTX_TRX_P1: length 143.5
  TOP w0.076: UH1.B17 145.12,40.9 145.12,41.06 145.39,41.32 146.71,41.32 146.73,41.34 146.75,41.34
  TOP w0.102: v2(148.84,41.77) 148.66,41.95 148.66,42.22 148.41,42.47 147.85,42.47 147.58,42.2 147.58,42.03 146.89,41.34 146.75,41.34
  IN4 w0.102: v2(148.84,41.77) 148.65,41.58 148.65,41.32 148.44,41.11 147.24,41.11 147.01,40.88 147.01,39.37 145.25,37.61 145.25,36.86 144.5,36.11 144.5,33.26 143.93,32.69 142.42,32.69 141.93,32.2 141.93,31.76 142.16,31.54 142.16,31.24 142.04,31.12 142.04,30.67 142.22,30.49 142.22,29.97 141.55,29.3 141.55,27.83 140.74,27.02 139.6,27.02 139.27,26.68 138.49,26.68 138.09,26.29 136.99,26.29 136.3,26.98 135.05,26.98 133.96,28.07 132.19,28.07 131.98,27.85 131.98,26.77 131.24,26.03 130.06,26.03 129.21,26.89 128.15,26.89 128.03,26.77 127.22,26.77 126.87,27.12 126.19,27.12 125.84,27.46 125.65,27.46 124.78,28.33 124.11,28.33 123.66,28.78 123.66,34.96 122.63,36 121.49,36 120.62,35.13 117.32,35.13 115.84,36.61 115.84,37.12 115.45,37.51 114.38,37.51 113.28,38.61 111.15,38.61 109.5,40.26 101.51,40.26 99.09,42.68 96.81,42.68 94.72,44.76 84.09,44.76 82.97,45.88 70.36,45.88 67.7,43.22 60.13,43.22 59.83,42.92 56.47,42.92 54.87,41.31 54.87,40.15 54.18,39.45 49.22,39.45 48.74,38.97 47.56,38.97 45.49,36.9 44.76,36.9 44.54,37.11 44.54,37.38 v2(44.23,37.68)
  BOTTOM w0.102: v2(44.23,37.68) 44.6,38.05 44.6,38.68 CT2.2
PCIE_PTX_TRX_P2: length 142.1
  TOP w0.076: 146.62,39.83 146.61,39.83 146.59,39.85 146,39.85 145.91,39.76 145.06,39.76 144.98,39.68 144.63,39.68 144.5,39.8 144.5,39.95 UH1.C18
  TOP w0.102: v2(148.74,40.65) 148.52,40.43 148.52,40.22 148.13,39.83 146.62,39.83
  IN4 w0.102: v2(41.75,37.53) 42.05,37.24 42.05,36.26 42.47,35.84 45.28,35.84 47.78,38.34 49.12,38.34 49.59,38.82 54.76,38.82 56.22,40.27 56.22,41.5 56.98,42.27 60.22,42.27 60.53,42.58 67.9,42.58 70.6,45.28 82.73,45.28 83.85,44.16 94.46,44.16 96.72,41.9 98.94,41.9 101.27,39.58 109.34,39.58 112.06,36.86 113.61,36.86 115.41,35.06 116.51,35.06 117.23,34.33 118.57,34.33 119.65,33.25 119.65,32.59 123.01,29.23 123.01,28.29 123.69,27.61 124.18,27.61 125.7,26.09 127.83,26.09 128,25.93 129.35,25.93 129.79,25.48 131.73,25.48 132.23,25.98 135.99,25.98 136.35,25.61 138.42,25.61 138.76,25.95 140.92,25.95 142.07,27.1 142.07,28.82 142.32,29.06 142.59,29.06 143.07,28.58 143.33,28.33 144.01,28.33 144.99,29.31 144.99,35.45 145.72,36.17 146.8,36.17 148.08,37.46 148.08,39.83 148.53,40.28 148.53,40.44 v2(148.74,40.65)
  BOTTOM w0.102: v2(41.75,37.53) 42.15,37.94 42.15,38.65 CT4.2
PCIE_PTX_TRX_P3: length 146.8
  TOP w0.076: UH1.C19 144.75,39.18 145.05,39.18 145.24,39.38 146.36,39.38 146.44,39.45 147.57,39.45 147.59,39.43 147.61,39.43
  TOP w0.102: 147.61,39.43 149.28,39.43 150.07,40.23 150.07,40.47 v2(150.25,40.66)
  IN4 w0.102: v2(150.25,40.66) 150.09,40.5 150.09,39.82 148.65,38.38 148.65,36.98 145.49,33.82 145.49,28.93 141.96,25.4 139.29,25.4 138.78,24.89 135.8,24.89 135.21,25.49 132.95,25.49 132.38,24.92 129.21,24.92 128.92,25.21 127.64,25.21 127.52,25.33 124.24,25.33 123.43,26.14 123.06,26.14 122.8,26.4 122.8,27.27 122.55,27.51 122.55,28.52 119.13,31.94 118,31.94 117.11,32.84 117.11,33.53 116.2,34.43 114.69,34.43 114.22,33.96 112.34,33.96 111.95,34.35 111.95,35.05 108.06,38.94 99.75,38.94 97.71,40.99 96.79,40.99 94.23,43.55 87.32,43.55 86.15,42.38 81.35,42.38 80.78,42.96 79.19,42.96 78.96,42.73 74.09,42.73 73.86,42.5 73.2,42.5 72.97,42.73 69.6,42.73 68.76,41.89 63.17,41.89 62.52,41.24 61.05,41.24 60.63,41.66 57.67,41.66 57.13,41.12 57.13,39.89 54.94,37.7 47.99,37.7 45.54,35.24 41.29,35.24 39.64,36.89 39.64,37.35 39.35,37.65 v2(39.35,37.68)
  BOTTOM w0.102: CT123.2 39.66,38.61 39.66,38.01 39.64,37.99 39.64,37.99 39.35,37.7 v2(39.35,37.68)
PCIE_PTX_TRX_P4: length 154.7
  TOP w0.076: UH1.C20 144.33,39.05 144.36,39.02 145.11,39.02 145.28,39.18 146.84,39.18 146.86,39.2
  TOP w0.102: 146.86,39.2 150.02,39.2 150.36,39.53 150.79,39.53 151.26,40 151.26,40.74 151.17,40.84 150.92,40.84 150.84,40.75 v2(150.84,40.57)
  IN4 w0.102: v2(37.57,37.79) 37.31,37.79 37.21,37.69 37.21,36.62 37.56,36.27 39.64,36.27 41.07,34.84 45.84,34.84 48.28,37.28 56.5,37.28 57.15,37.92 58.16,37.92 59.36,39.12 61.53,39.12 62.84,40.43 73.52,40.43 75.41,42.32 79.31,42.32 79.47,42.48 80.54,42.48 81.18,41.85 86.31,41.85 87.56,43.1 94.1,43.1 97.22,39.99 97.22,37.37 98.2,36.38 104.75,36.38 106.06,35.08 107.97,35.08 109.85,33.2 114.14,33.2 115.68,31.65 115.88,31.65 116.07,31.46 117.14,31.46 117.78,30.82 119.08,30.82 120.84,29.06 120.84,28.54 120.42,28.12 120.42,27.76 120.75,27.43 122.03,27.43 122.5,26.96 122.5,25.98 123.16,25.32 123.51,25.32 123.94,24.88 126.7,24.88 127.52,24.06 129.34,24.06 129.86,23.54 130.78,23.54 131.24,23.09 131.6,23.09 131.9,23.38 138.06,23.38 139.59,24.92 142.86,24.92 143.23,25.29 144.09,25.29 146.45,27.64 146.45,30.89 146.34,31 146.34,33.35 149.51,36.52 151.23,38.24 151.23,40.58 151.1,40.71 150.98,40.71 v2(150.84,40.57)
  BOTTOM w0.102: CT125.2 37.25,38.65 37.25,38.11 v2(37.57,37.79)
PCIE_WAKE#: length 509.4
  TOP w0.109: v2(324.65,31.13) 324.83,31.13 325.27,31.57 325.88,31.57 325.99,31.47 325.99,30.44 325.16,29.61 325.16,19.61 v2(325.8,18.96) ; v2(97.01,68.53) 97.23,68.75 100.07,68.75 101.46,70.14 112.03,70.14 112.83,70.94 116.73,70.94 117.4,70.26 117.4,67.88 118.11,67.18 v2(118.76,67.18) 119.15,67.18 121.03,65.3 121.56,65.3 123.09,63.77 128.33,63.77 128.93,64.37 128.93,64.82 128.69,65.06 128.55,65.06 128.27,65.34 RE275.1 127.69,66 RE274.1 ; v2(327.65,44.46) 329.47,46.29 329.47,54.7 330.07,55.31 332.61,55.31 333.68,56.38 v2(333.68,56.83) ; v2(113.42,61.88) 113.32,61.98 RT448.1 ; JDGFF1.E2 232.67,88.12 232.9,87.89 232.9,87.31 232.64,87.06 v2(232.64,86.56)
  IN1 w0.102: v2(273.63,79.21) 273.91,78.93 273.91,78.36 272.73,77.18 267.99,77.18 266.49,78.69 256.85,78.69 255.85,77.69 241.96,77.69 237.67,81.98 237.67,82.43 236.69,83.4 235.62,83.4 232.64,86.38 v2(232.64,86.56)
  IN2 w0.081: v2(160.96,111.23) 160.37,111.23 158.46,113.14 147.51,113.14 146.81,112.44 146.81,111.61 146.17,110.98 144.56,110.98 141.27,114.26 136.34,114.26 133.63,111.55 133.63,109.2 131.89,107.46 131.18,107.46 130.64,106.92 v2(124.86,106.92) ; v2(113.42,61.88) 113.46,61.88 v2(118.76,67.18) ; v2(327.65,44.46) 328.41,43.7 328.41,40.12 322.81,34.53 322.81,32.72 324.41,31.13 v2(324.65,31.13) ; v2(325.8,18.96) 326.12,18.65 326.12,16.77 321.61,12.26 321.61,2.78 321.85,2.54 325.84,2.54 326.03,2.35 334.21,2.35 334.55,2.69 343.02,2.69 343.47,3.14 349.38,3.14 351.64,5.4 356.13,5.4 361.2,10.47 362.47,10.47 363.4,11.39 364.48,11.39 366.19,13.1 371.37,13.1 372.29,12.18 372.29,11.01 371,9.73 JNGFF4.54
  VCC w0.086: v2(160.96,111.23) 162.52,111.23 163.93,109.82 163.93,101.15 167.04,98.03 178.81,98.03 184.11,92.73 223.24,92.73 224.47,91.5 227.02,91.5 228.73,89.79 228.73,88.01 230.51,86.23 232.31,86.23 v2(232.64,86.56)
  IN3 w0.081: 118.52,91.07 118.9,91.07 119.1,90.87 120.62,90.87 122.08,92.33 122.86,92.33 123.81,93.28 127.7,93.28 v2(128.15,92.83) ; 118.52,91.07 118.52,95.2 120.17,96.84 120.17,103.32 121.41,104.56 122.5,104.56 v2(124.86,106.92) ; 118.52,91.07 118.52,90.45 110.98,82.91 109.75,82.91 97.01,70.17 v2(97.01,68.53) ; v2(333.68,56.83) 333.24,57.27 326.59,57.27 325.9,56.58 322.19,56.58 316.09,62.68 314.64,62.68 311.94,65.39 311.94,71.19 306.98,76.14 303.63,76.14 301.6,78.17 290.7,78.17 289.71,79.16 275.87,79.16 275.49,79.54 274.32,79.54 273.99,79.21 v2(273.63,79.21)
  BOTTOM w0.109: v2(160.96,111.23) 161.03,111.31 161.03,113.2 160.71,113.52 158.63,113.52 158.49,113.66 JNGFF2.46 ; JNGFF6.54 126.04,91.11 127.75,92.83 v2(128.15,92.83) ; JNGFF5.54 327.28,44.11 327.28,44.1 v2(327.65,44.46) ; JNGFF3.54 326.3,18.79 326.13,18.96 v2(325.8,18.96) ; v2(333.68,56.83) v1(334.39,56.83) ; JNGFF1.47 124.26,106.31 v2(124.86,106.92)
PCIE_WAKE#_AR: length 96.5
  TOP w0.109: RT441.2 119.2,63.68 119.2,65.55 119.07,65.67 118.35,65.67 118.12,65.91 113.41,65.91 112.62,66.7 RT622.2 109.16,66.7 108.4,65.95 104.57,65.95 102.6,67.91 v2(98.41,67.91)
  IN4 w0.102: v2(44.5,58.97) 44.52,58.99 45.32,58.99 45.84,58.46 47.38,58.46 47.55,58.3 47.55,56.86 47.78,56.63 48.4,56.63 49.29,55.74 52.73,55.74 53.02,56.03 57.73,56.03 58.05,56.35 59.5,56.35 59.95,56.81 66.69,56.81 67.11,56.39 68.35,56.39 69.1,57.14 85.42,57.14 85.61,57.33 88.12,57.33 92.55,61.76 92.55,64.1 95.76,67.31 97.81,67.31 v2(98.41,67.91)
  BOTTOM w0.076: UT1.Y2 41.32,52.34 41.32,52.8
  BOTTOM w0.109: v2(44.5,58.97) 44.5,57.61 44.93,57.18 RT613.1 44.55,55.13 43.92,55.13 v1(43.32,54.54) 42.92,54.13 42.48,54.13 41.32,52.97 41.32,52.8
PCIE_WAKE#_AR_R: length 3.8
  TOP w0.109: UT32.4 117.75,63.75 117.93,63.58 RT440.2 118.15,63.39 118.55,62.98 RT441.1 v1(120.01,62.29)
PCIE_WAKE#_R: length 23.4
  TOP w0.109: UE1.N13 v2(142.81,69.28) 142.99,69.1 144.07,69.1 144.34,68.84 144.34,68.79 RE35.1 ; RE275.2 129.18,64.23 128.49,63.54 v2(128.49,62.64)
  IN3 w0.081: v2(128.49,62.64) 128.88,63.03 129.84,63.03 130.3,63.49 133.48,63.49 134.18,64.2 135.28,64.2 135.67,64.59 135.7,64.59 135.87,64.76 138.38,64.76 140.46,66.84 141.26,66.84 142.57,68.15 142.57,69.03 v2(142.81,69.28)
PCIECOMP: length 6.3
  TOP w0.109: UH1.A13 145.64,42.92 149.1,42.92 149.4,43.22 v1(150.4,43.22) v2(150.92,43.22)
  BOTTOM w0.109: v2(150.92,43.22) 150.85,43.29 RH192.1
PCIECOMP#: length 7.4
  TOP w0.109: v2(150.57,43.91) 150.21,43.55 v1(149.06,43.55) 148.92,43.55 148.49,43.13 145.47,43.13 145.34,43 UH1.B12
  BOTTOM w0.109: v2(150.57,43.91) 149.93,43.91 RH192.2
PD#: length 11.5
  TOP w0.109: v2(376.39,28.11) 376.39,28.11 CA31.2 376.95,27.74 376.78,27.57 376.25,27.57 376.07,27.75 DA8.2 375.05,27.14 RA48.2 RA50.2 375.1,25.54 375.82,26.26 RA18.2
  TOP w0.203: UA1.2 377.91,24.81 v2(377.87,24.85)
  IN1 w0.102: v2(376.39,28.11) 376.53,28.11 377.99,26.66 377.99,24.97 v2(377.87,24.85)
  BOTTOM w0.109: v2(377.87,24.85) v1(378.4,24.85)
PECI_EC_R: length 3
  TOP w0.109: UE1.K13 142.7,72.05 142.78,71.97 144.14,71.97 v1(144.22,71.88) 144.66,71.44 RE60.1
PEG_COMP: length 7.5
  TOP w0.109: v1(225.75,65.78) 225.75,65.53 226.35,64.94 227,64.94 227.48,65.42 RC2.2
  TOP w0.127: UC1.G2 231.22,64.01 230.03,65.19 228.48,65.19 228.25,65.42 RC2.2
PEG_CRX_C_GTX_N0: length 37.9
  TOP w0.102: JDGFF2.C8 250.9,91.53 251.1,91.53 251.62,92.05 251.62,93.15 252.03,93.56 252.25,93.56 252.37,93.69 v2(252.37,93.92)
  BOTTOM w0.102: CV428.1 236.9,77.98 236.9,78.92 236.01,79.81 235.96,79.81 235.55,80.22 235.55,80.28 234.17,81.65 234.17,82.91 236.28,85.02 238.03,85.02 238.81,85.8 238.81,92.17 239.88,93.24 240.27,93.24 241.97,94.94 251.18,94.94 251.81,94.3 251.81,93.73 251.9,93.64 252.09,93.64 v2(252.37,93.92)
PEG_CRX_C_GTX_N1: length 37.2
  TOP w0.102: v2(252.24,92.4) 252.53,92.1 252.87,92.1 JDGFF2.B9
  BOTTOM w0.102: v2(252.24,92.4) 251.94,92.1 251.76,92.1 250.88,92.98 247.43,92.98 247.21,93.21 247.21,93.84 246.71,94.34 244.94,94.34 244.58,93.97 244.58,92.64 244.16,92.22 244.16,86.39 242.87,85.1 240.01,85.1 239.33,84.42 236.53,84.42 234.97,82.86 234.97,81.89 237.32,79.55 237.32,79.49 237.73,79.08 237.78,79.08 238.2,78.66 238.2,76.27 CV430.1
PEG_CRX_C_GTX_N2: length 24.8
  TOP w0.102: JDGFF2.C5 250.91,89.72 251.15,89.72 251.43,89.43 251.43,89.06 251.57,88.93 251.8,88.93 251.88,89.01 v2(251.88,89.2)
  BOTTOM w0.102: CV432.1 239.24,78.19 239.24,78.74 238.86,79.12 238.86,80.75 237.75,81.85 237.75,83.29 238.25,83.78 v3(239.02,83.78) 239.9,83.78 240.54,84.42 243.03,84.42 246.35,87.73 249.83,87.73 251.11,89.02 251.71,89.02 v2(251.88,89.2)
PEG_CRX_C_GTX_N3: length 28.2
  TOP w0.102: JDGFF2.B6 252.89,90.32 252.54,90.32 252.42,90.2 252.21,90.2 v2(251.83,90.58)
  BOTTOM w0.102: v2(251.83,90.58) 252.12,90.28 252.71,90.28 253.12,89.88 253.12,88.41 252.18,87.47 250.9,87.47 250.35,86.92 249.63,86.92 248.4,85.69 248.4,85.29 247.47,84.36 244.09,84.36 243.36,83.63 241.15,83.63 240.45,82.93 240.45,82.17 239.9,81.63 v3(239.9,80.7) 239.9,79.71 240.04,79.57 240.1,79.57 240.51,79.16 240.51,79.1 240.65,78.96 240.65,75.39 CV434.1
PEG_CRX_C_GTX_N4: length 20.1
  TOP w0.102: JDGFF2.B3 252.88,88.51 252.56,88.51 252.36,88.32 252.36,88.08 251.76,87.48 251.76,86.84 v2(251.58,86.67)
  BOTTOM w0.102: v2(251.58,86.67) 251.81,86.45 251.81,86.13 251.43,85.75 251.43,85.59 250.48,84.64 248.45,84.64 247.72,83.91 245.01,83.91 244.97,83.94 244.38,83.94 244.35,83.91 244.21,83.91 242.45,82.15 242.45,81.61 241.04,80.2 241.04,79.22 241.49,78.77 241.49,77.93 CV436.1
PEG_CRX_C_GTX_N5: length 31.7
  TOP w0.102: JDGFF2.A8 254.27,91.72 254.47,91.52 255.27,91.52 v2(255.67,91.91)
  BOTTOM w0.102: CV438.1 242.73,75.57 242.73,77.65 243.2,78.12 243.2,79.9 243.81,80.51 244.35,80.51 244.6,80.76 244.6,82.35 245.35,83.1 248.03,83.1 248.78,83.85 251.51,83.85 253.57,85.91 253.57,88.02 253.82,88.27 253.82,91.44 253.98,91.6 254.04,91.6 254.45,92.01 254.45,92.07 254.86,92.48 255.86,92.48 256.32,92.01 256.32,91.64 256.14,91.45 255.42,91.45 255.32,91.56 255.32,91.71 255.53,91.91 v2(255.67,91.91)
PEG_CRX_C_GTX_N6: length 23.9
  TOP w0.102: JDGFF2.A5 254.51,89.92 254.77,89.66 255.84,89.66 v2(256.14,89.96)
  BOTTOM w0.102: CV440.1 243.72,77.5 243.72,78.06 243.97,78.31 243.97,78.36 244.39,78.77 244.44,78.77 245.08,79.42 245.08,80.07 245.61,80.6 246.07,80.6 246.29,80.82 246.29,82.17 246.8,82.68 248.18,82.68 248.95,83.45 251.69,83.45 253.25,85.01 v3(253.46,85.21) 253.98,85.74 253.98,87.75 254.24,88.02 254.24,89.42 254.65,89.83 256.01,89.83 v2(256.14,89.96)
PEG_CRX_C_GTX_N7: length 23.6
  TOP w0.102: JDGFF2.A2 254.21,87.92 254.36,87.92 254.79,88.35 255.35,88.35 255.57,88.56 v2(255.57,88.68)
  BOTTOM w0.102: v2(255.57,88.68) 255.85,88.39 255.99,88.39 256.23,88.15 256.23,87.23 256.22,87.21 256.22,86.44 255.57,85.79 255.23,85.79 252.07,82.63 249.24,82.63 248.62,82.01 248.62,80.67 248.41,80.46 247.7,80.46 247.19,79.95 247.19,79.24 246.3,78.35 246.3,78.28 245.86,77.84 245.8,77.84 245.22,77.27 245.22,74.6 CV442.1
PEG_CRX_C_GTX_N8: length 28.2
  TOP w0.102: v2(257.22,91.75) 257.22,91.62 257.39,91.44 257.67,91.44 257.95,91.72 JDGFF3.H8
  BOTTOM w0.102: CV444.1 247.37,74.74 247.37,77.52 247.79,77.93 248.82,77.93 249.86,78.97 253.26,78.97 254.86,80.57 254.86,83.73 255.72,84.59 257.43,84.59 258.82,85.98 258.82,89.86 258.86,89.89 258.86,90.48 258.82,90.51 258.82,90.83 258.2,91.44 257.53,91.44 v2(257.22,91.75)
PEG_CRX_C_GTX_N9: length 23.9
  TOP w0.102: JDGFF3.H5 258.08,89.92 257.8,89.64 257.31,89.64 257.07,89.89 v2(257.07,89.97)
  BOTTOM w0.102: v2(257.07,89.97) 257.36,89.68 257.74,89.68 258.22,89.2 v3(258.22,88.04) 258.22,86.23 257.19,85.19 255.48,85.19 254.19,83.9 254.19,81.97 253.14,80.92 251.77,80.92 251.59,80.74 250.12,80.74 249.92,80.53 249.92,79.89 248.6,78.56 247.53,78.56 246.23,77.26 246.23,76.96 CV446.1
PEG_CRX_C_GTX_N10: length 22.3
  TOP w0.102: JDGFF3.H2 257.99,87.92 257.65,87.92 257.4,88.17 256.68,88.17 255.99,87.48 255.99,86.23 256.78,85.45 256.78,83.62 v2(256.54,83.38)
  BOTTOM w0.102: CV448.1 248.51,76.9 248.51,77.14 248.7,77.33 249.11,77.33 250.15,78.37 253.51,78.37 255.46,80.32 255.46,83.48 255.96,83.99 256.92,83.99 257,83.91 257,83.36 256.89,83.25 256.67,83.25 v2(256.54,83.38)
PEG_CRX_C_GTX_N11: length 25.4
  TOP w0.102: v2(260.31,91.19) 260.31,91.11 260.04,90.84 259.86,90.84 259.64,90.62 259.64,90.42 259.54,90.31 259.32,90.31 JDGFF3.G6
  BOTTOM w0.102: v2(260.31,91.19) 260.12,91 259.69,91 259.33,90.64 259.33,86.11 259.3,86.07 259.3,85.49 259.33,85.45 v3(259.33,84.37) 259.33,83.62 253.68,77.97 250.35,77.97 249.35,76.97 249.35,74.74 CV450.1
PEG_CRX_C_GTX_N12: length 20.4
  TOP w0.102: v2(260.3,88.1) 259.98,87.79 259.89,87.79 259.85,87.83 259.85,88.26 259.59,88.52 259.31,88.52 JDGFF3.G3
  BOTTOM w0.102: CV452.1 250.79,76.91 250.79,77.06 250.91,77.18 254.01,77.18 261.44,84.61 v3(261.44,85.68) 261.44,86.73 260.96,87.21 260.96,87.59 260.74,87.81 260.59,87.81 v2(260.3,88.1)
PEG_CRX_C_GTX_N13: length 39.5
  TOP w0.102: v2(260.45,93.97) 260.45,93.87 260.2,93.62 259.92,93.62 259.64,93.34 259.64,92.21 259.54,92.1 259.33,92.1 JDGFF3.G9
  BOTTOM w0.102: CV454.1 253.79,74.92 253.79,75.22 254.33,75.75 254.33,75.81 262.94,84.42 267,84.42 268.17,85.59 268.17,92.78 267.94,93 267.94,93.73 267.39,94.28 266.45,94.28 266.1,93.93 266.1,93.47 265.62,92.99 261.63,92.99 260.92,93.71 260.72,93.71 v2(260.45,93.97)
PEG_CRX_C_GTX_N14: length 23.1
  TOP w0.102: JDGFF3.F5 261.24,89.92 261,89.68 260.84,89.68 260.77,89.61 260.6,89.61 v2(260.23,89.98)
  BOTTOM w0.102: v2(260.23,89.98) 260.52,89.69 260.71,89.69 261.26,89.14 261.26,88.66 262.52,87.41 262.52,84.85 254.01,76.34 252.88,76.34 v3(252.44,75.9) 251.99,75.45 251.99,74.94 CV456.1
PEG_CRX_C_GTX_N15: length 41.8
  TOP w0.102: JDGFF3.F8 261.29,91.52 261.11,91.52 260.96,91.67 260.96,91.97 260.75,92.17 260.61,92.17 260.55,92.23 260.55,92.32 v2(260.86,92.63)
  BOTTOM w0.102: CV458.1 255.36,75.95 255.36,76.27 256,76.91 256.08,76.98 263.02,83.92 266.1,83.92 266.14,83.96 266.72,83.96 266.76,83.92 267.2,83.92 268.58,85.3 268.58,88.81 268.92,89.16 268.92,93.59 267.82,94.69 259.8,94.69 259.26,94.15 259.26,93.57 260.64,92.19 260.82,92.19 260.95,92.32 260.95,92.54 v2(260.86,92.63)
PEG_CRX_C_GTX_P0: length 37.8
  TOP w0.102: v2(252.37,93.04) 252.37,93.29 252.28,93.37 252.11,93.37 251.81,93.07 251.81,91.98 251.18,91.34 250.93,91.34 JDGFF2.C7
  BOTTOM w0.102: CV427.1 237.09,78.18 237.09,79 v3(235.91,80.18) 234.36,81.73 234.36,82.83 236.36,84.83 238.11,84.83 239,85.72 239,92.09 239.96,93.05 240.35,93.05 242.05,94.75 251.1,94.75 251.62,94.22 251.62,93.65 251.82,93.45 252.26,93.45 252.37,93.34 v2(252.37,93.04)
PEG_CRX_C_GTX_P1: length 37.1
  TOP w0.102: JDGFF2.B8 252.9,91.91 252.55,91.91 252.35,91.71 v2(252.35,91.53)
  BOTTOM w0.102: v2(252.35,91.53) 252.35,91.81 252.25,91.91 251.68,91.91 250.8,92.79 247.35,92.79 247.02,93.13 247.02,93.76 246.63,94.15 245.02,94.15 244.77,93.89 244.77,92.56 244.35,92.14 244.35,86.31 242.95,84.91 240.09,84.91 239.41,84.23 236.61,84.23 235.16,82.78 235.16,81.97 v3(237.68,79.45) 238.39,78.74 238.39,76.24 CV429.1
PEG_CRX_C_GTX_P2: length 24.7
  TOP w0.102: JDGFF2.C4 250.92,89.53 251.07,89.53 251.24,89.35 251.24,88.98 251.49,88.74 251.66,88.74 v2(251.99,88.41)
  BOTTOM w0.102: CV431.1 239.43,78.23 239.43,78.82 239.05,79.2 239.05,80.83 237.94,81.93 237.94,83.21 238.33,83.59 238.69,83.59 238.73,83.56 239.32,83.56 239.35,83.59 239.98,83.59 240.61,84.23 243.11,84.23 246.43,87.54 249.9,87.54 251.19,88.83 251.53,88.83 v2(251.99,88.41)
PEG_CRX_C_GTX_P3: length 28.2
  TOP w0.102: JDGFF2.B5 252.89,90.12 252.62,90.12 252.5,90.01 252.01,90.01 v2(251.77,89.78)
  BOTTOM w0.102: v2(251.77,89.78) 251.77,90.02 251.85,90.09 252.63,90.09 252.93,89.8 252.93,88.49 252.1,87.66 250.82,87.66 250.27,87.11 249.55,87.11 248.21,85.77 248.21,85.37 247.39,84.55 244.01,84.55 243.28,83.82 241.07,83.82 240.26,83.01 240.26,82.25 239.71,81.7 239.71,81.03 239.67,80.99 239.67,80.41 239.71,80.37 239.71,79.63 v3(240.14,79.2) 240.46,78.88 240.46,75.59 CV433.1
PEG_CRX_C_GTX_P4: length 20.1
  TOP w0.102: v2(252.38,86.63) 252.3,86.63 251.95,86.99 251.95,87.4 252.55,88 252.55,88.24 252.63,88.32 253.01,88.32 253.09,88.25 JDGFF2.B2
  BOTTOM w0.102: v2(252.38,86.63) 252,86.25 252,86.05 251.62,85.67 251.62,85.51 250.56,84.45 248.53,84.45 247.8,83.72 v3(244.68,83.72) 244.29,83.72 242.64,82.07 242.64,81.53 241.23,80.12 241.23,79.3 241.68,78.85 241.68,77.89 CV435.1
PEG_CRX_C_GTX_P5: length 31.7
  TOP w0.102: JDGFF2.A7 254.25,91.12 254.45,91.32 255.35,91.32 v2(255.7,90.97)
  BOTTOM w0.102: v2(255.7,90.97) 255.99,91.26 256.22,91.26 256.51,91.56 256.51,92.09 255.94,92.67 254.78,92.67 v3(254.08,91.97) 253.63,91.52 253.63,88.35 253.38,88.1 253.38,85.99 251.44,84.04 248.7,84.04 247.95,83.29 245.28,83.29 244.41,82.42 244.41,80.84 244.27,80.7 243.73,80.7 243.01,79.98 243.01,78.2 242.54,77.73 242.54,75.43 CV437.1
PEG_CRX_C_GTX_P6: length 23.9
  TOP w0.102: v2(256.14,89.09) 255.76,89.47 254.67,89.47 254.51,89.32 JDGFF2.A4
  BOTTOM w0.102: CV439.1 243.91,77.56 243.91,77.98 v3(244.34,78.4) 245.27,79.34 245.27,79.99 245.69,80.41 246.15,80.41 246.48,80.74 246.48,82.09 246.88,82.49 248.26,82.49 249.03,83.26 251.77,83.26 253.35,84.84 253.41,84.84 253.83,85.26 253.83,85.32 254.17,85.66 254.17,87.67 254.43,87.94 254.43,89.34 254.73,89.64 255.78,89.64 256.14,89.28 v2(256.14,89.09)
PEG_CRX_C_GTX_P7: length 23.6
  TOP w0.102: JDGFF2.A1 254.22,87.73 254.44,87.73 254.87,88.16 255.34,88.16 v2(255.63,87.87)
  BOTTOM w0.102: CV441.1 245.03,74.87 245.03,77.35 v3(245.89,78.21) 246.17,78.48 247,79.32 247,80.03 247.62,80.65 248.33,80.65 248.43,80.75 248.43,82.09 249.16,82.82 251.99,82.82 255.15,85.98 255.49,85.98 256.03,86.52 256.03,87.29 256.04,87.3 256.04,88.08 255.92,88.2 255.66,88.2 255.53,88.07 255.53,87.97 v2(255.63,87.87)
PEG_CRX_C_GTX_P8: length 28.2
  TOP w0.102: JDGFF3.H7 257.96,91.12 257.83,91.25 257.43,91.25 257.09,90.91 v2(257.09,90.91)
  BOTTOM w0.102: v2(257.09,90.91) 257.09,91.17 257.17,91.25 258.13,91.25 258.63,90.75 v3(258.63,90.18) 258.63,86.06 257.36,84.78 255.64,84.78 254.67,83.81 254.67,80.65 253.18,79.16 249.78,79.16 248.74,78.12 247.71,78.12 247.18,77.6 247.18,74.74 CV443.1
PEG_CRX_C_GTX_P9: length 24
  TOP w0.102: v2(256.97,89.06) 257.35,89.45 257.83,89.45 257.95,89.32 JDGFF3.H4
  BOTTOM w0.102: CV445.1 246.03,76.93 246.03,77.33 247.45,78.75 248.52,78.75 249.73,79.96 249.73,80.61 250.05,80.93 251.51,80.93 251.69,81.11 253.06,81.11 254,82.05 254,83.98 255.4,85.38 257.11,85.38 258.03,86.3 258.03,87.71 258,87.75 258,88.33 258.03,88.37 258.03,89.12 257.66,89.49 257.06,89.49 256.97,89.4 v2(256.97,89.06)
PEG_CRX_C_GTX_P10: length 22.3
  TOP w0.102: JDGFF3.H1 257.98,87.73 257.57,87.73 257.32,87.98 256.76,87.98 256.18,87.4 256.18,86.31 256.97,85.53 256.97,83.61 257.17,83.4 257.34,83.4 v2(257.48,83.54)
  BOTTOM w0.102: CV447.1 248.32,76.89 248.32,77.22 248.62,77.52 249.03,77.52 250.07,78.56 253.43,78.56 255.27,80.4 255.27,83.56 255.88,84.18 257,84.18 257.19,83.99 257.19,83.83 v2(257.48,83.54)
PEG_CRX_C_GTX_P11: length 25.4
  TOP w0.102: v2(260.54,90.65) 259.94,90.65 259.83,90.54 259.83,90.34 259.62,90.12 259.31,90.12 JDGFF3.G5
  BOTTOM w0.102: CV449.1 249.54,74.98 249.54,76.89 250.43,77.78 253.76,77.78 259.52,83.54 259.52,84.04 259.56,84.08 259.56,84.66 259.52,84.7 v3(259.52,85.78) 259.52,90.57 259.77,90.81 260.02,90.81 260.18,90.65 v2(260.54,90.65)
PEG_CRX_C_GTX_P12: length 20.5
  TOP w0.102: JDGFF3.G2 259.32,88.33 259.51,88.33 259.66,88.18 259.66,87.75 259.81,87.6 259.94,87.6 v2(260.3,87.24)
  BOTTOM w0.102: CV451.1 250.6,76.88 250.6,77.14 250.83,77.37 253.93,77.37 261.25,84.69 261.25,85.35 261.21,85.38 261.21,85.97 261.25,86.01 261.25,86.65 260.77,87.13 260.77,87.52 260.66,87.62 260.3,87.62 260.2,87.52 260.2,87.34 v2(260.3,87.24)
PEG_CRX_C_GTX_P13: length 39.5
  TOP w0.102: JDGFF3.G8 259.3,91.91 259.62,91.91 259.83,92.13 259.83,93.26 260,93.43 260.2,93.43 260.44,93.19 v2(260.44,93.07)
  BOTTOM w0.102: CV453.1 253.6,75.06 253.6,75.35 v3(253.96,75.71) 262.86,84.61 266.92,84.61 267.98,85.67 267.98,92.7 267.75,92.93 267.75,93.65 267.31,94.09 266.53,94.09 266.29,93.86 266.29,93.4 265.7,92.8 261.55,92.8 260.84,93.52 260.61,93.52 260.44,93.35 v2(260.44,93.07)
PEG_CRX_C_GTX_P14: length 23.1
  TOP w0.102: JDGFF3.F4 261.25,89.32 261.08,89.49 260.91,89.49 260.85,89.42 260.47,89.42 v2(260.17,89.12)
  BOTTOM w0.102: v2(260.17,89.12) 260.17,89.44 260.23,89.5 260.64,89.5 261.07,89.06 261.07,88.58 262.33,87.33 262.33,84.93 253.93,76.53 252.8,76.53 252.54,76.27 252.49,76.27 252.07,75.86 252.07,75.81 251.8,75.53 251.8,75.03 CV455.1
PEG_CRX_C_GTX_P15: length 41.8
  TOP w0.102: JDGFF3.F7 261.28,91.33 261.03,91.33 260.76,91.59 260.76,91.89 260.7,91.96 260.51,91.96 v2(260.33,91.78)
  BOTTOM w0.102: v2(260.33,91.78) 260.33,92.23 259.07,93.49 259.07,94.23 259.72,94.88 267.89,94.88 269.11,93.66 269.11,89.08 268.77,88.73 268.77,85.22 267.28,83.73 v3(266.43,83.73) 263.1,83.73 255.55,76.19 255.55,75.95 CV457.1
PEG_CRX_GTX_N0: length 14.4
  TOP w0.102: v2(236.84,65.03) 237.17,65.35 UC1.E10
  BOTTOM w0.076: v2(236.84,65.03) 237.02,65.03 237.16,65.17 237.16,65.37 236.81,65.71 236.44,65.71 236.13,66.02 236.13,66.82 236.11,66.84
  BOTTOM w0.102: CV428.2 237,76.79 237,74.06 236.96,74.02 236.96,73.43 237,73.4 237,72.12 236.36,71.48 236.36,71.01 235.75,70.4 235.75,67.63 236.11,67.26 236.11,66.84
PEG_CRX_GTX_N1: length 11.4
  TOP w0.102: v2(237.64,65.62) 237.69,65.62 237.96,65.35 UC1.E11
  BOTTOM w0.076: 236.61,68.04 236.61,68.03 236.62,68.01 236.62,67.65 236.93,67.35 236.93,66.91 237.16,66.68 237.16,66.05 237.53,65.68 237.58,65.68 v2(237.64,65.62)
  BOTTOM w0.102: CV430.2 238.17,74.98 238.17,74.02 237.76,73.61 v3(237.76,72.39) 237.76,69.85 236.61,68.7 236.61,68.04
PEG_CRX_GTX_N2: length 13.8
  TOP w0.102: UC1.E12 238.87,65.41 238.87,65.54 238.66,65.75 238.49,65.75 v2(238.42,65.68)
  BOTTOM w0.076: v2(238.42,65.68) 238.42,65.61 238.48,65.55 238.57,65.55 238.62,65.6 238.7,65.72 238.7,66.71 238.83,66.84 238.83,67.34 238.81,67.36 238.81,67.37
  BOTTOM w0.102: CV432.2 239.34,76.84 239.34,74.18 v3(238.96,73.8) 238.45,73.29 238.45,69.32 238.14,69 238.14,68.16 238.81,67.48 238.81,67.37
PEG_CRX_GTX_N3: length 10.1
  TOP w0.102: UC1.E13 239.53,65.35 v2(239.21,65.68)
  BOTTOM w0.076: v2(239.21,65.68) 239.64,66.31 239.64,66.73 239.71,66.8 239.71,67.15 239.72,67.16 239.72,67.2 239.75,67.22 239.75,67.23
  BOTTOM w0.102: 239.75,67.23 239.75,67.82 239.73,67.84 239.73,72.61 239.87,72.76 v3(240.15,73.03) 240.62,73.51 240.62,74.28 CV434.2
PEG_CRX_GTX_N4: length 13.2
  TOP w0.076: v2(240,65.68) 240.07,65.75 240.23,65.75 240.46,65.52 240.46,65.42 UC1.E14
  BOTTOM w0.076: 240.76,68.96 240.76,68.95 240.78,68.93 240.78,68.29 240.41,67.92 240.41,66.24 240.28,66.11 240.28,65.7 240.22,65.62 240.14,65.55 240.05,65.55 240,65.6 v2(240,65.68)
  BOTTOM w0.102: CV436.2 241.56,76.53 241.56,72.88 240.76,72.07 v3(240.76,71.27) 240.76,68.96
PEG_CRX_GTX_N5: length 11
  TOP w0.102: v2(240.78,65.03) 241.11,65.35 UC1.E15
  BOTTOM w0.076: v2(240.78,65.03) 241.22,65.66 241.22,67.68 241.51,67.97 241.51,69.03 241.63,69.15 241.63,69.36 241.65,69.38 241.65,69.4
  BOTTOM w0.102: CV438.2 242.79,74.2 242.79,73.56 242.83,73.52 242.83,72.94 242.79,72.9 242.79,72.66 v3(242.04,71.91) 241.77,71.64 241.65,71.52 241.65,69.4
PEG_CRX_GTX_N6: length 13.1
  TOP w0.076: v2(241.57,65.68) 241.67,65.78 241.81,65.78 242.01,65.57 242.01,65.41 UC1.E16
  BOTTOM w0.076: v2(241.57,65.68) 241.57,65.63 241.65,65.55 241.72,65.55 241.8,65.63 241.85,65.7 241.85,66.03 241.97,66.16 241.97,67.91 242.37,68.31 242.37,69.09 242.35,69.11
  BOTTOM w0.102: CV440.2 243.72,76.28 243.72,72.85 242.35,71.47 v3(242.35,70.61) 242.35,69.11
PEG_CRX_GTX_N7: length 11
  TOP w0.076: v2(242.36,65.03) 242.68,65.35 UC1.E17
  BOTTOM w0.076: 243.3,69.38 243.28,69.36 243.28,68.98 243.11,68.8 243.11,67.83 242.78,67.5 242.78,66.25 243.08,65.95 243.08,65.56 242.73,65.22 242.55,65.22 v2(242.36,65.03)
  BOTTOM w0.102: CV442.2 245.18,73.55 245.18,72.8 245.05,72.67 245.05,72.6 244.66,72.21 244.59,72.21 v3(243.81,71.43) 243.3,70.92 243.3,69.38
PEG_CRX_GTX_N8: length 12
  TOP w0.076: UC1.F18 243.47,64.7 v2(243.15,64.38)
  BOTTOM w0.076: v2(243.15,64.38) 243.35,64.58 243.56,64.58 244.47,65.5 244.47,67.43 244.74,67.7 244.74,68.91 244.76,68.93 244.76,68.94
  BOTTOM w0.102: CV444.2 247.46,73.54 247.46,72.71 247.04,72.29 247.04,72.24 246.63,71.83 246.58,71.83 244.97,70.22 244.97,69.46 244.76,69.25 244.76,68.94
PEG_CRX_GTX_N9: length 12.4
  TOP w0.102: v2(243.93,66.33) 244.26,66 UC1.D19
  BOTTOM w0.076: v2(243.93,66.33) 243.93,66.09 243.88,66.03 243.63,66.03 243.5,66.16 243.5,66.53 243.77,66.8 243.77,67.25 243.77,67.58 244.15,67.96 244.15,68.98 244.17,69 244.17,69.01
  BOTTOM w0.102: CV446.2 246.19,75.58 246.19,72.88 244.17,70.86 v3(244.17,70.06) 244.17,69.01
PEG_CRX_GTX_N10: length 13.8
  TOP w0.102: v2(244.72,64.38) 245.05,64.7 UC1.F20
  BOTTOM w0.076: 245.33,67.38 245.33,67.36 245.31,67.34 245.31,67.09 245.15,66.93 245.15,65.04 v2(244.72,64.38)
  BOTTOM w0.102: CV448.2 248.5,75.59 248.5,72.71 246.58,70.79 246.58,70.74 246.17,70.33 246.11,70.33 245.75,69.96 245.75,68.24 245.33,67.82 245.33,67.38
PEG_CRX_GTX_N11: length 11.3
  TOP w0.102: v2(245.51,65.68) 245.59,65.6 245.71,65.6 245.95,65.83 245.95,65.96 UC1.D21
  BOTTOM w0.076: 246.41,69.43 246.41,69.2 246.14,68.93 246.14,67.93 245.72,67.51 245.72,66.67 245.91,66.49 245.91,66.13 245.79,66.01 245.79,65.72 245.71,65.6 245.66,65.55 245.57,65.55 245.51,65.6 v2(245.51,65.68)
  BOTTOM w0.102: CV450.2 249.53,73.52 249.53,73.06 247.75,71.27 247.69,71.27 247.18,70.77 247.18,70.7 247.07,70.59 246.41,69.94 246.41,69.43
PEG_CRX_GTX_N12: length 13.6
  TOP w0.102: v2(246.3,65.03) 246.62,64.7 UC1.F22
  BOTTOM w0.076: v2(246.3,65.03) 246.5,65.23 246.6,65.23 246.88,65.51 246.88,67.55 247.14,67.82 247.14,68.07 247.36,68.29 247.36,68.97 247.38,68.99
  BOTTOM w0.102: CV452.2 250.86,75.67 250.86,73.12 250.53,72.79 v3(250.09,72.34) 249.38,71.64 249.38,71.59 248.97,71.18 248.92,71.18 247.38,69.63 247.38,68.99
PEG_CRX_GTX_N13: length 12.2
  TOP w0.076: UC1.D23 247.8,66.33 v2(247.87,66.33)
  BOTTOM w0.076: 248.43,67.31 248.41,67.29 248.41,67.02 248.1,66.72 248.1,66.62 248.28,66.44 248.28,66.21 248.1,66.03 247.93,66.03 247.87,66.09 v2(247.87,66.33)
  BOTTOM w0.102: 248.43,67.31 248.43,67.72 249.18,68.47 249.18,69.59 249.72,70.13 251.86,72.28 252.39,72.28 252.88,72.76 252.88,72.82 253.05,72.99 253.46,72.99 253.65,73.18 253.65,73.64 CV454.2
PEG_CRX_GTX_N14: length 13.9
  TOP w0.102: v2(247.87,65.03) 248.19,64.7 UC1.F24
  BOTTOM w0.076: v2(247.87,65.03) 248.06,65.22 248.21,65.22 248.28,65.14 248.28,64.85 247.97,64.54 247.74,64.54 247.35,64.93 247.35,65.71 247.19,65.87 247.19,66.79 247.74,67.34 247.74,67.89 247.98,68.12 247.98,68.88 248,68.9 248,68.92
  BOTTOM w0.102: CV456.2 251.95,73.71 251.95,73.13 251.7,72.88 251.58,72.88 248.45,69.75 248.45,69.69 248,69.24 248,68.92
PEG_CRX_GTX_N15: length 14.4
  TOP w0.102: UC1.D25 248.98,66 v2(248.66,66.33)
  BOTTOM w0.076: 249.1,67.61 249.09,67.6 249.09,67.57 248.85,67.33 248.85,66.72 249.13,66.44 249.13,66.19 249.02,66.07 248.91,66.07 v2(248.66,66.33)
  BOTTOM w0.102: CV458.2 255.36,74.67 255.36,73.44 v3(254.83,72.91) 254.5,72.57 253.49,72.57 252.79,71.87 252.07,71.87 249.99,69.78 249.99,68.99 250.26,68.72 250.26,68.35 249.99,68.09 249.58,68.09 249.1,67.61
PEG_CRX_GTX_P0: length 14.4
  TOP w0.102: v2(237.63,65.03) 237.56,65.03 UC1.F10
  BOTTOM w0.076: v2(237.63,65.03) 237.45,65.03 237.31,65.16 237.31,65.43 236.88,65.87 236.5,65.87 236.28,66.08 236.28,66.81 236.3,66.83 236.3,66.84
  BOTTOM w0.102: CV427.2 237.19,76.79 v3(237.19,73.73) 237.19,72.04 236.55,71.4 236.55,70.93 235.94,70.32 235.94,67.71 236.3,67.34 236.3,66.84
PEG_CRX_GTX_P1: length 11.5
  TOP w0.102: v2(237.68,66.33) 238.01,66 UC1.D11
  BOTTOM w0.076: v2(237.68,66.33) 237.68,66.07 237.61,65.99 237.43,65.99 237.31,66.12 237.31,66.74 237.08,66.97 237.08,67.41 236.78,67.72 236.78,68.01 236.8,68.04
  BOTTOM w0.102: CV429.2 238.36,74.95 238.36,73.94 237.95,73.53 237.95,72.72 237.99,72.68 237.99,72.1 237.95,72.06 237.95,69.77 236.8,68.62 236.8,68.04
PEG_CRX_GTX_P2: length 13.9
  TOP w0.102: v2(238.42,65.03) 238.75,64.7 UC1.F12
  BOTTOM w0.076: v2(238.42,65.03) 238.85,65.67 238.85,65.67 238.85,66.64 238.99,66.77 238.99,67.35 239,67.37
  BOTTOM w0.102: 239,67.37 239,67.56 238.33,68.24 238.33,68.93 238.64,69.24 238.64,73.22 238.86,73.43 238.92,73.43 239.33,73.85 239.33,73.9 239.53,74.1 239.53,76.99 CV431.2
PEG_CRX_GTX_P3: length 10.1
  TOP w0.102: UC1.D13 239.62,66.02 239.62,66.31 239.56,66.37 239.25,66.37 v2(239.21,66.33)
  BOTTOM w0.076: v2(239.21,66.33) 239.21,66.24 239.27,66.18 239.34,66.18 239.42,66.26 239.49,66.36 239.49,66.8 239.56,66.87 239.56,67.23
  BOTTOM w0.102: 239.56,67.23 239.56,67.75 239.54,67.76 239.54,72.69 239.78,72.94 239.78,72.99 240.19,73.4 240.25,73.4 240.43,73.59 240.43,74.13 CV433.2
PEG_CRX_GTX_P4: length 13.3
  TOP w0.076: UC1.F14 240.06,65.03 v2(240,65.03)
  BOTTOM w0.076: 240.95,68.96 240.95,68.95 240.93,68.93 240.93,68.23 240.56,67.85 240.56,66.18 240.43,66.04 240.43,65.66 v2(240,65.03)
  BOTTOM w0.102: CV435.2 241.76,76.72 241.76,72.8 240.95,71.99 240.95,71.6 240.99,71.57 240.99,70.98 240.95,70.94 240.95,68.96
PEG_CRX_GTX_P5: length 11
  TOP w0.102: v2(240.78,65.68) 240.74,65.72 240.74,66.05 240.87,66.18 240.99,66.18 UC1.D15
  BOTTOM w0.076: 241.46,69.45 241.48,69.43 241.48,69.21 241.35,69.09 241.35,68.03 241.06,67.74 241.06,65.71 240.99,65.61 240.98,65.6 240.86,65.6 v2(240.78,65.68)
  BOTTOM w0.102: CV437.2 242.6,74.22 v3(242.6,73.23) 242.6,72.74 242.14,72.28 242.09,72.28 241.67,71.87 241.67,71.82 241.46,71.6 241.46,69.45
PEG_CRX_GTX_P6: length 13.2
  TOP w0.076: UC1.F16 v2(241.57,65.03)
  BOTTOM w0.076: 242.54,69.11 242.54,69.1 242.52,69.08 242.52,68.24 242.13,67.85 242.13,66.09 242,65.97 242,65.65 v2(241.57,65.03)
  BOTTOM w0.102: CV439.2 243.91,76.21 243.91,72.77 242.54,71.39 242.54,70.94 242.58,70.91 242.58,70.32 242.54,70.28 242.54,69.11
PEG_CRX_GTX_P7: length 11
  TOP w0.076: UC1.D17 242.68,66 v2(242.36,65.68)
  BOTTOM w0.076: 243.11,69.38 243.13,69.36 243.13,69.04 242.95,68.86 242.95,67.89 242.62,67.56 242.62,66.19 242.92,65.89 242.92,65.62 242.67,65.37 242.47,65.37 242.36,65.48 v2(242.36,65.68)
  BOTTOM w0.102: CV441.2 244.99,73.36 244.99,72.88 v3(244.69,72.57) 243.93,71.82 243.88,71.82 243.41,71.35 243.41,71.29 243.11,71 243.11,69.38
PEG_CRX_GTX_P8: length 12
  TOP w0.102: UC1.E18 243.47,65.35 v2(243.15,65.03)
  BOTTOM w0.076: v2(243.15,65.03) 243.15,64.79 243.2,64.73 243.49,64.73 244.32,65.56 244.32,67.5 244.59,67.77 244.59,68.91 244.57,68.93 244.57,68.94
  BOTTOM w0.102: CV443.2 247.27,73.37 247.27,72.79 v3(246.68,72.2) 244.78,70.3 244.78,69.54 244.57,69.33 244.57,68.94
PEG_CRX_GTX_P9: length 12.5
  TOP w0.102: v2(243.93,65.68) 244.26,65.35 UC1.E19
  BOTTOM w0.076: v2(243.93,65.68) 243.73,65.88 243.56,65.88 243.35,66.09 243.35,66.59 243.62,66.86 243.62,67.19 243.62,67.19 243.62,67.64 243.99,68.02 243.99,68.98 243.98,69 243.98,69.01
  BOTTOM w0.102: 243.98,69.01 243.98,69.73 243.94,69.76 243.94,70.35 243.98,70.39 243.98,70.94 246,72.96 246,75.69 CV445.2
PEG_CRX_GTX_P10: length 13.8
  TOP w0.102: v2(244.72,65.03) 244.72,65.39 244.84,65.52 244.95,65.52 UC1.E20
  BOTTOM w0.076: v2(244.72,65.03) 244.72,64.94 244.78,64.89 244.85,64.89 244.91,64.94 245,65.08 245,66.99 245.16,67.15 245.16,67.38 245.14,67.39
  BOTTOM w0.102: CV447.2 248.31,75.63 248.31,72.79 247.42,71.9 247.42,71.9 v3(246.21,70.69) 245.56,70.04 245.56,68.32 245.14,67.9 245.14,67.39
PEG_CRX_GTX_P11: length 11.4
  TOP w0.102: v2(245.51,65.03) 245.83,65.35 UC1.E21
  BOTTOM w0.076: 246.6,69.43 246.6,69.42 246.58,69.4 246.58,69.36 246.56,69.35 246.56,69.14 246.29,68.87 246.29,67.86 245.88,67.45 245.88,66.73 246.06,66.55 246.06,66.07 245.94,65.95 245.94,65.67 v2(245.51,65.03)
  BOTTOM w0.102: 246.6,69.43 246.6,69.86 v3(247.61,70.87) 247.61,70.93 247.76,71.08 247.83,71.08 249.72,72.98 249.72,73.64 CV449.2
PEG_CRX_GTX_P12: length 13.5
  TOP w0.102: UC1.E22 246.62,65.35 v2(246.3,65.68)
  BOTTOM w0.076: 247.19,68.99 247.2,68.97 247.2,68.35 246.99,68.14 246.99,67.88 246.72,67.61 246.72,65.57 246.53,65.38 246.34,65.38 246.3,65.43 v2(246.3,65.68)
  BOTTOM w0.102: 247.19,68.99 247.19,69.71 v3(249.02,71.54) 249.71,72.23 249.71,72.29 250.14,72.72 250.2,72.72 250.67,73.2 250.67,75.55 CV451.2
PEG_CRX_GTX_P13: length 12.2
  TOP w0.102: v2(247.87,65.68) 247.55,65.35 UC1.E23
  BOTTOM w0.076: v2(247.87,65.68) 247.51,66.19 247.51,66.2 247.51,66.48 247.72,66.69 247.85,66.69 248.25,67.09 248.25,67.23 248.23,67.25 248.23,67.26
  BOTTOM w0.102: 248.23,67.26 248.23,67.8 248.99,68.55 248.99,69.67 250.26,70.94 251.78,72.47 252.26,72.47 v3(252.51,72.72) 252.97,73.18 253.38,73.18 253.46,73.26 253.46,73.78 CV453.2
PEG_CRX_GTX_P14: length 13.9
  TOP w0.102: v2(248.66,65.03) 248.33,65.35 UC1.E24
  BOTTOM w0.076: v2(248.66,65.03) 248.55,65.03 248.44,64.91 248.44,64.79 248.03,64.39 247.68,64.39 247.2,64.86 247.2,65.64 247.04,65.8 247.04,66.86 247.59,67.4 247.59,67.95 247.81,68.17 247.81,68.55
  BOTTOM w0.102: 247.81,68.55 247.81,69.38 v3(248.08,69.65) 251.5,73.07 251.62,73.07 251.76,73.21 251.76,73.71 CV455.2
PEG_CRX_GTX_P15: length 14.5
  TOP w0.102: UC1.E25 249.37,65.68 v2(249.45,65.68)
  BOTTOM w0.076: v2(249.45,65.68) 249.22,65.9 249.22,66.06 249.29,66.13 249.29,66.5 249,66.79 249,67.27 249.2,67.46 249.22,67.46 249.24,67.47
  BOTTOM w0.102: CV457.2 255.55,74.67 255.55,73.36 255.2,73 255.2,72.95 254.79,72.54 254.73,72.54 254.58,72.38 253.57,72.38 252.86,71.68 252.15,71.68 250.18,69.7 250.18,69.07 250.45,68.8 250.45,68.27 250.07,67.9 249.66,67.9 249.24,67.47
PEG_CTX_C_GRX_N0: length 23.8
  TOP w0.102: CC65.2 235.99,78.42 235.99,82.22 v2(236.38,82.62) ; v2(241.57,91.58) 241.94,91.21 242.12,91.21 242.41,91.5 242.97,91.5 JDGFF2.H8
  IN4 w0.102: v2(236.38,82.62) 236.31,82.54 236.07,82.54 235.98,82.63 235.98,83.59 237.45,85.07 237.45,85.85 238.57,86.97 238.57,90 239.11,90.54 239.11,92.04 239.63,92.56 241.94,92.56 242.29,92.21 242.29,91.4 242.03,91.15 241.42,91.15 241.35,91.23 241.35,91.37 v2(241.57,91.58)
PEG_CTX_C_GRX_N1: length 20.1
  TOP w0.102: JDGFF2.H5 243.01,89.74 242.63,89.74 v2(242.33,90.04) ; CC63.2 236.97,76.49 236.97,78.71 237.39,79.13 237.39,80.81 v2(237.15,81.05)
  IN4 w0.102: v2(237.15,81.05) 237.17,81.05 237.36,81.24 237.36,81.52 237.68,81.84 237.68,83.48 239.32,85.12 239.32,85.97 238.97,86.31 238.97,89.55 239.98,90.55 240.63,90.55 241.43,89.74 242.04,89.74 v2(242.33,90.04)
PEG_CTX_C_GRX_N2: length 23.3
  TOP w0.102: v2(241.21,82.11) 241.3,82.02 241.56,82.02 241.63,82.09 241.63,82.8 241.38,83.05 238.25,83.05 237.94,82.74 237.94,82.13 238.8,81.28 v3(238.8,80.29) 238.8,79.58 238.26,79.04 238.26,78.51 CC61.2 ; JDGFF2.G6 244.32,90.31 244.51,90.31 244.64,90.45 244.64,90.64 244.82,90.81 245.05,90.81 245.27,91.03 v2(245.27,91.13)
  IN4 w0.102: v2(241.21,82.11) 241.48,82.38 241.48,83.83 243.63,85.98 243.63,90.03 244.43,90.83 244.97,90.83 v2(245.27,91.13)
PEG_CTX_C_GRX_N3: length 15.9
  TOP w0.102: JDGFF2.H2 242.99,87.92 242.55,87.92 242.21,88.26 242,88.26 v2(241.66,88.6) ; CC59.2 239.29,76.5 239.29,81.51 239.18,81.62 239.18,81.97 v2(238.88,82.26)
  IN4 w0.102: v2(241.66,88.6) 241.38,88.32 241.25,88.32 240.98,88.05 240.98,85.7 239.1,83.82 239.1,82.48 v2(238.88,82.26)
PEG_CTX_C_GRX_N4: length 21
  TOP w0.102: v2(245.36,93.74) 245.36,93.66 245.09,93.4 244.92,93.4 244.65,93.13 244.65,92.25 244.5,92.1 244.33,92.1 JDGFF2.G9 ; v2(240.44,81.47) 240.61,81.3 240.61,80.8 240.33,80.52 240.33,78.46 CC57.2
  IN4 w0.102: v2(245.36,93.74) 245.06,93.45 244.83,93.45 243.69,92.31 243.69,91.05 243.03,90.39 243.03,86.28 240.25,83.5 240.25,82.11 240.53,81.83 240.53,81.57 v2(240.44,81.47)
PEG_CTX_C_GRX_N5: length 18.4
  TOP w0.102: CC55.2 241.56,76.51 241.56,78.66 242.1,79.2 242.1,79.61 242.17,79.69 v2(242.52,79.69) ; JDGFF2.G3 244.31,88.52 244.56,88.52 244.83,88.25 244.83,87.83 244.89,87.77 245.11,87.77 245.25,87.91 v2(245.25,88.03)
  IN4 w0.102: v2(245.25,88.03) 244.95,87.74 244.53,87.74 244.22,87.43 244.22,85.59 242.53,83.91 242.53,81.79 241.12,80.38 241.12,79.57 241.54,79.15 241.91,79.15 242.45,79.69 v2(242.52,79.69)
PEG_CTX_C_GRX_N6: length 15.1
  TOP w0.102: v2(243.15,81.78) 243.36,81.58 243.36,80.5 243,80.14 243,79.18 242.52,78.7 242.52,78.46 CC53.2 ; v2(245.74,89.97) 245.98,89.74 246.31,89.74 JDGFF2.F5
  IN4 w0.102: v2(243.15,81.78) 243.28,81.91 243.28,83.8 245.25,85.77 245.25,86.47 245.82,87.04 245.82,88.18 245.19,88.82 245.19,89.58 245.4,89.8 245.57,89.8 245.74,89.97 v2(245.74,89.97)
PEG_CTX_C_GRX_N7: length 20.6
  TOP w0.102: v2(245.35,92.43) 245.35,92.43 245.64,92.14 245.73,92.14 245.95,91.92 245.95,91.66 246.09,91.52 246.29,91.52 JDGFF2.F8 ; v2(244.59,80.02) 244.38,79.81 244.38,79.17 243.87,78.66 243.87,76.52 CC51.2
  IN4 w0.102: v2(245.35,92.43) 245.35,92.43 245.63,92.14 246.07,92.14 246.45,91.76 246.45,89.17 246.97,88.65 246.97,86.14 244.56,83.73 244.56,80.66 244.37,80.47 244.37,80.24 v2(244.59,80.02)
