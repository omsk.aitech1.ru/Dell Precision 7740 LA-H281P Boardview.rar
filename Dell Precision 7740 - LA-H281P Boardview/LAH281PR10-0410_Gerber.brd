# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_MA15: length 81.2
  TOP w0.076: v2(224.98,49.88) 225.4,50.31 225.7,50.31 226.97,51.57 231.19,51.57 UC1.AD1
  TOP w0.211: JDIMM2.156 174.63,56.48 175.84,57.69 178.02,57.69 v2(178.85,56.86)
  IN1 w0.076: v2(224.98,49.88) 224.84,50.01 224.66,50.01 221.27,53.41 220.6,53.41
  IN1 w0.188: v2(178.85,56.86) 178.85,56.9 179.27,57.31 180.9,57.31 181.03,57.18 182.45,57.18 183.06,57.79 184.3,57.79 185.03,58.53 187.42,58.53 188.95,60.06 192.63,60.06 192.84,59.85 204.51,59.85 204.7,59.66 204.7,59.41 204.51,59.22 200.72,59.22 200.56,59.06 200.56,58.81 200.74,58.63 207.82,58.63 207.96,58.48 207.96,58.32 208.14,58.15 208.38,58.15 208.56,58.32 208.56,58.97 209.18,59.59 209.95,59.59 216.14,53.41 220.6,53.41
  BOTTOM w0.211: JDIMM1.156 181.03,56.48 180.17,57.35 179.57,57.35 178.93,57.99 178.18,57.99 178.03,57.84 178.03,57.58 178.19,57.41 178.53,57.41 178.85,57.09 v2(178.85,56.86)
DDR_A_MA16: length 79.8
  TOP w0.076: v2(232.95,49.35) 233,49.29 233,48.46 UC1.AH4
  TOP w0.211: JDIMM2.152 174.43,55.48 175.36,56.42 175.36,56.51 176.17,57.32 177.77,57.32 v2(178.23,56.86)
  IN1 w0.076: 220.6,53.96 221.03,53.96 224.73,50.26 225.26,50.26 225.61,49.92 225.61,49.36 226.03,48.94 228.67,48.94 229.16,48.45 232.05,48.45 v2(232.95,49.35)
  IN1 w0.188: v2(178.23,56.86) 177.86,56.86 177.68,57.04 177.68,57.48 177.89,57.69 181.76,57.69 181.97,57.9 182.41,57.9 182.84,58.32 182.95,58.32 183.23,58.6 183.23,58.9 183.4,59.08 183.65,59.08 183.82,58.9 183.82,58.55 183.95,58.42 184.18,58.42 184.81,59.06 186.06,59.06 186.23,59.23 186.23,59.59 186.41,59.77 186.65,59.77 186.83,59.59 186.83,59.23 187,59.06 187.2,59.06 189.08,60.95 192.62,60.95 193.19,60.38 204.83,60.38 205.23,59.98 205.23,59.35 205.42,59.16 207.99,59.16 208.99,60.16 210.14,60.16 213.78,56.51 214.66,56.51 215.04,56.13 215.04,55.26 216.33,53.96 220.6,53.96
  BOTTOM w0.211: JDIMM1.152 181.05,55.48 180.93,55.36 180.78,55.36 180.66,55.48 180.66,55.93 180.37,56.22 179.02,56.22 178.84,56.39 178.54,56.39 178.35,56.2 178.01,56.2 177.9,56.3 177.9,56.7 178.06,56.86 v2(178.23,56.86)
DDR_A_ODT0: length 73.3
  TOP w0.076: UC1.AD3 232.37,51.14 231.13,51.14 230.99,51.28 227.74,51.28 v1(227.55,51.09) 226.49,50.03 226.49,49.39 226.24,49.14 224.69,49.14 224.4,49.44 224.4,49.56 v2(224.13,49.82)
  TOP w0.168: v2(180.05,56.83) 180.65,56.23 JDIMM2.155
  IN1 w0.076: 220.55,52.73 221.4,52.73 224.13,50 v2(224.13,49.82)
  IN1 w0.152: 220.55,52.73 215.86,52.73 209.67,58.91 209.46,58.91 209.28,58.73 209.28,58.52 212.51,55.29 212.51,55.07 212.33,54.89 212.11,54.89 209.65,57.36 205.37,57.36 205.22,57.51 205.22,57.77 205.07,57.92 204.81,57.92 204.66,57.77 204.66,57.51 204.51,57.36 203.69,57.36 203.53,57.51 203.53,57.8 203.38,57.95 203.13,57.95 202.97,57.8 202.97,57.51 202.82,57.36 202.22,57.36 201.65,57.93 200.48,57.93 199.23,59.17 193.84,59.17 193.75,59.08 188.93,59.08 187.7,57.85 185.31,57.85 184.58,57.11 183.34,57.11 182.73,56.5 180.38,56.5 v2(180.05,56.83)
DDR_A_ODT1: length 73.6
  TOP w0.076: v2(229.53,49.79) 229.91,50.18 230.17,50.18 230.36,50.37 230.99,50.37 231.13,50.23 231.62,50.23 231.78,50.39 233.1,50.39 233.3,50.58 UC1.AE4
  TOP w0.168: v2(176.23,60.99) 177.03,60.19 178.95,60.19 179.73,59.4 179.73,59.13 181.13,57.73 JDIMM2.161
  IN1 w0.076: v2(229.53,49.79) 229.53,50.56 229.01,51.08 227.9,51.08 227.62,51.36 226.52,51.36 226.35,51.53 225.37,51.53 219.77,57.13
  IN1 w0.152: 219.77,57.13 218.45,57.13 215.71,59.87 214.83,59.87 211.21,63.49 209.1,63.49 207.99,64.61 193.63,64.61 193.18,65.06 188.49,65.06 187.09,63.67 183.49,63.67 180.92,61.1 180.7,61.1 180.41,60.8 179.35,60.8 179.09,60.54 176.68,60.54 v2(176.23,60.99)
DDR_A_ODT2: length 74.2
  TOP w0.076: v2(228.05,49.84) 228.96,50.75 231.28,50.75 UC1.AE1
  IN1 w0.076: 219.91,55.76 220.07,55.76 224.91,50.92 225.94,50.92 226.15,50.71 227.02,50.71 227.41,50.32 227.57,50.32 v2(228.05,49.84)
  IN1 w0.152: v2(177.71,59.4) 177.56,59.25 177.56,59.03 177.69,58.89 179.21,58.89 179.74,59.43 180.97,59.43 181.27,59.73 181.56,59.73 183.4,61.56 187.1,61.56 188.62,63.08 193.65,63.08 193.81,62.93 193.81,62.32 193.96,62.17 194.21,62.17 194.37,62.32 194.37,62.93 194.52,63.08 194.77,63.08 194.92,62.93 194.92,62.32 195.08,62.17 195.33,62.17 195.48,62.32 195.48,62.93 195.64,63.08 198.99,63.08 199.14,63.24 200.9,63.24 201.05,63.09 201.05,62.83 200.9,62.68 200.13,62.68 199.98,62.53 199.98,62.27 200.13,62.12 210.64,62.12 213.72,59.03 213.73,59.03 214.26,58.5 215.14,58.5 217.88,55.76 219.91,55.76
  BOTTOM w0.168: JDIMM1.155 174.47,56.23 174.76,56.53 174.76,57.48 175.76,58.48 175.76,59.35 176.25,59.84 177.27,59.84 v2(177.71,59.4)
DDR_A_ODT3: length 77.1
  TOP w0.076: UC1.AD4 233.3,51.54 v2(232.97,51.86)
  IN1 w0.076: v2(232.97,51.86) 232.58,51.47 227.87,51.47 227.78,51.56 226.67,51.56 226.48,51.74 225.51,51.74 219.66,57.59 219.4,57.59
  IN1 w0.152: 219.4,57.59 218.63,57.59 215.89,60.33 215.02,60.33 211.4,63.95 209.29,63.95 208.18,65.07 201.19,65.07 201.04,65.22 201.04,65.45 200.89,65.61 200.63,65.61 200.48,65.45 200.48,65.22 200.33,65.07 200.07,65.07 199.92,65.22 199.92,65.45 199.77,65.61 199.51,65.61 199.36,65.45 199.36,65.22 199.21,65.07 193.9,65.07 193.75,65.22 193.75,65.47 193.9,65.63 195.82,65.63 195.97,65.78 195.97,66.03 195.82,66.18 190.44,66.18 190.29,66.03 190.29,65.71 190.14,65.56 189.89,65.56 189.73,65.71 189.73,66.03 189.58,66.18 188.87,66.18 186.81,64.12 183.26,64.12 180.69,61.55 180.51,61.55 180.13,61.18 179.03,61.18 v2(178.8,60.95)
  BOTTOM w0.168: JDIMM1.161 174.37,57.73 175.02,58.38 175.02,59.03 176.47,60.49 178.34,60.49 v2(178.8,60.95)
DDR_A_PARITY: length 78.4
  TOP w0.076: UC1.AG3 232.35,48.61 231.17,48.61 231.03,48.76 228.45,48.76 227.87,48.18 227.16,48.18 v2(226.35,47.37)
  TOP w0.211: JDIMM2.143 180.96,51.23 180.25,51.95 178.71,51.95 v2(176.73,53.92)
  IN1 w0.076: v2(226.35,47.37) 225.96,46.97 222.61,46.97 222,47.58 221.12,47.58 221.11,47.57
  IN1 w0.188: v2(176.73,53.92) 174.97,53.92 174.54,53.49 174.54,52.61 174.86,52.29 178.03,52.29 178.53,52.78 187.34,52.78 187.9,53.35 188.59,53.35 188.89,53.65 192.35,53.65 192.6,53.91 196.93,53.91 197.32,53.52 201.82,53.52 202.78,52.56 207.34,52.56 211.77,48.13 219.18,48.13 219.74,47.57 221.11,47.57
  BOTTOM w0.211: v2(176.73,53.92) 176.22,53.4 176.22,53.1 176.71,52.61 176.71,52.31 176.37,51.97 176.07,51.97 175.58,52.46 174.76,52.46 174.43,52.14 174.43,51.62 174.04,51.23 JDIMM1.143
DDR_B_ACT#: length 67.8
  TOP w0.076: v2(236.88,41.98) UC1.AT9
  TOP w0.211: v2(189.79,42.93) 190.56,42.16 190.56,41.82 190.41,41.67 189.88,41.67 188.77,42.78 188.77,43.8 188.6,43.98 JDIMM4.114
  IN4 w0.076: 224.97,39.16 225.2,39.39 229.44,39.39 230.38,40.33 233.66,40.33 235.2,41.87 235.2,42.1 235.45,42.35 236.51,42.35 v2(236.88,41.98)
  IN4 w0.188: 224.97,39.16 224.25,38.44 223.82,38.44 219.35,33.98 205.66,33.98 200.41,39.23 195.94,39.23 194.16,41.01 194.16,41.34 193.5,42 190.72,42 v2(189.79,42.93)
  BOTTOM w0.211: JDIMM3.114 195.59,43.98 194.21,43.98 193.64,43.4 190.26,43.4 v2(189.79,42.93)
DDR_B_ALERT#: length 64
  TOP w0.076: v2(236.23,42.89) UC1.AR8
  TOP w0.211: JDIMM4.116 188.36,44.48 188.76,44.87 189.52,44.87 189.7,44.69 189.7,44.5 189.2,44 189.2,43.57 189.4,43.37 189.75,43.37 v2(190.49,44.11)
  IN4 w0.076: v2(236.23,42.89) 236.09,42.89 235.71,43.27 235.32,43.27 234.47,42.42 233.93,42.42 233.52,42.01 233.52,41.78 233.08,41.34 227.85,41.34 226.78,40.28 224.28,40.28 224.07,40.07 223.96,40.07
  IN4 w0.188: 223.96,40.07 223.14,40.07 219.12,36.05 209.44,36.05 208.75,36.73 206.88,36.73 205.69,37.93 203.97,37.93 200.9,40.99 196.41,40.99 194.07,43.33 192.72,43.33 192.64,43.42 191.18,43.42 v2(190.49,44.11)
  BOTTOM w0.211: JDIMM3.116 195.59,44.48 194.19,44.48 193.44,43.73 190.87,43.73 v2(190.49,44.11)
DDR_B_BA0: length 67.5
  TOP w0.076: v2(236.23,48.38) UC1.AH8
  TOP w0.211: v2(191.6,54.17) 191.23,54.54 191,54.54 190.78,54.75 189.15,54.75 188.93,54.98 JDIMM4.150
  IN4 w0.076: 221.35,51.23 223.85,48.73 231.69,48.73 231.81,48.61 235.28,48.61 235.44,48.78 235.73,48.78 236.13,48.38 v2(236.23,48.38)
  IN4 w0.188: 221.35,51.23 217.87,51.23 217.26,51.83 214.93,51.83 210.88,55.88 210.49,55.88 210.32,55.71 210.32,55.31 210.15,55.14 209.9,55.14 209.73,55.31 209.73,55.71 209.55,55.88 209.31,55.88 209.13,55.71 209.13,55.31 208.96,55.14 208.71,55.14 208.54,55.31 208.54,55.71 208.29,55.96 200.69,55.96 200.51,55.78 200.51,55.54 200.69,55.36 202.67,55.36 202.84,55.19 202.84,54.94 202.67,54.77 199.83,54.77 199.66,54.94 199.66,55.32 199.48,55.49 199.24,55.49 199.06,55.32 199.06,54.94 198.89,54.77 198.64,54.77 198.47,54.94 198.47,55.32 198.3,55.49 198.05,55.49 197.88,55.32 197.88,54.94 197.7,54.77 196.15,54.77 195.69,54.31 191.75,54.31 v2(191.6,54.17)
  BOTTOM w0.211: JDIMM3.150 194.83,54.98 194.16,54.31 193.72,54.31 193.48,54.54 191.98,54.54 v2(191.6,54.17)
DDR_B_BA1: length 72.7
  TOP w0.076: UC1.AH9 v2(236.85,48.39)
  TOP w0.203: v2(193.83,53.31) 193.83,52.39 194.05,52.17 195.96,52.17 196.21,52.42 196.21,52.72 196.01,52.92 194.86,52.92 194.66,53.12 194.66,53.52 194.86,53.73 JDIMM4.145
  IN4 w0.076: 221.65,50.17 221.78,50.17 223.55,48.4 231.35,48.4 231.47,48.28 235.11,48.28 235.39,48 236.45,48 v2(236.85,48.39)
  IN4 w0.188: 221.65,50.17 217.43,50.17 217.19,50.4 216.85,50.4 216.44,49.99 216.09,49.99 215.53,50.55 215.22,50.55 215.09,50.41 215.09,50.11 214.97,49.99 214.6,49.99 214.33,50.26 214.33,50.93 213.87,51.39 213.62,51.39 213.54,51.31 213.29,51.31 213.12,51.48 213.12,51.73 213.2,51.81 213.2,52.06 213.03,52.23 212.78,52.23 212.7,52.15 212.45,52.15 212.28,52.32 212.28,52.57 212.36,52.65 212.36,52.9 212.12,53.14 211.79,53.14 211.52,52.86 209.68,52.86 209.5,53.04 209.5,53.29 209.68,53.46 211.2,53.46 211.38,53.63 211.38,53.88 211.2,54.05 208.15,54.05 207.38,54.82 204.24,54.82 204.06,54.64 204.06,54.4 204.24,54.22 205.6,54.22 205.77,54.05 205.77,53.8 205.6,53.63 202.9,53.63 202.72,53.46 202.72,53.04 202.55,52.86 202.3,52.86 202.13,53.04 202.13,53.46 201.96,53.63 197.27,53.63 197.1,53.81 196.56,53.81 196.06,53.31 v2(193.83,53.31)
  BOTTOM w0.211: v2(193.83,53.31) 193.78,53.31 193.36,53.73 192.4,53.73 191.97,53.3 190.54,53.3 190.12,53.72 JDIMM3.145
DDR_B_BG0: length 65.7
  TOP w0.076: v2(236.88,42.89) UC1.AR9
  TOP w0.211: v2(191.12,42.89) 191.12,43.09 191.41,43.37 193.9,43.37 194.75,44.23 JDIMM4.115
  IN4 w0.076: 224.7,39.54 224.83,39.67 226.94,39.67 228.06,40.79 233.77,40.79 234.77,41.79 234.77,41.97 235.32,42.52 236.51,42.52 v2(236.88,42.89)
  IN4 w0.188: v2(191.12,42.89) 191.61,42.41 193.68,42.41 196.15,39.93 200.46,39.93 205.58,34.81 205.82,34.81 206,34.99 206,35.23 205.61,35.62 205.61,35.87 205.79,36.04 206.03,36.04 207.56,34.51 219.08,34.51 223.48,38.91 224.07,38.91 224.7,39.54
  BOTTOM w0.211: v2(191.12,42.89) 190.72,42.49 189.63,42.49 189.28,42.83 189.28,43.71 188.77,44.22 JDIMM3.115
DDR_B_BG1: length 69.3
  TOP w0.076: v2(235.58,42.89) UC1.AR7
  TOP w0.211: v2(192.31,42.92) 191.86,42.47 191.86,42.11 192,41.97 192.54,41.97 192.82,42.25 192.82,42.72 193.07,42.97 193.65,42.97 193.84,42.78 194.18,42.78 194.52,43.12 194.52,43.38 194.86,43.73 JDIMM4.113
  IN4 w0.076: 224.28,39.78 224.45,39.95 226.85,39.95 228.05,41.15 233.2,41.15 233.85,41.79 233.85,42.01 234.05,42.22 234.55,42.22 235.22,42.89 v2(235.58,42.89)
  IN4 w0.188: v2(192.31,42.92) 193.79,42.92 196.23,40.48 200.66,40.48 204.92,36.22 205.17,36.22 205.34,36.39 205.34,36.64 205.04,36.95 205.04,37.19 205.21,37.37 205.5,37.37 207.71,35.16 207.96,35.16 208.13,35.33 208.13,35.58 207.96,35.74 207.96,35.99 208.14,36.16 208.38,36.16 209.03,35.52 210.11,35.52 210.28,35.35 210.28,35.21 210.45,35.04 210.7,35.04 210.88,35.21 210.88,35.35 211.05,35.52 211.3,35.52 211.47,35.35 211.47,35.21 211.64,35.04 211.89,35.04 212.06,35.21 212.06,35.35 212.24,35.52 212.48,35.52 212.66,35.35 212.66,35.21 212.83,35.04 213.08,35.04 213.25,35.21 213.25,35.35 213.43,35.52 213.67,35.52 213.85,35.35 213.85,35.21 214.02,35.04 214.27,35.04 214.44,35.21 214.44,35.35 214.62,35.52 214.86,35.52 215.04,35.35 215.04,35.21 215.21,35.04 215.46,35.04 215.63,35.21 215.63,35.35 215.8,35.52 216.22,35.52 216.71,35.04 217.32,35.04 217.49,35.21 217.49,35.34 217.66,35.51 217.91,35.51 218.08,35.34 218.08,35.21 218.26,35.04 218.86,35.04 223.26,39.44 223.94,39.44 224.28,39.78
  BOTTOM w0.211: v2(192.31,42.92) 192.31,42.89 191.93,42.52 191.38,42.52 191.03,42.16 189.39,42.16 188.75,42.8 188.75,43.15 188.17,43.72 JDIMM3.113
DDR_B_CB0: length 65.6
  TOP w0.076: v2(238.18,40.15) UC1.AW11
  TOP w0.152: JDIMM4.104 188.82,41.48 189.76,40.53 193.3,40.53 193.75,40.98 v2(193.75,41.17)
  IN2 w0.076: 235.08,42.99 235.22,42.85 235.22,42.72 235.53,42.42 238.26,42.42 238.56,42.12 238.56,40.52 v2(238.18,40.15)
  IN2 w0.114: 235.08,42.99 234.18,43.9 232.6,43.9 232.41,44.09 220.23,44.09 217.47,41.33 209.76,41.33 208.63,40.19 202.15,40.19 200.84,41.51 199.13,41.51 198.72,41.92 193.94,41.92 193.75,41.73 v2(193.75,41.17)
  BOTTOM w0.152: JDIMM3.104 194.61,41.47 194.26,41.82 194.26,42.28 194.1,42.44 193.33,42.44 193.18,42.29 193.18,40.53 193.33,40.38 194.06,40.38 194.25,40.57 194.25,41.02 194.11,41.17 v2(193.75,41.17)
DDR_B_CB1: length 65
  TOP w0.076: UC1.AY11 237.95,38.9 v2(238.18,39.23)
  TOP w0.152: JDIMM4.88 188.43,37.48 188.83,37.08 188.83,36.79 189.65,35.97 191.9,35.97 v2(192.32,36.39)
  IN2 w0.076: v2(238.18,39.23) 238.18,39.2 237.68,38.7 236.18,38.7 235.87,38.39 235.26,38.39 234.65,39 234.65,39.4 234.4,39.66 233.68,39.66 233.56,39.78 230.24,39.78 229.38,38.93 227.9,38.93 227.58,39.24
  IN2 w0.114: v2(192.32,36.39) 193.23,35.48 201.85,35.48 201.99,35.62 201.99,35.89 201.85,36.03 200.77,36.03 200.63,36.17 200.63,36.52 200.78,36.66 219.63,36.66 222.36,39.4 227.43,39.4 227.58,39.24
  BOTTOM w0.152: v2(192.32,36.39) 192.32,36.75 192.42,36.86 192.78,36.86 192.94,37.01 192.94,37.33 193.09,37.48 193.43,37.48 193.59,37.33 193.59,37.15 194.1,36.63 194.28,36.63 194.5,36.85 194.5,37.02 194.22,37.31 194.22,37.5 194.39,37.67 194.58,37.67 194.78,37.47 JDIMM3.88
DDR_B_CB2: length 64.7
  TOP w0.076: UC1.AY8 236,38.9 v2(236.23,39.23)
  TOP w0.152: v2(189.78,36.4) 190.94,37.56 193.96,37.56 194.62,38.23 JDIMM4.91
  IN2 w0.076: v2(236.23,39.23) 236.13,39.23 235.78,38.88 235.43,38.88 235.14,39.16 235.14,39.41 234.43,40.12 233.96,40.12 233.76,40.31 230.08,40.31 229.13,39.36 228.64,39.36 228.2,39.8
  IN2 w0.114: 228.2,39.8 227.92,40.08 221.71,40.08 219.03,37.4 196.66,37.4 196.52,37.26 196.52,36.64 196.38,36.5 196.11,36.5 195.97,36.64 195.97,37.26 195.83,37.4 190.78,37.4 v2(189.78,36.4)
  BOTTOM w0.152: v2(189.78,36.4) 189.83,36.4 190.19,36.76 190.19,36.97 189.96,37.2 189.82,37.2 189.44,36.83 189.27,36.83 189.15,36.95 189.15,37.11 189.53,37.49 189.53,37.63 189.39,37.78 189.24,37.78 188.94,37.47 188.77,37.47 188.65,37.59 188.65,37.76 188.96,38.07 188.96,38.21 188.7,38.47 188.45,38.47 188.21,38.22 JDIMM3.91
DDR_B_CB3: length 64.9
  TOP w0.076: v2(236.23,40.15) UC1.AW8
  TOP w0.152: v2(190.69,39.95) 190.69,39.07 189.66,38.04 189.66,37.83 189.51,37.67 189.25,37.67 189.1,37.83 189.1,38.32 188.95,38.48 JDIMM4.92
  IN2 w0.076: v2(236.23,40.15) 234.9,41.48 234.9,42.23 234.48,42.66 234.2,42.66
  IN2 w0.114: v2(190.69,39.95) 191.27,40.53 192.45,40.53 193,39.98 195.7,39.98 196.14,40.43 200.47,40.43 201.48,39.42 213.56,39.42 213.7,39.56 213.7,39.83 213.56,39.97 212.26,39.97 212.12,40.11 212.12,40.37 212.26,40.51 218.23,40.51 220.86,43.14 230.64,43.14 231.12,42.66 234.2,42.66
  BOTTOM w0.152: JDIMM3.92 194.28,38.47 193.85,38.9 191.74,38.9 v2(190.69,39.95)
DDR_B_CB4: length 63.7
  TOP w0.076: UC1.AY10 237.3,38.9 v2(237.53,39.23)
  TOP w0.152: v2(191.05,36.38) 191.59,36.92 194.22,36.92 194.53,37.23 JDIMM4.87
  IN2 w0.076: 227.88,39.49 228.2,39.17 229.28,39.17 230.15,40.04 233.68,40.04 233.84,39.88 234.41,39.88 234.89,39.4 234.89,39.02 235.3,38.61 235.85,38.61 236.1,38.86 237.16,38.86 v2(237.53,39.23)
  IN2 w0.114: 227.88,39.49 227.66,39.71 222.05,39.71 219.37,37.03 200.58,37.03 199.49,35.94 194.35,35.94 194.22,36.08 194.22,36.34 194.35,36.48 195.28,36.48 195.42,36.62 195.42,36.89 195.28,37.03 191.31,37.03 191.05,36.77 v2(191.05,36.38)
  BOTTOM w0.152: JDIMM3.87 188.48,37.22 188.7,37.01 188.7,36.82 189.74,35.78 190.94,35.78 191.05,35.9 v2(191.05,36.38)
DDR_B_CB5: length 65.5
  TOP w0.076: v2(237.53,40.15) UC1.AW10
  TOP w0.152: v2(192.35,41.17) 192.35,40.93 192.46,40.82 193.09,40.82 193.28,41.01 193.28,41.61 193.78,42.11 194.04,42.11 194.19,41.96 194.19,41.73 194.05,41.59 194.05,41.42 194.22,41.25 194.44,41.25 194.92,41.73 JDIMM4.105
  IN2 w0.076: v2(237.53,40.15) 237.17,40.51 236.36,40.51 235.17,41.7 235.17,42.3 234.46,43.01
  IN2 w0.114: 234.46,43.01 234.23,43.25 232.25,43.25 231.84,43.65 220.68,43.65 217.94,40.92 209.87,40.92 209.73,40.78 209.73,40.51 209.87,40.37 211.62,40.37 211.75,40.23 211.75,39.96 211.62,39.82 201.67,39.82 200.58,40.92 195.88,40.92 195.35,40.39 193.14,40.39 v2(192.35,41.17)
  BOTTOM w0.152: JDIMM3.105 188.51,41.72 189.43,40.8 191.98,40.8 v2(192.35,41.17)
DDR_B_CB6: length 64.9
  TOP w0.076: v2(235.58,39.23) 235.35,38.9 UC1.AY7
  TOP w0.152: v2(189.47,39.97) 189.47,40.22 189.34,40.36 189.12,40.36 189,40.24 189,39.59 189.12,39.47 189.91,39.47 190.06,39.32 190.06,39.06 189.89,38.9 188.61,38.9 188.44,39.07 188.44,40.31 188.27,40.48 JDIMM4.100
  IN2 w0.076: v2(235.58,39.23) 235.56,39.23 234.11,40.68 232.86,40.68
  IN2 w0.114: 232.86,40.68 229.76,40.68 229.56,40.88 227,40.88 226.58,40.46 221.36,40.46 218.67,37.77 190.03,37.77 189.6,38.2 189.6,38.63 189.92,38.95 189.92,39.22 189.78,39.36 189.61,39.36 189.47,39.5 v2(189.47,39.97)
  BOTTOM w0.152: v2(189.47,39.97) 189.84,40.34 190.86,40.34 191.2,40 191.2,39.87 191.47,39.6 192.38,39.6 192.73,39.95 194.15,39.95 194.67,40.47 JDIMM3.100
DDR_B_CB7: length 64.7
  TOP w0.076: v2(235.6,40.15) UC1.AW7
  TOP w0.152: v2(190.69,38.27) 192.03,39.6 192.38,39.6 192.89,40.12 193.41,40.12 194.02,40.73 JDIMM4.101
  IN2 w0.076: v2(235.6,40.15) 235.6,40.35 234.64,41.31 234.64,42.11 234.46,42.29 234.2,42.29
  IN2 w0.114: 234.2,42.29 230.97,42.29 230.48,42.77 221.4,42.77 218.78,40.15 214.4,40.15 214.25,40 214.25,39.73 214.39,39.6 215.49,39.6 215.63,39.46 215.63,39.19 215.49,39.05 201.32,39.05 200.34,40.04 196.28,40.04 195.79,39.55 191.98,39.55 v2(190.69,38.27)
  BOTTOM w0.152: JDIMM3.101 187.4,40.73 188.46,40.73 188.81,40.38 188.81,39.89 189.67,39.03 189.85,39.03 190.22,39.4 190.43,39.4 190.61,39.22 190.61,39 190.24,38.63 190.24,38.42 190.39,38.27 v2(190.69,38.27)
DDR_B_CKE0: length 64
  TOP w0.076: v2(236.23,41.98) UC1.AT8
  TOP w0.168: v2(191.07,41.19) 191.51,41.63 192.82,41.63 193.6,42.41 194.46,42.41 194.78,42.73 JDIMM4.109
  IN4 w0.076: v2(236.23,41.98) 236.14,41.98 234.73,40.56 234.73,39.11 234.55,38.94 226.27,38.94 225.41,38.08 225.22,38.08
  IN4 w0.152: v2(191.07,41.19) 191.49,40.78 192.86,40.78 195.42,38.23 195.42,37.8 196.94,36.28 200.17,36.28 202.88,33.57 203.1,33.57 203.28,33.75 203.28,33.97 201.9,35.34 201.9,35.55 202.08,35.73 202.3,35.73 205.19,32.84 219.99,32.84 225.22,38.08
DDR_B_CKE1: length 62.6
  TOP w0.076: v2(237.53,41.98) UC1.AT10
  TOP w0.168: v2(186.19,42.74) 186.43,42.98 JDIMM4.110
  IN4 w0.076: v2(237.53,41.98) 237.16,41.6 237.04,41.6 236.02,41.6 234.93,40.51 234.93,39.04 234.58,38.68 226.47,38.68 225.69,37.9
  IN4 w0.152: v2(186.19,42.74) 186.21,42.74 188.52,40.43 192.56,40.43 194.94,38.05 194.94,37.55 196.66,35.82 199.98,35.82 203.42,32.38 220.18,32.38 225.69,37.9
DDR_B_CKE2: length 62.4
  TOP w0.076: v2(235.58,41.98) UC1.AT7
  IN4 w0.076: v2(235.58,41.98) 235.58,41.77 233.71,39.9 230.27,39.9 229.56,39.19 229.56,39.19 229.47,39.1 225.41,39.1 225.01,38.71
  IN4 w0.152: 225.01,38.71 225.01,38.63 219.69,33.3 205.38,33.3 200.34,38.34 200.12,38.34 199.94,38.16 199.94,37.95 201.59,36.3 201.59,36.08 201.41,35.9 201.2,35.9 199.46,37.64 196.61,37.64 192.66,41.58 190.83,41.58 v2(190.44,41.2)
  BOTTOM w0.168: JDIMM3.109 188.33,42.72 189.38,41.67 190.16,41.67 190.44,41.39 v2(190.44,41.2)
DDR_B_CKE3: length 62.5
  TOP w0.076: v2(238.18,41.98) UC1.AT11
  IN4 w0.076: 226.13,37.89 226.69,38.45 234.67,38.45 235.16,38.94 235.16,40.46 236.13,41.43 237.33,41.43 237.43,41.53 237.73,41.53 v2(238.18,41.98)
  IN4 w0.152: v2(191.63,40) 192.94,38.69 193.65,38.69 194.27,38.07 194.27,37.43 196.33,35.37 199.79,35.37 203.23,31.93 220.47,31.93 222.54,34 222.54,34.3 226.13,37.89
  BOTTOM w0.168: JDIMM3.110 195.59,42.98 193.39,42.98 192.86,42.44 192.86,40.58 192.71,40.43 191.86,40.43 191.63,40.2 v2(191.63,40)
DDR_B_CLK0: length 59.7
  TOP w0.076: v2(236.88,45.63) UC1.AM9
  TOP w0.109: v2(193.17,50.29) 193.01,50.29 192.9,50.4 192.9,50.58 193.04,50.72 194.04,50.72 194.28,50.48 194.28,50.28 194.46,50.1 194.46,49.86 194.6,49.73 JDIMM4.137
  IN4 w0.076: 221.23,46.19 221.25,46.19 221.27,46.17 221.93,46.17 222.36,45.73 232.58,45.73 233.39,46.54 234.48,46.54 234.87,46.14 234.87,45.7 235.35,45.23 236.46,45.23 236.54,45.15 236.79,45.15 236.88,45.25 v2(236.88,45.63)
  IN4 w0.102: 221.23,46.19 219.1,46.19 218.84,45.94 211.09,45.94 210.65,46.38 210.1,46.38 209.66,45.94 209.12,45.94 206.17,48.89 205.86,48.89 205.52,48.55 205.52,48.24 207.58,46.19 207.58,46.04 207.36,45.83 207.22,45.83 204.03,49.02 200.11,49.02 199.73,49.4 194.9,49.4 194.58,49.71 193.11,49.71 192.96,49.87 192.96,50.07 v2(193.17,50.29)
DDR_B_CLK1: length 61.3
  TOP w0.076: UC1.AM7 v2(235.51,45.61)
  TOP w0.109: JDIMM4.138 188.2,49.98 188.66,49.51 189.77,49.51 190.02,49.76 190.02,50.15 v2(190.13,50.27)
  IN4 w0.076: 220.93,46.7 220.95,46.7 220.97,46.73 221.93,46.73 222.43,46.23 224.66,46.23 224.9,45.98 232.33,45.98 233.12,46.78 234.52,46.78 235.28,46.02 235.63,46.02 235.87,45.78 235.87,45.52 235.8,45.45 235.67,45.45 v2(235.51,45.61)
  IN4 w0.102: 220.93,46.7 218.89,46.7 218.64,46.45 212.71,46.45 212.49,46.67 212.49,47 212.39,47.1 212.08,47.1 211.98,47 211.98,46.67 211.76,46.45 211.34,46.45 208.39,49.4 208.25,49.4 208.03,49.18 208.03,49.04 209.8,47.27 209.8,46.96 209.46,46.62 209.15,46.62 206.25,49.52 200.36,49.52 199.95,49.93 195.1,49.93 194.38,50.66 191.41,50.66 191.31,50.76 190,50.76 189.87,50.64 189.87,50.39 189.99,50.27 v2(190.13,50.27)
DDR_B_CLK2: length 61.6
  TOP w0.076: UC1.AM11 v2(238.27,45.62)
  IN4 w0.076: v2(238.27,45.62) 238.06,45.83 238.06,45.93 237.8,46.18 236.14,46.18 235.8,46.52 235.5,46.52 234.64,47.38 232.12,47.38 231.27,46.52 225.34,46.52 224.95,46.92 224.58,46.92 224.56,46.94 224.54,46.94
  IN4 w0.102: 224.54,46.94 222.78,46.94 222.11,47.61 218.51,47.61 218.26,47.37 213.68,47.37 213.01,48.04 211.04,48.04 208.65,50.44 200.74,50.44 200.34,50.85 195.66,50.85 195.02,51.5 191.89,51.5 191.79,51.6 188.78,51.6 188.3,52.07 188.3,52.26 187.55,53 186.55,53 186.3,52.75 186.3,52.2 v2(186.15,52.05)
  BOTTOM w0.109: v2(186.15,52.05) 186.26,51.94 186.26,51.58 185.78,51.1 185.78,50.05 186.11,49.72 JDIMM3.137
DDR_B_CLK3: length 63.9
  TOP w0.076: v2(237.53,47.46) UC1.AJ10
  IN4 w0.076: v2(237.53,47.46) 237.73,47.27 237.73,47.14 237.65,47.06 236.6,47.06 236.56,47.1 235.41,47.1 234.8,47.71 231.91,47.71 231.09,46.89 225.63,46.89 225.01,47.51 224.51,47.51 224.48,47.54 224.47,47.54
  IN4 w0.102: v2(190.19,52.02) 190.41,52.25 190.41,52.43 190.64,52.66 191.57,52.66 192.14,52.09 195.76,52.09 196.06,51.79 200.48,51.79 201.12,51.15 209,51.15 211.37,48.77 211.52,48.77 211.73,48.99 211.73,49.13 210.37,50.5 210.37,50.81 210.7,51.15 211.02,51.15 214.08,48.08 217.97,48.08 218.21,48.33 222.34,48.33 223.12,47.54 224.47,47.54
  BOTTOM w0.109: v2(190.19,52.02) 190.19,51.36 190.75,50.79 193.94,50.79 194.15,50.58 194.15,50.23 194.4,49.98 JDIMM3.138
DDR_B_CLK#0: length 59.7
  TOP w0.076: v2(236.88,44.72) UC1.AN9
  TOP w0.109: v2(192.54,50.29) 192.66,50.41 192.66,50.68 192.94,50.96 194.14,50.96 194.52,50.58 194.52,50.38 194.68,50.23 JDIMM4.139
  IN4 w0.076: 221.23,45.99 221.25,45.99 221.27,46.01 221.87,46.01 222.3,45.58 232.65,45.58 233.45,46.39 234.41,46.39 234.72,46.08 234.72,45.64 235.28,45.07 236.4,45.07 236.48,45 236.6,45 v2(236.88,44.72)
  IN4 w0.102: 221.23,45.99 219.18,45.99 218.93,45.73 211.01,45.73 210.56,46.18 210.18,46.18 209.74,45.73 209.04,45.73 206.08,48.69 205.94,48.69 205.72,48.47 205.72,48.33 207.78,46.27 207.78,45.96 207.45,45.62 207.13,45.62 203.94,48.81 200.02,48.81 199.64,49.2 194.81,49.2 194.5,49.51 193.03,49.51 192.75,49.79 192.75,50.07 192.75,50.08 v2(192.54,50.29)
DDR_B_CLK#1: length 61.3
  TOP w0.076: v2(236.23,45.63) UC1.AM8
  TOP w0.109: JDIMM4.140 188.3,50.48 188.49,50.28 188.49,50.03 188.76,49.75 189.67,49.75 189.78,49.86 189.78,50.16 189.67,50.27 v2(189.52,50.27)
  IN4 w0.076: v2(236.23,45.63) 235.7,46.17 235.35,46.17 234.59,46.93 233.06,46.93 232.26,46.13 224.97,46.13 224.72,46.38 222.49,46.38 221.99,46.88 220.97,46.88 220.95,46.9 220.93,46.9
  IN4 w0.102: 220.93,46.9 218.8,46.9 218.55,46.65 212.79,46.65 212.69,46.76 212.69,47.09 212.47,47.31 212,47.31 211.78,47.09 211.78,46.76 211.68,46.65 211.42,46.65 208.48,49.6 208.17,49.6 207.83,49.27 207.83,48.95 209.6,47.19 209.6,47.04 209.38,46.83 209.24,46.83 206.34,49.73 200.44,49.73 200.03,50.14 195.19,50.14 194.46,50.86 191.49,50.86 191.39,50.96 189.91,50.96 189.67,50.72 189.67,50.41 v2(189.52,50.27)
DDR_B_CLK#2: length 61.6
  TOP w0.076: UC1.AM10 v2(237.53,45.63)
  IN4 w0.076: v2(237.53,45.63) 237.72,45.44 237.83,45.44 237.91,45.52 237.91,45.86 237.74,46.03 236.07,46.03 235.74,46.37 235.43,46.37 234.58,47.22 232.19,47.22 231.33,46.37 225.28,46.37 224.88,46.76 224.58,46.76 224.56,46.74 224.54,46.74
  IN4 w0.102: v2(186.87,52.05) 186.87,52.23 186.77,52.33 186.59,52.33 186.5,52.41 186.5,52.67 186.64,52.8 187.47,52.8 188.1,52.17 188.1,51.99 188.69,51.39 191.71,51.39 191.81,51.29 194.93,51.29 195.58,50.64 200.25,50.64 200.66,50.24 208.56,50.24 210.96,47.84 212.92,47.84 213.59,47.17 218.35,47.17 218.59,47.41 222.02,47.41 222.7,46.74 224.54,46.74
  BOTTOM w0.109: JDIMM3.139 186.67,50.22 186.41,49.97 186.21,49.97 186.02,50.15 186.02,51 186.5,51.48 186.5,51.91 186.64,52.05 v2(186.87,52.05)
DDR_B_CLK#3: length 63.9
  TOP w0.076: v2(238.18,47.46) UC1.AJ11
  IN4 w0.076: 224.47,47.34 224.49,47.36 224.95,47.36 225.57,46.74 231.15,46.74 231.97,47.56 234.74,47.56 235.35,46.95 236.5,46.95 236.54,46.91 237.71,46.91 237.88,47.08 237.88,47.36 237.98,47.46 v2(238.18,47.46)
  IN4 w0.102: v2(190.79,52.02) 190.61,52.2 190.61,52.34 190.72,52.45 191.48,52.45 192.05,51.88 195.68,51.88 195.98,51.58 200.4,51.58 201.03,50.95 208.91,50.95 211.29,48.57 211.6,48.57 211.94,48.9 211.94,49.22 210.57,50.58 210.57,50.73 210.79,50.94 210.93,50.94 213.99,47.88 218.06,47.88 218.3,48.12 222.25,48.12 223.04,47.34 224.47,47.34
  BOTTOM w0.109: JDIMM3.140 194.92,50.47 194.66,50.22 194.5,50.22 194.39,50.33 194.39,50.68 194.04,51.03 190.85,51.03 190.43,51.46 190.43,51.66 190.52,51.75 190.68,51.75 190.79,51.86 v2(190.79,52.02)
DDR_B_CS#0: length 65.2
  TOP w0.076: v2(238.18,50.21) UC1.AF11
  TOP w0.165: 191.12,54.85 v2(190.71,55.25) ; JDIMM4.149 194.87,54.73
  TOP w0.168: 191.12,54.85 191.63,54.85 192.32,54.16 194.3,54.16 194.87,54.73
  IN4 w0.076: v2(238.18,50.21) 237.65,49.67 236.67,49.67 236.37,49.37 235.38,49.37 235.04,49.71 234.55,49.71 234.4,49.86 231.76,49.86 231.29,49.39 225.77,49.39 225.6,49.56 225.6,50.1 225.03,50.68
  IN4 w0.152: 225.03,50.68 223.81,51.9 223.58,51.9 222.62,52.86 218.4,52.86 217.43,53.83 215.39,53.83 213.42,55.8 213.42,56.62 209.96,60.08 207.32,60.08 206.71,59.46 206.71,58.56 206.56,58.41 205.99,58.41 205.84,58.56 205.84,58.8 205.69,58.95 205.44,58.95 205.28,58.8 205.28,58.56 205.13,58.41 204.88,58.41 204.72,58.56 204.72,58.8 204.57,58.95 204.32,58.95 204.17,58.8 204.17,58.56 204.01,58.41 203.76,58.41 203.61,58.56 203.61,58.8 203.45,58.95 203.2,58.95 203.05,58.8 203.05,58.56 202.9,58.41 201.19,58.41 200.69,57.92 197.41,57.92 195.86,56.37 195.46,56.37 194.98,55.89 191.74,55.89 191.51,55.65 191.08,55.65 190.81,55.92 190.6,55.92 190.39,55.71 190.39,55.57 v2(190.71,55.25)
DDR_B_CS#1: length 63.1
  TOP w0.076: v2(235.58,51.12) UC1.AE7
  TOP w0.168: JDIMM4.157 194.1,56.73 v2(191.27,59.56)
  IN4 w0.076: 219.8,55.43 223.05,55.43 227.37,51.12 v2(235.58,51.12)
  IN4 w0.152: v2(191.27,59.56) 190.96,59.25 190.96,59.1 191.06,59 191.53,59 191.71,59.18 192.07,59.18 192.25,59 192.54,59 192.89,59.35 193.11,59.35 193.38,59.08 193.62,59.08 194.18,59.63 194.51,59.63 196.34,61.46 196.75,61.46 197,61.2 197.35,61.2 197.5,61.36 197.86,61.36 198.02,61.2 199.37,61.2 199.53,61.36 199.53,61.52 199.35,61.7 199.35,61.88 199.49,62.02 199.97,62.02 202.11,64.16 203.53,64.16 203.95,64.58 204.11,64.58 204.28,64.4 204.46,64.4 204.65,64.59 204.65,64.81 204.53,64.93 204.53,65.14 204.71,65.32 204.93,65.32 205.08,65.17 205.32,65.17 205.6,65.45 205.89,65.45 206.17,65.17 206.49,65.17 206.68,65.36 209.88,65.36 209.99,65.25 209.99,65.08 209.89,64.97 209.89,64.75 210.07,64.57 210.28,64.57 210.4,64.69 210.63,64.69 210.81,64.51 210.81,64.31 210.68,64.18 210.68,63.96 215,59.64 215.38,59.64 219.59,55.43 219.8,55.43
DDR_B_CS#2: length 62.1
  TOP w0.076: UC1.AF10 v2(237.53,50.21)
  IN4 w0.076: 223.93,52.27 225.95,50.26 232.59,50.26 232.81,50.03 234.47,50.03 234.62,49.88 235.11,49.88 235.45,49.53 236.27,49.53 236.59,49.85 237.18,49.85 v2(237.53,50.21)
  IN4 w0.152: v2(189.43,55.25) 189.43,55.55 189.19,55.79 188.11,55.79 187.9,56 187.9,56.29 188.2,56.59 189.54,56.59 189.84,56.29 194.71,56.29 195.2,56.78 195.62,56.78 197.22,58.38 200.51,58.38 201,58.87 202.47,58.87 203.01,59.41 205.97,59.41 207.1,60.53 210.15,60.53 213.87,56.8 213.87,55.99 215.56,54.31 217.53,54.31 218.52,53.32 222.89,53.32 223.93,52.27
  BOTTOM w0.168: JDIMM3.149 187.4,54.73 188.91,54.73 v2(189.43,55.25)
DDR_B_CS#3: length 66.3
  TOP w0.076: v2(237.53,51.12) UC1.AE10
  IN4 w0.076: 222.83,55.14 223.09,55.14 227.32,50.92 235.28,50.92 235.43,50.76 237.18,50.76 v2(237.53,51.12)
  IN4 w0.152: v2(189.24,57.38) 188.93,57.69 188.02,57.69 187.13,56.8 186.82,56.8 186.63,56.98 186.63,57.27 187.95,58.58 193.73,58.58 194.05,58.9 194.43,58.9 196.25,60.72 199.53,60.72 199.98,61.17 199.98,61.38 202.3,63.7 203.72,63.7 203.96,63.95 204.65,63.95 205.42,64.71 206.68,64.71 206.87,64.91 209.09,64.91 214.81,59.18 215.03,59.18 219.07,55.14 222.83,55.14
  BOTTOM w0.168: v2(189.24,57.38) 188.58,56.73 187.4,56.73 JDIMM3.157
DDR_B_D0: length 72.8
  TOP w0.076: UC1.BT11 237.8,27.04 237.56,26.81 237.56,26.18 236.94,25.56 236.94,25.15 237.16,24.93 v2(237.34,24.76)
  TOP w0.14: JDIMM4.7 194.69,17.23 194.05,16.59 193.52,16.59 193.36,16.44 v2(193.36,16.27)
  IN4 w0.076: 236.42,23.12 236.42,23.84 v2(237.34,24.76)
  IN4 w0.14: v2(193.36,16.27) 193.36,16.55 193.52,16.71 194.33,16.71 196.58,14.47 199.24,14.47 199.71,14 221.14,14 221.28,13.86 221.28,13.59 221.14,13.45 218,13.45 217.86,13.31 217.86,13.04 218,12.9 222.29,12.9 223.45,11.74 233.42,11.74 236.42,14.74 236.42,23.12
  BOTTOM w0.152: JDIMM3.8 195.59,17.48 194.88,17.48 194.02,16.61 193.7,16.61 v2(193.36,16.27)
DDR_B_D1: length 74.6
  TOP w0.076: UC1.BR11 237.8,27.74 237.64,27.59 237.64,27.59 237.31,27.25 237.31,26.38 236.67,25.74 236.67,24.78 v2(237.34,24.12)
  TOP w0.152: v2(190.08,16.17) 190.08,16.47 189.45,17.1 189.45,17.44 189.23,17.66 188.83,17.66 188.65,17.48 JDIMM4.8
  IN4 w0.076: 236.82,22.34 236.82,23.61 v2(237.34,24.12)
  IN4 w0.14: v2(190.08,16.17) 190.25,16.34 192.26,16.34 192.87,15.74 194.66,15.74 196.33,14.06 199.05,14.06 199.48,13.63 217.29,13.63 217.43,13.49 217.43,13.22 217.29,13.08 216.44,13.08 216.3,12.94 216.3,12.67 216.44,12.53 222.04,12.53 223.21,11.37 233.58,11.37 236.82,14.62 236.82,22.34
  BOTTOM w0.152: JDIMM3.7 187.4,17.23 188.29,17.23 188.74,16.77 188.74,16.28 189.27,15.76 189.67,15.76 v2(190.08,16.17)
DDR_B_D2: length 71.2
  TOP w0.076: UC1.BT9 v2(236.94,26.64)
  TOP w0.152: v2(192.93,19.25) 193.55,19.25 194.03,19.73 JDIMM4.17
  IN4 w0.076: 234.61,23.22 234.61,24.62 235.74,25.75 236.38,25.75 236.94,26.31 v2(236.94,26.64)
  IN4 w0.14: v2(192.93,19.25) 193.08,19.4 194.71,19.4 197.09,17.01 208.24,17.01 208.39,16.86 208.39,16.59 208.25,16.45 204.44,16.45 204.3,16.31 204.3,16.05 204.44,15.91 222.11,15.91 224.35,13.67 231.03,13.67 233.82,16.46 233.82,22.15 234.61,22.94 234.61,23.22
  BOTTOM w0.152: JDIMM3.16 195.59,19.48 193.79,19.48 193.44,19.13 193.05,19.13 v2(192.93,19.25)
DDR_B_D3: length 74.6
  TOP w0.076: UC1.BR8 236.22,27.51 236.29,27.45 236.29,27.2 235.52,26.44 235.52,25.8 235.29,25.58 v2(235.29,24.41)
  TOP w0.152: v2(191.18,17.31) 191.18,18.08 188.78,20.48 JDIMM4.20
  IN4 w0.14: v2(191.18,17.31) 192.28,18.42 194.64,18.42 196.78,16.28 201.71,16.28 201.88,16.1 201.88,15.83 201.74,15.69 200.41,15.69 200.27,15.55 200.27,15.29 200.41,15.15 221.82,15.15 224.07,12.91 231.31,12.91 235.29,16.88 235.29,24.4 v2(235.29,24.41)
  BOTTOM w0.152: JDIMM3.21 187.4,20.73 188.33,20.73 191.18,17.88 v2(191.18,17.31)
DDR_B_D4: length 74.1
  TOP w0.076: UC1.BP11 238.09,28.33 238.09,26.83 237.84,26.58 237.84,25.9 v2(237.78,25.84)
  TOP w0.152: JDIMM4.4 188.4,16.48 189.52,15.36 v2(190.11,15.36)
  IN4 w0.14: v2(237.78,25.84) 237.78,23.01 238.15,22.64 238.15,16.83 237.21,15.89 237.21,14.46 233.75,11.01 223.03,11.01 221.87,12.16 215.37,12.16 215.23,12.3 215.23,12.57 215.37,12.71 215.67,12.71 215.81,12.85 215.81,13.12 215.67,13.26 210.73,13.26 210.05,12.58 199.89,12.58 198.8,13.66 196.02,13.66 194.38,15.31 192.64,15.31 192.09,15.86 190.61,15.86 v2(190.11,15.36)
  BOTTOM w0.152: JDIMM3.3 187.4,16.23 188.44,16.23 189.43,15.24 189.99,15.24 v2(190.11,15.36)
DDR_B_D5: length 74.3
  TOP w0.076: UC1.BN11 237.8,29.04 238.08,28.76 238.08,28.71 238.29,28.5 238.29,26.35 v2(238.23,26.29)
  TOP w0.152: JDIMM4.3 194.52,16.23 194.38,16.08 194.38,15.8 194.08,15.49 194.08,14.87 v2(194.25,14.7)
  IN4 w0.14: v2(238.23,26.29) 238.23,23.35 238.52,23.06 238.52,16.45 237.6,15.53 237.6,14.28 233.95,10.64 222.84,10.64 221.68,11.8 212.16,11.8 212.02,11.94 212.02,12.2 212.16,12.34 214.58,12.34 214.72,12.48 214.72,12.75 214.58,12.89 210.88,12.89 210.21,12.21 199.54,12.21 198.45,13.3 195.65,13.3 v2(194.25,14.7)
  BOTTOM w0.152: JDIMM3.4 194.72,16.47 194.38,16.14 194.38,14.83 v2(194.25,14.7)
DDR_B_D6: length 73.6
  TOP w0.076: UC1.BP8 236.51,28.33 236.51,27.08 235.72,26.29 235.72,25.07 v2(235.69,25.04)
  TOP w0.152: JDIMM4.16 188.68,19.48 189.96,18.2 v2(189.96,17.34)
  IN4 w0.076: v2(235.69,25.04) 235.35,25.04 234.92,24.61 234.92,22.81
  IN4 w0.14: v2(189.96,17.34) 189.96,17.82 190.94,18.81 194.77,18.81 196.94,16.65 203.73,16.65 203.89,16.49 203.89,16.23 203.75,16.09 202.46,16.09 202.32,15.95 202.32,15.68 202.46,15.54 221.95,15.54 224.19,13.3 231.19,13.3 234.51,16.63 234.51,21.84 234.92,22.25 234.92,22.81
  BOTTOM w0.152: JDIMM3.17 187.4,19.73 188.24,19.73 189.96,18.01 v2(189.96,17.34)
DDR_B_D7: length 74.9
  TOP w0.076: v2(236.34,26.26) 236.34,26.6 236.72,26.98 236.72,28.73 236.22,29.22 UC1.BN8
  TOP w0.152: v2(191.69,19.25) 192.18,19.74 193.42,19.74 194.41,20.73 JDIMM4.21
  IN4 w0.076: 234.14,23.34 234.28,23.48 234.28,24.73 235.82,26.26 v2(236.34,26.26)
  IN4 w0.14: 234.14,23.34 233.28,22.47 233.28,16.43 230.88,14.04 224.5,14.04 222.26,16.28 209.07,16.28 208.91,16.43 208.91,16.7 209.05,16.84 211.45,16.84 211.59,16.98 211.59,17.24 211.45,17.38 197.24,17.38 194.59,20.03 192.61,20.03 191.83,19.25 v2(191.69,19.25)
  BOTTOM w0.152: JDIMM3.20 195.59,20.48 193.89,20.48 193.2,19.78 192.05,19.78 191.69,19.42 v2(191.69,19.25)
DDR_B_D8: length 71.1
  TOP w0.076: UC1.BL12 238.52,30.58 238.33,30.39 v2(238.19,30.25)
  TOP w0.152: v2(192.42,20.52) 193.37,21.46 194.14,21.46 194.41,21.73 JDIMM4.25
  IN4 w0.076: 233.77,23.69 233.9,23.81 233.9,24.65 236.49,27.25 236.49,29.21 237.53,30.25 v2(238.19,30.25)
  IN4 w0.14: 233.77,23.69 232.67,22.58 232.67,16.59 230.57,14.48 224.98,14.48 222.56,16.9 212.31,16.9 212.14,17.07 212.14,17.33 212.28,17.47 213.28,17.47 213.42,17.61 213.42,17.88 213.28,18.02 200.4,18.02 199.99,18.44 196.82,18.44 194.29,20.96 192.87,20.96 v2(192.42,20.52)
  BOTTOM w0.152: JDIMM3.24 193.2,21.47 192.42,20.7 v2(192.42,20.52)
DDR_B_D9: length 72.1
  TOP w0.076: UC1.BL11 v2(238.18,31.05)
  TOP w0.152: v2(191.18,20.52) 190.78,20.91 189.42,20.91 188.82,21.52 188.82,22.16 188.51,22.48 JDIMM4.28
  IN4 w0.076: v2(238.18,31.05) 237.66,30.53 237.5,30.53 236.28,29.32 236.28,27.34 233.55,24.61 233.55,23.9 233.42,23.77
  IN4 w0.14: v2(191.18,20.52) 191.94,21.28 194.5,21.28 196.97,18.8 200.15,18.8 200.57,18.39 213.56,18.39 214.68,17.27 222.72,17.27 225.12,14.86 230.38,14.86 232.28,16.76 232.28,22.63 233.42,23.77
  BOTTOM w0.152: v2(191.18,20.52) 191.18,20.82 190.83,21.16 190.15,21.16 188.59,22.73 187.4,22.73 JDIMM3.29
DDR_B_D10: length 68.1
  TOP w0.076: UC1.BL8 v2(236.62,30.25)
  TOP w0.152: v2(189.93,20.52) 189.27,20.52 188.32,21.48 JDIMM4.24
  IN4 w0.076: 232.19,24.71 233.85,26.37 233.85,26.86 236.04,29.05 236.04,29.68 v2(236.62,30.25)
  IN4 w0.14: v2(189.93,20.52) 189.8,20.65 189.8,21.21 189.99,21.4 191.59,21.4 191.75,21.55 194.74,21.55 197.12,19.17 200.31,19.17 200.72,18.76 213.75,18.76 214.87,17.64 222.87,17.64 225.28,15.23 230.23,15.23 231.91,16.91 231.91,24.43 232.19,24.71
  BOTTOM w0.152: JDIMM3.25 187.4,21.73 188.73,21.73 v2(189.93,20.52)
DDR_B_D11: length 69.3
  TOP w0.076: v2(236.23,31.92) UC1.BJ8
  TOP w0.152: v2(192.94,23.68) 193.65,23.68 194.16,24.18 194.16,24.35 194.53,24.73 JDIMM4.37
  IN4 w0.076: 228.27,24.49 228.63,24.85 228.63,25.64 231.36,28.37 232.98,28.37 234.4,29.79 234.4,30.28 235.44,31.32 235.83,31.32 236.23,31.72 v2(236.23,31.92)
  IN4 w0.14: v2(192.94,23.68) 192.96,23.66 195.28,23.66 196.08,22.86 199.45,22.86 201.68,20.62 223.01,20.62 223.15,20.76 223.15,21.03 223.01,21.17 217.31,21.17 217.17,21.31 217.17,21.58 217.31,21.72 224.04,21.72 226.36,24.04 227.82,24.04 228.27,24.49
  BOTTOM w0.152: JDIMM3.38 194.8,24.97 194.17,24.35 193.61,24.35 v2(192.94,23.68)
DDR_B_D12: length 72.2
  TOP w0.076: v2(237.53,31.92) UC1.BJ11
  TOP w0.152: JDIMM4.38 188.14,24.98 189.99,23.12 v2(189.99,21.94)
  IN4 w0.076: v2(237.53,31.92) 237.12,31.51 236.35,31.51 235.95,31.1 235.5,31.1 234.64,30.23 234.64,29.73 232.95,28.04 231.36,28.04 228.86,25.54 228.86,24.33 228.53,24
  IN4 w0.14: 228.53,24 228.12,23.59 226.54,23.59 222.13,19.17 218.89,19.17 218.76,19.3 218.76,19.57 218.9,19.71 221.59,19.71 221.73,19.85 221.73,20.12 221.59,20.26 201.53,20.26 199.3,22.49 195.93,22.49 195.16,23.25 190.97,23.25 189.98,22.27 189.98,21.95 v2(189.99,21.94)
  BOTTOM w0.152: JDIMM3.37 187.4,24.73 188.54,24.73 189.99,23.27 v2(189.99,21.94)
DDR_B_D13: length 71.3
  TOP w0.076: v2(236.88,31.92) UC1.BJ10
  TOP w0.152: JDIMM4.42 188.3,25.98 190.39,23.89 v2(190.39,23.7)
  IN4 w0.076: 227.75,25.01 228.18,25.44 228.18,25.87 231.39,29.08 233.05,29.08 233.9,29.93 233.9,30.37 235.18,31.64 235.18,32.03 235.48,32.33 236.47,32.33 v2(236.88,31.92)
  IN4 w0.14: 227.75,25.01 227.57,24.83 226.03,24.83 223.65,22.45 207.58,22.45 207.44,22.31 207.44,22.05 207.58,21.91 211.67,21.91 211.81,21.77 211.81,21.5 211.67,21.36 201.99,21.36 199.75,23.59 196.39,23.59 195.59,24.39 193.56,24.39 193.44,24.51 191.2,24.51 v2(190.39,23.7)
  BOTTOM w0.152: JDIMM3.41 188.72,25.72 190.39,24.06 v2(190.39,23.7)
DDR_B_D14: length 67.1
  TOP w0.076: v2(235.8,30.29) UC1.BL7
  TOP w0.152: JDIMM4.29 194.16,22.73 v2(193.41,21.97)
  IN4 w0.076: 231.66,25.04 231.66,25.38 232.91,26.64 232.91,26.89 233.15,27.12 233.81,27.12 235.8,29.11 v2(235.8,30.29)
  IN4 w0.14: v2(193.41,21.97) 194.84,21.97 197.28,19.54 200.46,19.54 200.87,19.12 217.06,19.12 217.2,18.99 217.2,18.72 217.06,18.58 215.07,18.58 214.93,18.44 214.93,18.17 215.07,18.03 223.07,18.03 225.48,15.63 230.08,15.63 231.29,16.84 231.29,24.52 231.66,24.89 231.66,25.04
  BOTTOM w0.152: JDIMM3.28 194.65,22.47 194.04,21.86 193.52,21.86 v2(193.41,21.97)
DDR_B_D15: length 70.8
  TOP w0.076: v2(235.58,31.92) UC1.BJ7
  TOP w0.152: JDIMM4.41 194.69,25.73 193.43,24.47 192.02,24.47 191.65,24.1 v2(191.65,23.67)
  IN4 w0.076: v2(235.58,31.92) 235.58,31.75 234.14,30.32 234.14,29.87 233,28.72 231.39,28.72 228.42,25.75 228.42,25.17 228.12,24.87 228.12,24.86 228.01,24.75
  IN4 w0.14: 228.01,24.75 227.68,24.42 226.16,24.42 223.82,22.08 212.31,22.08 212.17,21.94 212.17,21.68 212.31,21.54 216.66,21.54 216.8,21.4 216.8,21.13 216.66,20.99 201.83,20.99 199.6,23.22 196.23,23.22 195.43,24.02 193.23,24.02 193.18,24.06 192.05,24.06 v2(191.65,23.67)
  BOTTOM w0.152: v2(191.65,23.67) 192.72,24.74 193.72,24.74 194.34,25.35 194.34,25.6 194.71,25.97 JDIMM3.42
DDR_B_D16: length 64.5
  TOP w0.076: v2(238.17,33.75) UC1.BG11
  TOP w0.152: JDIMM4.49 194.5,27.73 192.3,25.52 v2(192.3,25.36)
  IN4 w0.076: 226.65,25.34 226.73,25.42 227.36,25.42 231.35,29.41 231.98,29.41 233.13,30.55 233.8,30.55 234.96,31.71 234.96,32.16 235.46,32.65 235.62,32.65 236.15,33.19 237.4,33.19 237.58,33.37 237.79,33.37 v2(238.17,33.75)
  IN4 w0.14: 226.65,25.34 225.91,25.34 223.47,22.9 205.91,22.9 205.77,22.76 205.77,22.49 205.91,22.35 206.82,22.35 206.96,22.21 206.96,21.94 206.82,21.8 202.17,21.8 199.38,24.6 196.01,24.6 195.77,24.84 193.73,24.84 193.59,24.98 192.68,24.98 v2(192.3,25.36)
  BOTTOM w0.152: JDIMM3.50 194.91,27.97 v2(192.3,25.36)
DDR_B_D17: length 62.8
  TOP w0.076: v2(237.53,33.75) UC1.BG10
  TOP w0.152: JDIMM4.45 194.35,26.73 193.71,26.09 v2(193.71,25.34)
  IN4 w0.076: 231.86,31.14 231.92,31.2 231.92,31.86 232.2,32.14 234.56,32.14 235.37,32.95 235.6,32.95 236.04,33.39 237.18,33.39 v2(237.53,33.75)
  IN4 w0.14: v2(193.71,25.34) 196.43,25.34 196.81,24.96 199.53,24.96 202.32,22.17 205.24,22.17 205.38,22.31 205.38,22.58 205.24,22.72 202.62,22.72 202.48,22.86 202.48,23.13 202.62,23.27 223.32,23.27 225.77,25.72 226.44,25.72 231.86,31.14
  BOTTOM w0.152: v2(193.71,25.34) 193.71,25.92 194.77,26.98 195.59,26.98 JDIMM3.46
DDR_B_D18: length 62.8
  TOP w0.076: v2(236.23,33.75) UC1.BG8
  TOP w0.152: JDIMM4.46 189.49,26.98 v2(191.1,25.37)
  IN4 w0.076: 231.6,31.4 231.67,31.47 231.67,31.91 232.11,32.34 234.36,32.34 235.24,33.22 235.56,33.22 236.08,33.75 v2(236.23,33.75)
  IN4 w0.14: 231.6,31.4 226.29,26.09 225.62,26.09 224.26,24.73 222.52,24.73 222.16,24.73 222.02,24.59 222.02,24.32 222.16,24.18 223.15,24.18 223.29,24.04 223.29,23.77 223.15,23.63 201.38,23.63 199.69,25.33 197,25.33 196.5,25.83 191.57,25.83 v2(191.1,25.37)
  BOTTOM w0.152: v2(191.1,25.37) 191.1,25.54 189.92,26.73 187.4,26.73 JDIMM3.45
DDR_B_D19: length 63
  TOP w0.076: v2(236.23,34.66) UC1.BF8
  TOP w0.152: v2(190.64,29.07) 190.64,29.25 189.92,29.98 JDIMM4.58
  IN4 w0.076: 230.44,33.32 230.54,33.42 233.84,33.42 235.43,35.02 235.74,35.02 236.1,34.66 v2(236.23,34.66)
  IN4 w0.14: 230.44,33.32 227.34,30.22 227.11,30.22 223.49,26.6 215.65,26.6 215.51,26.46 215.51,26.19 215.65,26.05 216.93,26.05 217.07,25.91 217.07,25.65 216.93,25.51 202.15,25.51 199.11,28.55 196.83,28.55 196.32,28.03 191.68,28.03 v2(190.64,29.07)
  BOTTOM w0.152: v2(190.64,29.07) 189.49,30.22 JDIMM3.59
DDR_B_D20: length 67.6
  TOP w0.076: v2(238.17,34.66) UC1.BF11
  TOP w0.152: v2(193.22,29.12) 193.22,29.28 192.63,29.88 191.72,29.88 191.19,30.41 190.03,30.41 189.47,30.98 JDIMM4.62
  IN4 w0.076: v2(238.17,34.66) 237.61,35.22 236.17,35.22 235.91,35.47 235.28,35.47 233.68,33.87 229.95,33.87 229.92,33.84
  IN4 w0.14: 229.92,33.84 227.33,31.25 227.1,31.25 223.23,27.38 211.95,27.38 211.81,27.24 211.81,26.97 211.95,26.83 213.13,26.83 213.27,26.69 213.27,26.43 213.13,26.29 202.48,26.29 199.48,29.28 193.96,29.28 193.8,29.12 193.22,29.12 v2(193.22,29.12)
  BOTTOM w0.152: v2(193.22,29.12) 192.45,29.89 191.66,29.89 191.11,30.43 190.01,30.43 189.22,31.23 187.4,31.23 JDIMM3.63
DDR_B_D21: length 66
  TOP w0.076: v2(237.53,34.66) UC1.BF10
  TOP w0.152: v2(192.05,29.14) 192.05,29.14 192.57,28.62 193.28,28.62 193.61,28.96 193.61,29.98 194.85,31.23 JDIMM4.63
  IN4 w0.076: 230.18,33.58 230.25,33.65 233.77,33.65 235.37,35.25 235.82,35.25 236.05,35.02 237.18,35.02 v2(237.53,34.66)
  IN4 w0.14: 230.18,33.58 227.3,30.7 227.07,30.7 223.33,26.97 213.87,26.97 213.73,26.83 213.73,26.56 213.87,26.42 215,26.42 215.14,26.28 215.14,26.01 215,25.87 202.37,25.87 199.33,28.91 196.44,28.91 196.06,28.53 192.36,28.53 192.05,28.84 v2(192.05,29.14)
  BOTTOM w0.152: v2(192.05,29.14) 192.05,28.95 192.4,28.6 193.26,28.6 193.61,28.96 193.61,29.95 194.64,30.97 JDIMM3.62
DDR_B_D22: length 60.2
  TOP w0.076: v2(235.58,33.75) UC1.BG7
  TOP w0.152: JDIMM4.50 188.92,27.98 v2(189.4,27.49)
  IN4 w0.076: 231.2,31.72 232.04,32.56 233.72,32.56 233.72,32.56 234.21,32.56 235.16,33.52 235.35,33.52 v2(235.58,33.75)
  IN4 w0.14: 231.2,31.72 231.05,31.57 231.05,31.36 226.35,26.67 225.68,26.67 224.11,25.1 222.02,25.1 220.93,24.01 201.53,24.01 199.84,25.7 197.2,25.7 196.6,26.3 189.05,26.3 188.28,27.07 188.28,27.27 188.47,27.46 188.66,27.46 189.25,26.87 189.45,26.87 189.64,27.06 189.64,27.26 v2(189.4,27.49)
  BOTTOM w0.152: JDIMM3.49 188.33,27.72 188.44,27.83 189.06,27.83 v2(189.4,27.49)
DDR_B_D23: length 63.3
  TOP w0.076: v2(235.58,34.66) UC1.BF7
  TOP w0.152: JDIMM4.59 194.7,30.23 193.9,29.43 193.9,28.54 v2(192.89,27.53)
  IN4 w0.076: 230.7,33.06 230.84,33.2 233.98,33.2 235.44,34.66 v2(235.58,34.66)
  IN4 w0.14: v2(192.89,27.53) 192.9,27.54 199.6,27.54 202,25.14 220.46,25.14 220.6,25.28 220.6,25.54 220.46,25.68 217.7,25.68 217.56,25.82 217.56,26.09 217.7,26.23 223.64,26.23 227.08,29.67 227.31,29.67 230.68,33.04 230.68,33.04 230.7,33.06
  BOTTOM w0.152: JDIMM3.58 195.59,29.98 194.61,29.98 194.05,29.42 194.05,28.38 193.19,27.53 v2(192.89,27.53)
DDR_B_D24: length 62.5
  TOP w0.076: v2(238.18,37.4) UC1.BB11
  TOP w0.152: v2(193.72,36.39) 194,36.1 194.55,36.1 194.67,36.23 JDIMM4.83
  IN4 w0.076: v2(238.18,37.4) 237.72,37.87 237.43,37.87 237.34,37.96 236.16,37.96 235.88,38.24 227.71,38.24 225.08,35.61 225.08,35.61 223.43,33.96 223.43,33.63 223.34,33.54
  IN4 w0.14: v2(193.72,36.39) 194.3,36.39 196.33,34.36 199.88,34.36 204.05,30.18 207.44,30.18 207.58,30.32 207.58,30.59 207.44,30.73 204.39,30.73 204.25,30.87 204.25,31.13 204.39,31.27 221.07,31.27 223.34,33.54
  BOTTOM w0.152: v2(193.72,36.39) 193.88,36.23 194.5,36.23 194.75,36.47 JDIMM3.84
DDR_B_D25: length 63.2
  TOP w0.076: v2(238.17,36.49) UC1.BC11
  TOP w0.152: JDIMM4.66 189.46,31.98 190.15,31.28 v2(190.15,31.09)
  IN4 w0.076: v2(238.17,36.49) 237.72,36.04 237.42,36.04 237.31,35.93 236.17,35.93 235.96,35.73 235.24,35.73 234.97,35.46 233.87,35.46 233.15,34.74 229.57,34.74 227.07,32.25 227.07,32.11 226.83,31.86
  IN4 w0.14: 226.83,31.86 222.79,27.82 211.7,27.82 210.69,26.82 202.57,26.82 199.66,29.73 191.35,29.73 190.96,30.12 190.76,30.12 190.07,29.43 189.87,29.43 189.68,29.62 189.68,29.81 190.4,30.54 190.4,30.83 v2(190.15,31.09)
  BOTTOM w0.152: v2(190.15,31.09) 189.01,32.23 187.4,32.23 JDIMM3.67
DDR_B_D26: length 64.3
  TOP w0.076: v2(236.23,37.4) UC1.BB8
  TOP w0.152: v2(191.15,34.77) 191.78,34.14 193.02,34.14 194.1,35.23 JDIMM4.79
  IN4 w0.076: 224.12,33.77 224.12,34.05 227.91,37.84 235.65,37.84 236.09,37.4 v2(236.23,37.4)
  IN4 w0.14: 224.12,33.77 224.12,33.29 221.26,30.43 210.47,30.43 209.49,29.44 203.63,29.44 199.5,33.58 195.61,33.58 194.75,34.44 194.55,34.44 194.08,33.97 193.88,33.97 193.69,34.16 193.69,34.36 194.16,34.83 194.16,35.02 193.92,35.27 191.64,35.27 191.15,34.78 v2(191.15,34.77)
  BOTTOM w0.152: v2(191.15,34.77) 191.67,34.25 192.81,34.25 194.04,35.48 195.59,35.48 JDIMM3.80
DDR_B_D27: length 62.4
  TOP w0.076: v2(236.23,36.49) UC1.BC8
  TOP w0.152: JDIMM4.71 194.54,33.23 194.2,32.88 193.75,32.88 192.74,31.87 192.74,31.12 v2(192.77,31.09)
  IN4 w0.076: v2(236.23,36.49) 236.09,36.49 235.73,36.13 235.04,36.13 234.77,35.86 233.5,35.86 232.94,35.3 232.24,35.3
  IN4 w0.14: 232.24,35.3 228.55,35.3 226.36,33.12 226.36,32.67 222.26,28.56 211.39,28.56 210.39,27.55 202.88,27.55 199.34,31.1 199.07,31.1 198.93,30.96 198.93,30.74 198.79,30.6 198.52,30.6 198.38,30.74 198.38,30.96 198.24,31.1 196.81,31.1 196.31,30.6 194.01,30.6 193.87,30.74 193.87,31.01 194.01,31.15 195.14,31.15 195.28,31.29 195.28,31.56 195.14,31.7 193.77,31.7 193.16,31.09 v2(192.77,31.09)
  BOTTOM w0.152: JDIMM3.70 195.59,32.98 194.53,32.98 194.05,32.5 194.05,31.94 193.61,31.49 193.05,31.49 192.77,31.21 v2(192.77,31.09)
DDR_B_D28: length 64.1
  TOP w0.076: v2(237.53,36.49) UC1.BC10
  TOP w0.152: v2(191.5,31.09) 191.94,30.64 192.91,30.64 194.49,32.23 JDIMM4.67
  IN4 w0.076: v2(237.53,36.49) 237.18,36.13 236.03,36.13 235.83,35.93 235.14,35.93 234.87,35.66 233.73,35.66 233.01,34.95 229.39,34.95 227.41,32.97
  IN4 w0.14: 227.41,32.97 222.64,28.19 211.55,28.19 210.54,27.19 202.73,27.19 199.82,30.1 193.73,30.1 193.58,30.24 193.58,30.51 193.44,30.65 193.18,30.65 193.04,30.51 193.04,30.24 192.9,30.1 192.63,30.1 192.49,30.24 192.49,30.48 192.35,30.62 192.09,30.62 191.95,30.48 191.95,30.24 191.81,30.1 191.5,30.1 191.37,30.22 191.37,30.96 v2(191.5,31.09)
  BOTTOM w0.152: JDIMM3.66 194.66,31.97 193.2,30.52 192.07,30.52 v2(191.5,31.09)
DDR_B_D29: length 63.2
  TOP w0.076: v2(237.53,37.4) UC1.BB10
  TOP w0.152: v2(189.8,34.77) 189.24,34.77 188.53,35.48 JDIMM4.80
  IN4 w0.076: 223.81,33.98 223.81,34.04 227.81,38.04 235.77,38.04 236.05,37.76 237.18,37.76 v2(237.53,37.4)
  IN4 w0.14: 223.81,33.98 223.81,33.49 221.22,30.9 208.25,30.9 208.11,30.76 208.11,30.5 208.25,30.36 209.12,30.36 209.26,30.22 209.26,29.95 209.12,29.81 203.78,29.81 199.65,33.95 196.03,33.95 194.13,35.84 190.88,35.84 v2(189.8,34.77)
  BOTTOM w0.152: v2(189.8,34.77) 189.67,34.64 189.33,34.64 188.75,35.22 JDIMM3.79
DDR_B_D30: length 59.1
  TOP w0.076: v2(235.58,36.49) UC1.BC7
  TOP w0.152: v2(189.56,32.6) 189.07,33.09 188.59,33.09 188.47,32.98 JDIMM4.70
  IN4 w0.076: v2(235.58,36.49) 235.08,36.49 234.66,36.07 233.25,36.07 232.86,35.67 232.26,35.67
  IN4 w0.14: 232.26,35.67 228.39,35.67 226.01,33.29 226.01,32.92 222.02,28.93 211.18,28.93 210.17,27.92 203.03,27.92 199.49,31.47 197.3,31.47 196.69,32.08 196.37,32.08 196.23,31.94 196.23,31.31 196.09,31.17 195.83,31.17 195.69,31.31 195.69,31.94 195.55,32.08 193.59,32.08 193.06,31.54 190.62,31.54 v2(189.56,32.6)
  BOTTOM w0.152: JDIMM3.71 188.19,33.22 188.81,32.6 v2(189.56,32.6)
DDR_B_D31: length 64.3
  TOP w0.076: v2(235.58,37.4) UC1.BB7
  TOP w0.152: JDIMM4.84 188.35,36.48 189.49,35.34 191.86,35.34 v2(192.44,34.76)
  IN4 w0.076: v2(235.58,37.4) 235.36,37.62 228.03,37.62 224.44,34.03 224.44,33.52
  IN4 w0.14: v2(192.44,34.76) 192.99,34.21 192.99,34.01 192.81,33.82 192.61,33.82 192.35,34.08 192.15,34.08 191.96,33.89 191.96,33.69 192.45,33.21 199.34,33.21 203.48,29.07 209.73,29.07 210.71,30.06 221.48,30.06 224.44,33.02 224.44,33.52
  BOTTOM w0.152: v2(192.44,34.76) 192.44,34.93 192.13,35.24 189.46,35.24 188.48,36.23 187.4,36.23 JDIMM3.83
DDR_B_D32: length 72.2
  TOP w0.076: v2(238.18,53.86) UC1.AA11
  TOP w0.152: v2(190.85,66.61) 188.21,63.98 JDIMM4.186
  IN4 w0.076: v2(238.18,53.86) 237.62,54.42 236.08,54.42 235.79,54.72 235.08,54.72 234.69,55.11 229.82,55.11 226.55,58.38 225.42,58.38 225.1,58.7 224.89,58.7
  IN4 w0.14: v2(190.85,66.61) 189.14,66.61 188.95,66.43 188.95,66.22 189.09,66.08 192.32,66.08 192.53,66.29 193.55,66.29 193.78,66.52 193.78,66.81 194.49,67.53 195.03,67.53 196.95,69.45 198.56,69.45 199.32,70.2 200.85,70.2 202.06,71.4 202.14,71.4 202.67,71.93 206.79,71.93 207.49,72.62 211.09,72.62 213.03,70.68 213.03,69.96 224.3,58.7 224.89,58.7
  BOTTOM w0.152: v2(190.85,66.61) 190.39,66.61 189.97,66.19 189.97,65.99 188.2,64.22 JDIMM3.187
