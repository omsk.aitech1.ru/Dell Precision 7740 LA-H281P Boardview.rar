# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML0_SMBCLK: length 284.1
  TOP w0.102: 121.33,36.31 121.97,36.31 122.16,36.5 123.1,36.5 123.32,36.73 UH1.BF25
  TOP w0.109: v2(148.58,140.56) 149.01,140.99 149.5,140.99 149.66,140.83 UL1.28 ; v2(115.03,36.33) 115.51,35.85 115.51,35.6 115.64,35.47 116.02,35.47 116.4,35.09 117.17,35.09 117.63,35.55 RH67.2 118.05,35.15 119.48,35.15 119.91,35.58 CC318.1 120.17,35.62 120.68,36.13 120.76,36.13 120.93,36.31 121.33,36.31
  IN1 w0.102: v2(148.58,140.56) 148.32,140.81 148.32,141.21 149.46,142.34 149.46,144.47 148.95,144.98 146.08,144.98 143.43,147.63 138.15,147.63 131.31,154.47 119.09,154.47 117.7,153.08 117.7,144.17 113.1,139.57 113.1,126.06 110.83,123.79 110.83,114.73 108.91,112.81 108.91,107.24 110.7,105.45 110.7,99.49 112.75,97.44 112.75,95.79 113.42,95.11 113.42,91.96 114.03,91.35 115.05,91.35 115.39,91.01 115.39,89.99 115.66,89.73 115.66,84.15 113.99,82.48 113.99,76.59 112.4,75 112.4,71.33 111.67,70.59 111.67,68.86 110.58,67.77 110.58,63.18 111.61,62.15 111.61,60.8 111.96,60.45 111.96,52.15 113.39,50.72 113.39,44.76 113.64,44.51 113.64,40.72 113.92,40.44 113.92,39.2 113.86,39.15 113.86,37.97 114.63,37.21 114.63,36.73 v2(115.03,36.33)
  IN4 w0.102: v2(39.41,60.19) 39.18,59.96 39.18,59.2 43.35,55.03 44.19,55.03 45.13,54.09 47.98,54.09 48.82,53.25 50.04,53.25 50.35,53.56 52.68,53.56 53.71,54.59 58.27,54.59 58.79,54.07 71.21,54.07 72.74,55.59 76.01,55.59 77.09,54.51 80.76,54.51 81.77,55.53 86.25,55.53 86.64,55.92 91.04,55.92 95.57,60.44 102.83,60.44 106.31,56.96 107.16,56.96 109.19,54.93 109.87,54.93 114.18,50.62 114.18,47.57 114.74,47.01 114.74,46.59 114.34,46.18 v2(114.32,46.18)
  BOTTOM w0.109: v2(114.32,46.18) 114.04,45.9 114.04,42.02 114.86,41.2 114.86,38.94 115.64,38.16 115.64,37.02 115.03,36.41 v2(115.03,36.33) ; RT623.1 39.2,59.98 v2(39.41,60.19)
SML0_SMBDATA: length 282.3
  TOP w0.102: 120,37.23 120.23,37.46 120.5,37.46 120.89,37.85 121.6,37.85 121.95,37.5 123.79,37.5 123.87,37.42 UH1.BE24
  TOP w0.109: 120,37.23 119.19,37.23 118.92,37.49 117.32,37.49 117.19,37.62 116.75,37.62 RH77.2 115.18,36.84 v2(115.03,36.99) ; v2(149.33,139.57) 149.39,139.63 UL1.31
  IN1 w0.102: v2(115.03,36.99) 114.86,37.17 114.86,37.3 114.09,38.06 114.09,39.05 114.15,39.11 114.15,40.54 113.87,40.82 113.87,44.61 113.62,44.86 113.62,50.82 112.19,52.24 112.19,60.54 111.83,60.9 111.83,62.25 110.81,63.27 110.81,67.67 111.9,68.76 111.9,70.5 112.63,71.23 112.63,74.91 114.22,76.5 114.22,82.39 115.89,84.06 115.89,89.82 115.62,90.09 115.62,91.11 115.15,91.58 114.13,91.58 113.65,92.06 113.65,95.21 112.98,95.88 112.98,97.54 110.93,99.58 110.93,105.55 109.14,107.34 109.14,112.72 111.06,114.63 111.06,123.69 113.33,125.97 113.33,139.48 117.93,144.07 117.93,152.99 119.19,154.24 131.21,154.24 138.05,147.4 143.33,147.4 145.99,144.75 148.81,144.75 149.23,144.33 149.23,142.44 148.09,141.3 148.09,140.39 148.91,139.57 v2(149.33,139.57)
  IN4 w0.102: v2(38.81,60.21) 38.95,60.07 38.95,59.1 43.25,54.8 44.09,54.8 45.03,53.86 47.89,53.86 48.73,53.02 50.14,53.02 50.44,53.33 52.78,53.33 53.81,54.36 58.18,54.36 58.7,53.84 71.31,53.84 72.83,55.36 75.92,55.36 77,54.28 80.85,54.28 81.87,55.3 86.35,55.3 86.74,55.69 91.14,55.69 95.66,60.21 102.74,60.21 106.22,56.73 107.07,56.73 109.1,54.7 109.78,54.7 113.95,50.52 113.95,47.47 114.33,47.1 v2(114.33,46.82)
  BOTTOM w0.109: RT624.1 38.62,60.02 v2(38.81,60.21) ; v2(114.33,46.82) 113.8,46.29 113.8,41.92 114.63,41.1 114.63,38.84 115.4,38.06 115.4,37.34 115.05,36.99 v2(115.03,36.99)
SML1_SMBCLK: length 90.1
  TOP w0.089: 121.87,35.52 121.87,35.51 122.18,35.51 122.45,35.78 123.06,35.78 123.22,35.63 123.26,35.63 123.35,35.54 UH1.BF27
  TOP w0.109: UE1.D8 138.44,76.88 v2(138.81,77.25) ; 121.87,35.52 121.3,35.52 121.15,35.37 121.15,34.99 120.41,34.24 117.85,34.24 117.73,34.12 116.04,34.12 115.81,34.35 115.18,34.35 115.02,34.19 115.02,33.99 114.85,33.83 114.42,33.83 114.1,33.5 RH80.2 114.07,33.29 CC319.1 112.69,33.93 110.48,33.93 v2(110.26,33.72)
  IN3 w0.081: v2(110.26,33.72) 110.02,33.96 109.69,33.96 109.42,34.23 109.42,35.69 110.4,36.67 110.4,42.74 111.69,44.03 111.69,53.65 114.14,56.09 116.58,56.09 117.66,57.16 117.66,57.43 122.68,62.45 126.37,62.45 127.57,61.25 130.29,61.25 131.59,62.55 133.83,62.55 134.36,63.08 137.9,63.08 139.5,64.68 140.97,64.68 141.22,64.93 141.26,64.93 143.22,66.88 143.22,67.39 144.63,68.8 144.63,72.08 141.71,75 140.98,75 140.82,75.16 140.82,76.59 140.56,76.84 139.22,76.84 v2(138.81,77.25)
SML1_SMBDATA: length 87
  TOP w0.089: 121.88,35.75 121.94,35.69 122.11,35.69 122.38,35.96 123.14,35.96 123.29,35.8 123.37,35.8 123.39,35.78 123.72,35.78 123.96,35.54 UH1.BE27
  TOP w0.109: v2(110.26,34.43) 110.52,34.17 112.86,34.17 113.2,33.83 114.02,33.83 RH81.2 114.78,34.58 115.91,34.58 116.14,34.36 117.63,34.36 117.76,34.48 120.31,34.48 120.92,35.09 120.92,35.47 121.2,35.75 121.88,35.75 ; v2(141.21,76.45) 140.84,76.08 UE1.E11
  IN3 w0.081: v2(141.21,76.45) 141.21,76.3 142.06,75.45 142.06,74.97 144.85,72.18 144.85,72.17 144.83,72.15 144.83,68.71 143.43,67.3 143.43,66.8 141.35,64.72 141.31,64.72 141.05,64.47 139.58,64.47 137.97,62.85 134.46,62.85 133.92,62.32 131.68,62.32 130.39,61.03 127.47,61.03 126.27,62.23 122.74,62.23 117.86,57.35 117.86,57.08 116.67,55.88 114.22,55.88 111.9,53.56 111.9,43.94 110.61,42.65 110.61,36.58 109.63,35.6 109.63,34.34 109.78,34.19 110.02,34.19 v2(110.26,34.43)
SNUB_1.2V:
  vias: v1(132.99,8.09)
SNUB_1V:
  vias: v1(111.75,38.74)
SNUB_3V: length 2.5
  TOP w0.109: PC109.1 v1(138.92,105.37)
  TOP w0.508: PR100.2 139.89,106.2 PC109.1
SNUB_5V: length 3.5
  TOP w0.109: PR112.2 48.18,13.55 48.67,14.04 v1(48.97,14.04)
  TOP w0.508: PR112.2 47.89,12.1 PC126.1
SNUB_5VR: length 2.8
  TOP w0.109: PC512.1 363.29,48.52 363.65,48.87 v1(364.03,48.87)
  TOP w0.508: PC512.1 362.84,47.81 362.75,47.89 PR502.2
SNUB_CHG:
  vias: v1(97.15,1.75)
SNUB_IO: length 1.2
  TOP w0.109: v1(301.37,63.03) 301.51,62.89 PC301.1
SPKR: length 339.7
  TOP w0.109: v2(126.55,33.91) 126.58,33.91 126.79,34.12 UH1.AW29 ; v2(391.23,29.1) 391.11,29.22 RA12.2
  IN2 w0.081: v2(348.43,13.46) 348.43,14.57 349.03,15.18 349.03,21.82 348.61,22.24 348.61,28.25 350.41,30.04 354.78,30.04 355.61,30.87 364.78,30.87 365.36,30.29 368.82,30.29 369.3,30.77 371.26,30.77 372.18,29.85 375.51,29.85 378.93,33.26 385.21,33.26 385.67,33.72 389.76,33.72 391.23,32.25 v2(391.23,29.1)
  IN3 w0.081: v2(348.43,13.46) 348.43,12.71 345.92,10.2 341.65,10.2 340.27,11.58 338.55,11.58 337.58,10.61 321.74,10.61 317.85,6.72 310.84,6.72 309.05,4.93 308.47,4.93 308.27,4.72 307.93,4.38 303.18,4.38 301.28,2.49 277.4,2.49 274.41,5.48 268.79,5.48 265.69,8.59 256.51,8.59 254.99,10.11 246.14,10.11 241.48,5.44 168.54,5.44 163.44,10.54 149.85,10.54 148.67,11.72 141.92,11.72 141.05,12.59 134.24,12.59 133.65,13.17 131.98,13.17 129.79,15.36 123.84,15.36 121.56,17.64 121.56,18.72 120.45,19.83 120.45,20.53 121.59,21.67 121.59,23.08 121.31,23.36 121.31,24.43 122.58,25.7 122.58,27.44 123.07,27.93 123.07,29.14 121.87,30.35 121.87,32.65 123.33,34.12 126.34,34.12 v2(126.55,33.91)
  BOTTOM w0.109: v2(391.23,29.1) 390.99,29.1 v1(390.74,28.84) ; RH86.2 120.47,33.71 122.36,33.71 122.82,34.16 126.13,34.16 126.39,33.91 v2(126.55,33.91)
SPKR_R: length 6.3
  TOP w0.109: RA12.1 389.67,29.22 390.26,28.64 v1(391.55,28.64)
  TOP w0.254: CA27.1 388.21,26.68 388.58,27.05 RA225.1 CA228.1 389.56,29.15 RA12.1
SRN_1: length 2.3
  TOP w0.109: PU700.19 70.48,20.77 70.56,20.68 70.56,20.53 71.01,20.08 71.28,20.08 71.35,20 71.35,19.8 PR728.2
SRP_1: length 2.3
  TOP w0.109: PR727.2 71.59,19.8 71.59,20.1 71.37,20.31 71.11,20.31 70.8,20.63 70.8,20.72 70.88,20.8 PU700.20
SRTCRST#: length 8.6
  TOP w0.102: v2(124.76,26.43) 124.59,26.26 124.23,26.26 UH1.BD46
  TOP w0.109: v2(122.19,24.1) 121.87,23.78 121.87,22.4 122.1,22.17 CH41.2 121.6,21.35 RH201.2
  BOTTOM w0.109: v2(122.19,24.1) 122.19,24.89 123.29,25.99 v1(123.54,25.99) 123.56,25.99 123.93,26.36 124.69,26.36 v2(124.76,26.43)
SSD_SCP#: length 350.4
  TOP w0.109: v2(361.83,25.29) 361.83,21.22 366.72,16.33 372.76,16.33 373.83,15.25 375.93,15.25 376.6,14.58 RN220.2 ; UE1.L6 v2(136.47,70.88) ; v2(332.37,55.96) 330.02,55.96 327.26,58.71 326.31,58.71 v2(325.64,59.39) ; v1(137.53,87.33) 137.22,87.02 RN476.2 136.51,86.73 135.46,85.68 v2(135.46,83.2)
  IN1 w0.102: v2(361.83,25.29) 358.35,25.29 356.39,27.25 331.05,27.25 330.72,27.57 330.72,29.16 v2(331.54,29.99) 332.31,29.99 332.75,30.43 332.75,43.96 331.04,45.67 331.04,47.77 330.21,48.59 330.21,54.15 330.32,54.42 331.86,55.96 v2(332.37,55.96)
  IN2 w0.081: v2(155.84,81.21) 145.31,81.21 144.9,81.63 137.26,81.63 137.11,81.77 137.11,82.89 136.68,83.33 135.59,83.33 v2(135.46,83.2) 135.24,82.98 134.84,82.98 132.14,80.28 131.01,80.28 130.34,79.61 130.34,73.27 131.51,72.09 134.19,72.09 134.21,72.12 135.73,72.12 136.02,71.83 136.02,71.32 v2(136.47,70.88)
  VCC w0.086: v2(275.14,82.89) 275,82.76 272.17,82.76 271.2,83.72 268.69,83.72 268.22,83.25 259.37,83.25 258.76,82.65 242.87,82.65 242.49,83.03 235.65,83.03 233.71,84.98 230.37,84.98 227.44,87.91 226.43,87.91 226.13,88.2 224.82,88.2 221.3,91.72 183.73,91.72 179.19,96.26 171.63,96.26 170.9,95.53 160.09,95.53 156.7,92.13 156.7,86.5 156.57,86.37 156.57,81.94 v2(155.84,81.21)
  IN3 w0.081: v2(325.64,59.39) 322.58,59.39 313.64,68.32 313.64,74.1 309.22,78.52 306.26,78.52 302.89,81.89 298.21,81.89 296.39,83.71 295.6,83.71 295.12,83.23 287.65,83.23 287.6,83.28 284.62,83.28 283.04,84.85 281.05,84.85 279.09,82.89 v2(275.14,82.89)
  BOTTOM w0.109: v2(331.54,29.99) RN219.2 ; RN475.2 v2(332.37,55.96)
SUNB_3VR: length 1.4
  TOP w0.109: v1(331.56,12.42) 331.1,11.97 PC527.1
SUSACK#: length 85
  TOP w0.109: RH443.2 116.52,29.67 113.86,29.67 v2(113.36,30.17)
  IN3 w0.081: v2(143.71,69.51) 143.4,69.2 143.4,68.21 142.89,67.7 142.41,67.7 140.68,65.97 140.68,65.69 140.37,65.39 139.3,65.39 138.47,64.56 135.96,64.56 135.37,63.97 134.28,63.97 133.57,63.26 130.43,63.26 130.1,62.94 130.1,62.18 129.9,61.97 128.24,61.97 126.44,63.77 123.11,63.77 116.66,57.32 116.25,57.32 115.77,57.8 115.17,57.8 111.83,54.46 111.83,54.41 111.27,53.85 111.27,44.2 109.98,42.91 109.98,36.84 108.99,35.85 108.99,33.8 108.56,33.37 108.56,31.89 106.24,29.57 104.71,29.57 104.31,29.97 v2(104.31,29.97)
  IN4 w0.102: v2(104.31,29.97) 104.96,29.97 105.79,30.8 108.56,30.8 108.86,30.49 110.76,30.49 111.67,29.58 112.77,29.58 v2(113.36,30.17)
  BOTTOM w0.109: RE745.1 143.71,69.98 v2(143.71,69.51)
SUSACK#_R: length 7.9
  TOP w0.076: 122.71,31.92 122.73,31.89 123.35,31.89 123.35,31.89 123.48,32.02 123.77,32.02 UH1.BE35
  TOP w0.102: 120.07,30.24 120.77,30.93 120.77,31.4 120.91,31.55 121.85,31.55 122.21,31.92 122.71,31.92
  TOP w0.109: RH443.1 117.82,29.82 119.49,29.82 RH327.1 120.07,30.24
SUSCLK: length 509.1
  TOP w0.109: v2(114.82,84.43) 117.08,84.43 v2(117.63,83.88) ; v2(124.04,27.24) 124.04,27.23 124.04,26.81 UH1.BE45
  IN1 w0.102: v2(117.63,83.88) 116.25,82.5 116.25,75.91 116.11,75.77 116.11,73.36 117.08,72.39 117.08,68.43 117.21,68.3 117.21,67.04 116.85,66.68 116.85,63.35 117.73,62.47 117.73,56.14 119.15,54.71 119.15,51.48 120.13,50.51 120.13,31.21 123.56,27.78 123.78,27.78 124.07,27.49 124.07,27.26 124.04,27.24 v2(124.04,27.24)
  IN2 w0.081: v2(122.37,108.98) 122.78,109.39 122.78,110.03 124.41,111.65 124.78,111.65 126.19,113.06 126.19,114.07 128.45,116.32 129.21,116.32 v2(130.8,117.92) 130.8,118.99 134.26,122.45 137.77,122.45 140.31,124.98 141.43,124.98 144.5,121.92 144.5,120.49 147.7,117.28 148.44,117.28 150.61,115.12 161.14,115.12 162.79,113.46 v2(162.79,112.86)
  IN3 w0.081: v2(124.04,27.24) 124.04,26.7 123.35,26.01 123.35,25.67 122.56,24.87 122.56,23.64 123.07,23.12 123.07,21.92 122.32,21.17 122.32,19.71 123.49,18.54 124.66,18.54 125.76,19.65 129.11,19.65 129.51,19.25 129.51,16.52 130.96,15.07 134.09,15.07 134.66,15.64 137.51,15.64 138.33,14.82 140.06,14.82 142.29,12.59 145.26,12.59 145.95,13.27 147.32,13.27 147.55,13.05 154.73,13.05 155.78,12 162.88,12 168.81,6.07 236,6.07 239.61,9.68 243.9,9.68 245.6,11.38 255.7,11.38 257.21,9.87 266.24,9.87 269.27,6.83 275.26,6.83 278.25,3.85 299.53,3.85 301.21,5.52 305.37,5.52 305.47,5.42 308.97,5.42 310.87,7.33 317.84,7.33 321.76,11.25 321.88,11.25 v2(322.76,12.12)
  IN4 w0.102: v2(322.76,12.12) 323.23,11.64 328.73,11.64 v2(330.76,13.67) 330.76,15.26 333.77,18.28 341.73,18.28 342.11,17.9 342.11,15.97 343.49,14.58 349.05,14.58 350.46,13.17 354.17,13.17 354.34,13.35 356.56,13.35 356.93,12.98 360.37,12.98 360.76,13.38 361.56,13.38 361.66,13.27 363.11,13.27 363.74,13.9 363.74,14.22 364.28,14.77 368.88,14.77 v2(369.67,13.98)
  BOTTOM w0.109: v2(122.37,108.98) 120.09,106.69 115.14,106.69 114.38,105.93 114.38,103.05 114.03,102.69 114.03,97.97 114.24,97.76 114.24,95.26 114.23,95.25 114.23,94.91 114.24,94.91 114.24,94.15 114.25,94.13 114.43,93.26 114.43,92.38 114.26,91.51 114.24,91.45 114.24,90.51 114.85,89.9 115.46,89.9 115.77,89.59 115.77,86.84 114.71,85.77 114.71,84.54 v2(114.82,84.43) ; RN99.2 330.76,15.58 v2(330.76,13.67) 331.49,12.93 331.49,11.93 v1(331.77,11.65) 332,11.42 336.7,11.42 343.18,17.9 343.18,37.81 340.18,40.81 RN207.2 ; JNGFF2.60 161.99,113.66 v2(162.79,112.86) ; RH83.1 123.57,27.77 124.04,27.3 124.04,27.24 v2(124.04,27.24) ; RN205.2 v2(369.67,13.98) ; v2(130.8,117.92) 129.58,119.14 123.64,119.14 123.01,118.51 123.01,116.98 122.58,116.55 RZ56.2 ; RN213.2 122.5,85.73 120.65,83.88 v2(117.63,83.88)
SUSCLK_R3: length 3.9
  BOTTOM w0.109: JNGFF3.60 327.83,15.29 328.56,16.02 RN99.1 329.4,16.74 v1(329.72,17.06)
SUSCLK_R4: length 5.1
  BOTTOM w0.109: RN205.1 369.67,12.11 v1(369.07,11.51) 368.58,11.01 368.58,9.34 JNGFF4.68
SUSCLK_R5: length 4.2
  BOTTOM w0.109: v1(329.31,41.75) 329.47,41.58 RN207.1 329.27,40.6 326.4,40.6 JNGFF5.60
SUSCLK_R6: length 2.8
  BOTTOM w0.109: JNGFF6.60 122.53,87.25 RN213.1
SW1_2PH: length 37.5
  TOP w0.109: v1(295.97,36.86) 295.97,37.26 v2(296.16,37.45)
  TOP w0.254: PR1145.2 297.18,37.1 PR1160.2 296.83,37.45 v2(296.16,37.45)
  TOP w0.381: PL1700.2 280.75,17.17 v2(280.72,17.13)
  IN2 w0.254: v2(280.72,17.13) 280.72,16.93 280.75,16.9 287.83,16.9 288.54,17.61 288.54,18.76 289.53,19.75 293.7,19.75 294.21,20.27 294.21,29.25 296.16,31.2 v2(296.16,37.45)
SW1_4PH: length 24.9
  TOP w0.254: v2(300.25,53.09) 300.21,53.04 300.21,52.92 300.68,52.45 PR1143.1 ; PL1202.2 280.81,57.33 v2(280.77,57.37)
  IN2 w0.254: v2(300.25,53.09) 297.95,55.39 295.37,55.39 295.15,55.62 290.98,55.62 289.84,56.76 281.38,56.76 v2(280.77,57.37)
  BOTTOM w0.109: v2(280.77,57.37) v1(281.34,57.37)
  BOTTOM w0.254: v2(300.25,53.09) 300.21,53.04 300.21,52.92 300.86,52.27 PR1154.1
SW1_CET: length 3.6
  TOP w0.109: UV64.47 152.82,122.49 152.3,123.01 v1(152.3,123.4) 152.3,124.21 152.56,124.47 152.56,124.6 CV818.2
SW1_EDP_AUXN: length 48.5
  TOP w0.109: UV64.31 159.22,122.22 159.28,122.28 159.28,122.59 160.04,123.35 160.04,126.67 v2(160.14,126.77) ; CV2.1 127.05,133.63 127.05,134.4 RV840.2 127,134.73 127,136.33 v2(127.07,136.41)
  IN2 w0.081: v2(127.07,136.41) 126.96,136.29 126.96,133.73 127.73,132.96 135.03,132.96 135.81,133.75 138,133.75 138.85,132.89 143.11,132.89 143.97,132.02 145.76,132.02 146.17,131.62 155.97,131.62 160.05,127.54 160.05,126.87 v2(160.14,126.77)
SW1_EDP_AUXN_C: length 14.6
  TOP w0.109: JEDP1.29 127.22,118.93 127.22,119.92 126.44,120.7 126.44,128.7 127.01,129.27 127.01,132.7 127.2,132.89 CV2.2
SW1_EDP_AUXP: length 48.5
  TOP w0.109: v2(126.36,136.41) 126.48,136.29 126.48,134.7 RV842.2 126.53,134.33 126.53,133.69 CV1.1 ; UV64.32 158.82,122.38 158.76,122.43 158.76,122.8 159.53,123.57 159.53,126.68 v2(159.43,126.77)
  IN2 w0.081: v2(126.36,136.41) 126.42,136.34 126.42,133.51 127.51,132.43 135.25,132.43 136.04,133.21 137.77,133.21 138.63,132.35 142.89,132.35 143.75,131.49 145.54,131.49 145.94,131.08 155.75,131.08 159.51,127.32 159.51,126.85 v2(159.43,126.77)
SW1_EDP_AUXP_C: length 14.6
  TOP w0.109: CV1.2 126.31,132.89 126.5,132.7 126.5,129.49 125.92,128.91 125.92,120.48 126.7,119.71 JEDP1.28
SW1_EDP_HPD: length 50.8
  TOP w0.109: RV7.2 124.69,132.69 v1(124.87,132.51) 125.2,132.18 v2(125.2,120.23) JEDP1.25 ; v2(153.87,123.33) 154.02,123.18 UV64.44
  IN2 w0.081: v2(153.87,123.33) 153.16,122.62 151.32,122.62 146.09,127.86 136.03,127.86 129.54,121.36 126.34,121.36 v2(125.2,120.23)
SW1_EDP_N0: length 31.8
  TOP w0.076: v2(153.46,123.84) 153.18,123.56 153.18,122.96 153.49,122.64 153.49,122.39 153.62,122.27 UV64.45
  TOP w0.109: v2(134.53,135.3) 134.83,135 134.83,134.43 134.63,134.22 134.63,133.66 CV847.1
  IN4 w0.102: v2(153.46,123.84) 153.38,123.92 153.38,124.43 152.27,125.54 147.98,125.54 145.06,128.46 141.33,128.46 139.01,130.77 139.01,134.1 136.66,136.45 135.24,136.45 134.53,135.74 v2(134.53,135.3)
SW1_EDP_N0_C: length 15.3
  TOP w0.109: CV847.2 134.63,132.7 134.63,126.99 133.41,125.78 133.41,122.31 131.69,120.59 131.69,119.79 131.7,119.79 JEDP1.38
SW1_EDP_N1: length 37.7
  TOP w0.076: v2(155.05,123.88) 154.69,123.51 154.69,122.4 154.82,122.27 UV64.42
  TOP w0.109: CV845.1 132.72,133.66 132.72,135.17 v2(132.47,135.42)
  IN4 w0.102: v2(155.05,123.88) 155.05,125.16 153.27,126.94 149.12,126.94 146.23,129.83 144.89,129.83 144.47,130.25 144.47,133.24 142.79,134.92 142.79,135.62 140.68,137.73 139,137.73 138.57,137.3 137.77,137.3 137.39,137.68 133.61,137.68 132.47,136.55 v2(132.47,135.42)
SW1_EDP_N1_C: length 15.6
  TOP w0.109: JEDP1.36 130.7,119.72 130.69,119.73 130.69,121.02 129.87,121.84 129.87,125.33 132.72,128.18 132.72,132.7 CV845.2
SW1_EDP_N2: length 41.5
  TOP w0.076: UV64.39 156.02,122.17 155.9,122.3 155.9,122.73 v2(156.18,123.01)
  TOP w0.109: CV5.1 130.82,133.66 130.82,134.95 v2(130.59,135.17)
  IN4 w0.102: v2(156.18,123.01) 156.18,123.36 156.31,123.5 156.31,125.62 152.45,129.48 148.39,129.48 145.93,131.93 145.93,133.87 145.16,134.65 145.16,135.6 143.91,136.84 143.53,136.84 141.42,138.95 132.78,138.95 130.59,136.76 v2(130.59,135.17)
SW1_EDP_N2_C: length 15.4
  TOP w0.109: CV5.2 130.82,132.7 130.82,128.6 128.69,126.47 128.69,121.52 129.69,120.52 129.69,119.79 129.7,119.79 JEDP1.34
SW1_EDP_N3: length 47.2
  TOP w0.076: v2(157.82,123.57) 157.54,123.29 157.54,123.05 157.09,122.61 157.09,122.39 157.22,122.27 UV64.36
  TOP w0.109: v2(128.7,135.15) 128.9,134.94 128.9,134.48 128.8,134.38 128.8,133.66 CV3.1
  IN4 w0.102: v2(128.7,135.15) 128.69,135.16 128.69,136.71 132.39,140.4 143.56,140.4 146.56,137.41 146.56,135.35 150.9,131 155.01,131 157.74,128.28 157.74,123.65 v2(157.82,123.57)
SW1_EDP_N3_C: length 15.1
  TOP w0.109: JEDP1.32 128.7,119.79 128.69,119.79 128.69,119.95 127.45,121.19 127.45,127.77 128.81,129.13 128.81,132.71 128.62,132.9 CV3.2
SW1_EDP_P0: length 31.7
  TOP w0.076: UV64.46 153.22,122.27 153.34,122.39 153.34,122.58 153.03,122.9 153.03,123.56 v2(152.74,123.84)
  TOP w0.109: v2(135.63,135.35) 135.35,135.07 135.35,134.22 135.14,134.01 135.14,133.66 CV848.1
  IN4 w0.102: v2(135.63,135.35) 135.83,135.15 135.83,134.88 135.71,134.76 135.23,134.76 135.09,134.9 135.09,135.51 135.47,135.89 136.43,135.89 138.45,133.87 138.45,130.54 141.1,127.9 144.83,127.9 147.75,124.98 152.04,124.98 152.82,124.2 152.82,123.92 v2(152.74,123.84)
SW1_EDP_P0_C: length 15.3
  TOP w0.109: CV848.2 135.14,132.7 135.14,126.78 133.93,125.56 133.93,122.1 132.21,120.38 132.21,119.79 132.2,119.79 JEDP1.39
SW1_EDP_P1: length 37.7
  TOP w0.076: v2(154.15,123.86) 154.53,123.47 154.53,122.38 154.42,122.27 UV64.43
  TOP w0.109: v2(133.49,135.42) 133.24,135.17 133.24,133.66 CV846.1
  IN4 w0.102: v2(154.15,123.86) 154.4,123.86 154.49,123.95 154.49,124.93 153.04,126.38 148.89,126.38 145.99,129.28 144.66,129.28 143.91,130.02 143.91,133.01 142.23,134.69 142.23,135.39 140.44,137.17 139.23,137.17 138.8,136.74 137.54,136.74 137.16,137.12 133.84,137.12 133.03,136.32 133.03,134.97 133.13,134.87 133.34,134.87 133.64,135.18 133.64,135.27 v2(133.49,135.42)
SW1_EDP_P1_C: length 15.6
  TOP w0.109: JEDP1.37 131.2,119.72 131.21,119.73 131.21,121.23 130.38,122.05 130.38,125.12 133.24,127.97 133.24,132.7 CV846.2
SW1_EDP_P2: length 41.5
  TOP w0.076: v2(155.46,123.01) 155.74,122.73 155.74,122.24 155.62,122.12 UV64.40
  TOP w0.109: v2(131.56,135.17) 131.33,134.95 131.33,133.66 CV6.1
  IN4 w0.102: v2(155.46,123.01) 155.62,123.17 155.62,123.59 155.76,123.73 155.76,125.38 152.22,128.92 148.16,128.92 145.37,131.7 145.37,133.64 144.6,134.42 144.6,135.37 143.68,136.29 143.3,136.29 141.19,138.39 133.01,138.39 131.15,136.53 131.15,134.62 131.24,134.53 131.58,134.53 131.72,134.67 131.72,135.01 v2(131.56,135.17)
SW1_EDP_P2_C: length 15.4
  TOP w0.109: CV6.2 131.33,132.7 131.33,128.38 129.21,126.26 129.21,121.73 130.21,120.73 130.21,119.79 130.2,119.79 JEDP1.35
SW1_EDP_P3: length 47.2
  TOP w0.076: UV64.37 156.82,122.27 156.94,122.39 156.94,122.67 157.39,123.12 157.39,123.28 v2(157.1,123.57)
  TOP w0.109: CV4.1 129.32,133.68 129.32,134.16 129.42,134.27 129.42,134.9 v2(129.67,135.15)
  IN4 w0.102: v2(157.1,123.57) 157.18,123.65 157.18,128.05 154.78,130.44 150.67,130.44 146,135.11 146,137.17 143.33,139.84 132.62,139.84 129.25,136.47 129.25,134.48 129.33,134.4 129.57,134.4 129.67,134.5 v2(129.67,135.15)
SW1_EDP_P3_C: length 15.1
  TOP w0.109: CV4.2 129.51,132.9 129.32,132.71 129.32,128.92 127.96,127.55 127.96,121.41 129.21,120.16 129.21,119.79 129.2,119.79 JEDP1.33
SW1_REXT: length 3.2
  TOP w0.109: RV835.2 158.73,123.65 v1(158.51,123.42) 158.14,123.06 158.14,122.42 158.02,122.3 UV64.34
SW2_4PH: length 27.3
  TOP w0.254: PR1146.1 299.54,52.85 v2(299.23,53.16)
  TOP w0.305: v2(280.97,47.11) 281.06,47.19 PL1203.2
  IN2 w0.254: 290.53,47.4 292.4,49.27 292.4,52.52 294.59,54.7 297.69,54.7 v2(299.23,53.16)
  IN2 w0.305: v2(280.97,47.11) 281.26,47.4 290.53,47.4
  BOTTOM w0.109: v2(280.97,47.11) v1(281.67,47.11)
  BOTTOM w0.254: PR1161.1 299.54,52.85 v2(299.23,53.16)
SW2_DP2_1_AUXN: length 300.3
  TOP w0.109: RV809.1 66.91,52.21 66.29,51.59 v2(66.29,51.02) ; UV8.27 305.02,80.54 305.48,81.01 307.18,81.01 v2(307.36,81.18)
  IN2 w0.081: v2(307.36,81.18) 307.45,81.09 308.37,81.09 308.86,80.61 308.86,79.09 308.32,78.55 307.35,77.58 302.98,77.58 300.03,74.64 295.9,74.64 295.25,73.99 295.25,73.2 294.3,72.25 292.26,72.25 291.6,72.91 280.34,72.91 279.94,73.31 271.71,73.31 268.52,76.5 267.71,76.5 265.46,78.75 257.83,78.75 255.01,75.93 239.3,75.93 238.45,76.78 236.28,76.78 235.13,77.93 230.96,77.93 229.29,79.6 226.39,79.6 221.47,84.52 216.58,84.52 212.91,88.19 197.43,88.19 196.67,88.95 184.88,88.95 184.2,89.62 177.99,89.62 176.4,91.2 173.76,91.2 171.07,88.52 165.84,88.52 164.51,87.19 156.72,87.19 154.7,89.2 128.08,89.2 126.69,87.82 125.41,87.82 119.27,81.67 118.46,81.67 116.72,79.94 116.72,78.82 115.98,78.08 114.86,78.08 110.21,73.43 108.09,73.43 105.59,70.93 105.59,69.4 103.96,67.77 103.96,66.97 95.47,58.48 95.09,58.48 90.24,53.63 90.24,45.95 87.6,43.32 83.71,43.32 82.62,42.22 72.6,42.22 72.09,42.73 70.24,42.73 69.36,43.61 69.36,46.86 66.31,49.9 66.31,51 v2(66.29,51.02)
SW2_DP2_1_AUXN_C: length 2.6
  TOP w0.109: UV67.59 70.58,51.69 70.52,51.75 v3(70.01,51.75) 69.73,51.75 69.45,52.03 69.04,52.03 RV809.2
SW2_DP2_1_AUXP: length 300.4
  TOP w0.109: UV8.26 304.18,80.14 304.3,80.03 305.23,80.03 305.7,80.49 307.26,80.49 307.36,80.39 v2(307.36,80.32) ; RV808.1 67.57,51.7 67.13,51.7 66.81,51.38 66.81,51.22 v2(67.01,51.02)
  IN2 w0.081: v2(67.01,51.02) 67.32,51.33 67.54,51.33 67.65,51.22 67.65,50.74 67.52,50.61 66.95,50.61 66.85,50.51 66.85,50.13 69.9,47.08 69.9,43.83 70.46,43.27 72.31,43.27 72.82,42.76 82.4,42.76 83.49,43.86 87.38,43.86 89.7,46.17 89.7,53.85 94.87,59.02 95.25,59.02 103.42,67.19 103.42,67.99 105.05,69.62 105.05,71.15 107.87,73.97 109.99,73.97 114.64,78.62 115.76,78.62 116.18,79.04 116.18,80.16 118.23,82.21 119.04,82.21 125.19,88.36 126.47,88.36 127.86,89.74 154.93,89.74 156.94,87.72 164.28,87.72 165.62,89.05 170.85,89.05 173.53,91.74 176.63,91.74 178.21,90.16 184.43,90.16 185.1,89.48 196.9,89.48 197.65,88.73 213.13,88.73 216.8,85.06 221.69,85.06 226.61,80.14 229.51,80.14 231.18,78.47 235.35,78.47 236.5,77.32 238.67,77.32 239.52,76.47 254.79,76.47 257.61,79.29 265.68,79.29 267.93,77.04 268.74,77.04 271.93,73.85 280.16,73.85 280.57,73.45 291.82,73.45 292.48,72.79 294.08,72.79 294.71,73.42 294.71,74.21 295.68,75.17 299.81,75.17 302.75,78.12 307.12,78.12 308.32,79.31 308.32,80.38 308.15,80.55 307.91,80.55 307.78,80.42 307.78,79.77 307.7,79.69 307.22,79.69 307.11,79.8 307.11,80.07 v2(307.36,80.32)
SW2_DP2_1_AUXP_C: length 2.6
  TOP w0.109: RV808.2 69.04,51.51 69.24,51.51 69.52,51.23 70.52,51.23 70.58,51.29 UV67.60
SW2_DP2_1_HPD: length 266.2
  TOP w0.109: v2(296.01,83.31) 296.17,83.15 UV8.48 ; RV903.1 79.5,43.98 v1(79.13,44.35) 79.13,44.86 79.19,44.92 79.19,46.12 79.07,46.24 v2(79.07,47.31) UV67.19
  IN1 w0.102: v2(79.07,47.31) 79.07,47.25 80.11,46.22 88.19,46.22 89.2,47.23 89.2,49.47 98.47,58.74 98.47,64.96 104.26,70.75 v2(106.25,70.75)
  IN2 w0.081: v2(106.25,70.75) 106.25,70.75 108.14,72.65 110.32,72.65 115.1,77.42 116.76,77.42 118.85,79.51 118.85,80.25 119.29,80.69 119.66,80.69 121.51,82.54 121.51,82.89 125.8,87.17 126.88,87.17 128.32,88.62 133.58,88.62 133.94,88.25 139.9,88.25 140.27,88.62 154.17,88.62 v2(155.78,87.01)
  VCC w0.086: v2(155.78,87.01) 155.75,87.04 155.75,94.24 157.47,95.96 170.72,95.96 171.52,96.75 179.39,96.75 183.91,92.24 221.48,92.24 225.02,88.69 226.34,88.69 226.63,88.4 227.65,88.4 230.57,85.47 233.93,85.47 235.69,83.71 242.66,83.71 243.22,83.16 254.21,83.16 255.27,84.21 271.47,84.21 272.38,83.3 272.95,83.3 v2(273.25,83.6)
  IN3 w0.081: v2(296.01,83.31) 295.62,82.92 293.92,82.92 292.65,81.65 287.65,81.65 286.94,82.36 284.35,82.36 282.32,84.39 281.4,84.39 279.12,82.11 274.14,82.11 273.25,83 v2(273.25,83.6)
SW2_DP2_1_N0: length 268.9
  TOP w0.076: UV8.49 295.77,82.86 295.6,83.02 295.6,83.3 295.17,83.73 294.57,83.73 294.24,84.07 294.24,85.25 v2(294.49,85.51)
  TOP w0.109: v2(77.45,44.54) 77.36,44.63 77.36,45.13 CV892.2
  IN2 w0.081: v2(77.45,44.54) 77.37,44.62 77.37,46.37 78.97,47.97 80.8,47.97 81.48,48.66 81.48,51.74 84.09,54.35 84.09,56.98 84.94,57.82 84.94,58.84 87.88,61.79 91.07,61.79 94.1,64.82 95.43,64.82 97.99,67.38 97.99,69.96 105.64,77.61 105.64,79.13 108.31,81.8 111.31,81.8 116.14,86.63 116.14,88.4 117.68,89.93 117.68,93.05 119.26,94.64 122.26,94.64 124.43,96.81 142.15,96.81 142.41,96.56 147.04,96.56 148.71,94.89 150.36,94.89 151.1,94.15 153.41,94.15 156.69,97.43 157.89,97.43 158.18,97.14 165.79,97.14 166.99,98.35 172.06,98.35 172.59,97.82 181.56,97.82 185.05,94.33 222.1,94.33 225.09,91.34 228.26,91.34 228.69,90.91 228.69,87.09 231.25,84.53 236.65,84.53 236.96,84.22 243.58,84.22 244.23,83.56 254.75,83.56 255.41,84.22 270.73,84.22 273.31,81.64 278.75,81.64 278.98,81.41 286.14,81.41 288.19,83.45 290.01,83.45 290.84,84.28 293.91,84.28 294.41,84.78 294.41,85.43 v2(294.49,85.51)
SW2_DP2_1_N0_C: length 2.6
  TOP w0.076: UV67.15 77.47,47.55 77.35,47.43 77.35,47.12 77.18,46.94 77.18,46.65 v3(77.18,46.65) 77.18,46.65 77.18,46.01 CV892.1
SW2_DP2_1_N1: length 267.2
  TOP w0.076: UV8.46 296.97,83.02 296.84,83.14 296.84,83.41 295.66,84.59 295.66,85.23 v2(295.93,85.5)
  TOP w0.109: v2(79.02,43.83) 78.74,44.11 78.74,45.11 CV894.2
  IN2 w0.081: v2(295.93,85.5) 295.87,85.44 295.87,84.08 294.76,82.97 293.3,82.97 290.79,80.46 287.44,80.46 287.16,80.17 281.51,80.17 280.35,79.01 275.9,79.01 275.13,79.77 271.19,79.77 267.91,83.05 258.46,83.05 257.72,82.31 253.41,82.31 253.38,82.34 243.43,82.34 242.75,83.02 236.5,83.02 236.29,83.23 235.53,83.23 235.05,82.74 231.12,82.74 230.78,83.09 228.73,83.09 225.19,86.63 225.19,87.51 219.55,93.14 184.26,93.14 180.82,96.58 171.8,96.58 171.3,97.08 167.38,97.08 166.32,96.01 157.4,96.01 154.06,92.67 144.27,92.67 141.38,95.57 140.2,95.57 139.95,95.31 124.55,95.31 121.72,92.49 121.72,91.57 117.4,87.24 117.4,86.24 115.95,84.78 115.95,84.1 112.08,80.23 108.41,80.23 106.81,78.63 106.81,77.11 101.95,72.25 101.95,70.74 99.49,68.27 99.49,67.28 94.6,62.4 93.33,62.4 88.27,57.34 86.74,57.34 85.46,56.06 85.46,52.31 82.93,49.79 82.93,48.17 81.56,46.8 80.06,46.8 78.94,45.68 78.94,43.91 v2(79.02,43.83)
SW2_DP2_1_N1_C: length 2.5
  TOP w0.076: CV894.1 78.57,46.01 v3(78.57,46.76) 78.57,47.25 78.55,47.27 78.55,47.43 78.67,47.55 UV67.18
SW2_DP2_1_N2: length 266.5
  TOP w0.076: UV8.44 297.77,83.02 297.64,83.14 297.64,83.71 296.96,84.39 296.96,84.58 v2(297.2,84.82)
  TOP w0.109: v2(80.39,44.64) 80.34,44.69 CV896.2
  IN2 w0.081: v2(297.2,84.82) 297.1,84.72 297.1,82.63 296.34,81.87 295.95,81.87 291.55,77.47 288.4,77.47 287.34,78.53 281.7,78.53 280.98,77.82 271.44,77.82 267.42,81.84 258.98,81.84 258.29,81.14 256.64,81.14 253.79,78.3 241.15,78.3 239.82,79.62 237.04,79.62 236.19,80.47 231.74,80.47 230.3,81.92 228.24,81.92 224.43,85.73 223.92,85.73 222.82,86.84 217.97,86.84 212.83,91.97 183.6,91.97 180.17,95.4 167.36,95.4 166.84,94.89 158.01,94.89 154.61,91.48 143.18,91.48 141.19,93.47 135.22,93.47 134.53,94.16 125.06,94.16 122.9,92 122.9,90.96 118.61,86.67 118.61,85.79 117.18,84.36 117.18,83.67 110.43,76.93 108.28,76.93 103.17,71.82 103.17,70.26 100.72,67.8 100.72,66.92 94.98,61.18 93.83,61.18 88.81,56.15 87.4,56.15 86.68,55.43 86.68,50.37 85.44,49.14 85.44,46.78 84.3,45.63 80.62,45.63 80.26,45.28 80.26,44.77 v2(80.39,44.64)
SW2_DP2_1_N2_C: length 2.7
  TOP w0.076: CV896.1 80.07,46.04 80.07,46.43 80.13,46.5 80.13,47.11 79.75,47.49 79.75,47.57 79.87,47.7 UV67.21
SW2_DP2_1_N3: length 271
  TOP w0.076: v2(299.16,84.47) 298.84,84.15 298.84,83.14 298.97,83.02 UV8.41
  TOP w0.109: v2(81.66,44.01) 81.53,44.13 81.53,45.11 CV898.2
  IN2 w0.081: v2(299.16,84.47) 299.06,84.37 299.06,82.98 299.42,82.62 299.42,78.1 298.68,77.35 294.55,77.35 291.78,74.58 289.59,74.58 288.72,75.46 286.77,75.46 285.43,74.13 281.7,74.13 279.62,76.21 271.31,76.21 268.32,79.2 266.66,79.2 265.17,80.69 260.13,80.69 259.36,79.92 257.3,79.92 254.5,77.12 239.85,77.12 238.65,78.32 236.53,78.32 235.73,79.12 231.47,79.12 229.82,80.77 226.9,80.77 221.98,85.69 217.37,85.69 212.23,90.82 196.09,90.82 195.38,90.11 185.62,90.11 184.92,90.81 183.02,90.81 180.77,93.05 171.09,93.05 167.79,89.76 165.19,89.76 165.01,89.57 160.25,89.57 158.99,88.31 157.55,88.31 155.53,90.33 126.29,90.33 124.95,88.99 122.59,88.99 120.29,86.69 120.29,84.49 118.72,82.92 118.06,82.92 110.57,75.44 108.41,75.44 104.4,71.42 104.4,69.86 102.82,68.28 102.82,67.42 95.43,60.03 94.99,60.03 89.07,54.11 89.07,46.38 87.18,44.49 81.74,44.49 81.56,44.31 81.56,44.1 v2(81.66,44.01)
SW2_DP2_1_N3_C: length 2.9
  TOP w0.076: UV67.23 80.67,47.7 80.55,47.57 80.55,47.39 v3(81.19,46.74) 81.35,46.58 81.35,46.03 CV898.1
SW2_DP2_1_P0: length 268.9
  TOP w0.076: v2(293.78,85.51) 294.08,85.2 294.08,84.01 294.51,83.58 295.11,83.58 295.45,83.24 295.45,82.97 295.37,82.89 UV8.50
  TOP w0.109: v2(76.73,44.54) 76.84,44.65 76.84,45.13 CV891.2
  IN2 w0.081: v2(76.73,44.54) 76.83,44.64 76.83,46.59 78.74,48.51 80.57,48.51 80.94,48.88 80.94,51.97 83.55,54.57 83.55,57.2 84.4,58.05 84.4,59.06 87.66,62.33 90.84,62.33 93.87,65.36 95.2,65.36 97.45,67.6 97.45,70.19 105.1,77.83 105.1,79.36 108.08,82.34 111.09,82.34 115.61,86.86 115.61,88.62 117.14,90.15 117.14,93.27 119.04,95.18 122.03,95.18 124.21,97.35 142.38,97.35 142.63,97.1 147.26,97.1 148.94,95.43 150.58,95.43 151.32,94.69 153.19,94.69 156.47,97.97 158.12,97.97 158.4,97.68 165.57,97.68 166.77,98.88 172.29,98.88 172.81,98.36 181.78,98.36 185.27,94.87 222.32,94.87 225.32,91.88 228.48,91.88 229.23,91.13 229.23,87.31 231.47,85.06 236.87,85.06 237.18,84.75 243.8,84.75 244.45,84.1 254.53,84.1 255.18,84.75 270.96,84.75 273.53,82.18 278.97,82.18 279.2,81.95 285.92,81.95 287.96,83.99 289.79,83.99 290.61,84.82 293.69,84.82 293.88,85 293.88,85.41 v2(293.78,85.51)
SW2_DP2_1_P0_C: length 2.6
  TOP w0.076: UV67.14 77.07,47.55 77.2,47.43 77.2,47.18 76.96,46.94 76.96,46.36 77.02,46.29 77.02,46.01 CV891.1
SW2_DP2_1_P1: length 267.2
  TOP w0.076: UV8.47 296.57,83.02 296.69,83.14 296.69,83.35 295.5,84.53 295.5,85.2 v2(295.21,85.5)
  TOP w0.109: CV893.2 78.18,43.96 v2(78.31,43.83)
  IN2 w0.081: v2(295.21,85.5) 295.33,85.38 295.33,84.3 294.54,83.51 293.08,83.51 290.57,81 287.22,81 286.94,80.71 281.29,80.71 280.12,79.55 276.12,79.55 275.36,80.31 271.41,80.31 268.13,83.59 258.24,83.59 257.5,82.85 253.63,82.85 253.6,82.88 243.66,82.88 242.98,83.56 236.72,83.56 236.52,83.76 235.31,83.76 234.83,83.28 231.35,83.28 231,83.63 228.95,83.63 225.72,86.85 225.72,87.73 219.78,93.68 184.48,93.68 181.04,97.12 172.02,97.12 171.52,97.61 167.15,97.61 166.09,96.55 157.18,96.55 153.84,93.21 144.49,93.21 141.6,96.11 139.98,96.11 139.73,95.85 124.32,95.85 121.19,92.72 121.19,91.79 116.86,87.47 116.86,86.46 115.41,85.01 115.41,84.32 111.85,80.77 108.18,80.77 106.27,78.86 106.27,77.33 101.41,72.47 101.41,70.96 98.95,68.5 98.95,67.51 94.38,62.94 93.11,62.94 88.05,57.88 86.52,57.88 84.92,56.28 84.92,52.54 82.39,50.01 82.39,48.4 81.33,47.34 79.84,47.34 78.4,45.91 78.4,43.93 v2(78.31,43.83)
SW2_DP2_1_P1_C: length 2.6
  TOP w0.076: UV67.17 78.27,47.55 78.4,47.43 78.4,47.09 78.36,47.05 78.36,46.47 78.42,46.41 78.42,46.01 CV893.1
SW2_DP2_1_P2: length 266.5
  TOP w0.076: UV8.45 297.37,83.02 297.49,83.14 297.49,83.64 296.8,84.33 296.8,84.5 v2(296.48,84.82)
  TOP w0.109: CV895.2 79.7,44.68 79.7,44.67 79.7,44.66 v2(79.67,44.64)
  IN2 w0.081: v2(296.48,84.82) 296.56,84.73 296.56,82.85 296.12,82.4 295.72,82.4 291.33,78.01 288.63,78.01 287.56,79.07 281.47,79.07 280.76,78.35 271.67,78.35 267.65,82.37 258.76,82.37 258.06,81.68 256.42,81.68 253.57,78.84 241.37,78.84 240.05,80.16 237.26,80.16 236.41,81.01 231.97,81.01 230.52,82.46 228.47,82.46 224.65,86.27 224.14,86.27 223.04,87.37 218.19,87.37 213.05,92.51 183.82,92.51 180.39,95.94 167.14,95.94 166.62,95.42 157.79,95.42 154.38,92.02 143.4,92.02 141.41,94.01 135.44,94.01 134.76,94.69 124.84,94.69 122.36,92.22 122.36,91.19 118.07,86.89 118.07,86.01 116.64,84.58 116.64,83.89 110.21,77.46 108.06,77.46 102.63,72.04 102.63,70.48 100.18,68.03 100.18,67.14 94.76,61.72 93.61,61.72 88.58,56.69 87.18,56.69 86.14,55.65 86.14,50.59 84.9,49.36 84.9,47 84.07,46.17 80.39,46.17 79.72,45.5 79.72,44.69 v2(79.67,44.64)
SW2_DP2_1_P2_C: length 2.6
  TOP w0.076: UV67.20 79.47,47.69 79.6,47.57 79.6,47.43 79.92,47.11 v3(79.92,46.79) 79.92,45.99 CV895.1
SW2_DP2_1_P3: length 271
  TOP w0.076: UV8.42 298.57,83.02 298.69,83.14 298.69,84.22 v2(298.44,84.47)
  TOP w0.109: v2(80.94,44.01) 81.02,44.08 81.02,45.14 CV897.2
  IN2 w0.081: v2(298.44,84.47) 298.52,84.39 298.52,82.76 298.89,82.39 298.89,78.32 298.46,77.89 294.33,77.89 291.56,75.12 289.81,75.12 288.94,76 286.54,76 285.21,74.67 281.92,74.67 279.84,76.75 271.54,76.75 268.55,79.74 266.89,79.74 265.4,81.23 259.91,81.23 259.14,80.46 257.07,80.46 254.28,77.66 240.07,77.66 238.87,78.86 236.75,78.86 235.95,79.66 231.69,79.66 230.04,81.31 227.12,81.31 222.2,86.23 217.6,86.23 212.46,91.36 195.87,91.36 195.16,90.65 185.84,90.65 185.14,91.35 183.24,91.35 181,93.59 170.87,93.59 167.57,90.29 164.97,90.29 164.78,90.11 160.03,90.11 158.77,88.85 157.77,88.85 155.75,90.87 126.07,90.87 124.72,89.52 122.37,89.52 119.75,86.91 119.75,84.72 118.5,83.46 117.83,83.46 110.34,75.97 108.19,75.97 103.86,71.64 103.86,70.08 102.28,68.5 102.28,67.64 95.2,60.57 94.76,60.57 88.53,54.33 88.53,46.6 86.95,45.02 81.52,45.02 81.02,44.53 81.02,44.09 v2(80.94,44.01)
SW2_DP2_1_P3_C: length 2.8
  TOP w0.076: UV67.22 80.27,47.67 80.4,47.54 80.4,47.32 80.83,46.89 80.83,46.8 81.2,46.43 81.2,46 CV897.1
SW2_DP2_2_AUXN: length 53.3
  TOP w0.109: JDGFF4.F5 276.25,89.92 276.11,89.78 275.68,89.78 v2(275.36,90.1) ; UV8.29 304.22,81.34 304.29,81.27 304.48,81.27 304.68,81.48 304.68,82.37 305.13,82.82 305.38,82.82 305.55,82.99 v2(305.55,83.24)
  IN2 w0.089: v2(305.55,83.24) 305.21,82.9 305.21,82.77 305.3,82.69 305.87,82.69 306.4,83.22 306.4,86.07 305.42,87.05 305.42,87.96 298.55,94.83 274.95,94.83 273.44,93.32 273.44,91.87 273.63,91.68 273.63,90.06 274.09,89.6 275.43,89.6 275.52,89.7 275.52,89.93 v2(275.36,90.1)
SW2_DP2_2_AUXP: length 53.2
  TOP w0.109: v2(305.54,82.2) 305.54,82.4 305.38,82.56 305.24,82.56 304.95,82.27 304.95,81.37 304.59,81.01 304.24,81.01 304.17,80.94 UV8.28 ; v2(275.41,89.12) 275.81,89.52 276.03,89.52 276.23,89.32 JDGFF4.F4
  IN2 w0.089: v2(305.54,82.2) 305.83,82.49 305.96,82.49 306.6,83.13 306.6,86.15 305.62,87.13 305.62,88.05 298.63,95.04 274.87,95.04 273.24,93.41 273.24,91.79 273.43,91.6 273.43,89.97 274,89.4 275.13,89.4 v2(275.41,89.12)
SW2_DP2_2_HPD: length 29.3
  TOP w0.109: v2(300.59,84.69) 300.45,84.56 300.45,83.99 300.23,83.77 300.23,82.87 300.17,82.8 UV8.38 ; JDGFF4.C2 280.95,88.12 281.25,87.82 281.25,86.58 281.71,86.12 284.27,86.12 284.48,85.92 286.07,85.92 v1(289.3,89.15) 289.75,89.6 v2(290.75,89.6)
  IN3 w0.081: v2(290.75,89.6) 292.5,87.85 300.33,87.85 300.78,87.39 300.78,86.83 300.59,86.63 v2(300.59,84.69)
SW2_DP2_2_N0: length 30.9
  TOP w0.109: UV8.39 299.77,83.07 299.7,83.13 299.7,83.51 299.93,83.74 299.93,87.01 v2(300.15,87.24) ; v2(291.44,93.29) 291.33,93.4 291.11,93.4 290.96,93.25 290.96,92.69 290.62,92.34 289,92.34 287.22,94.12 282.9,94.12 282.51,93.73 282.51,92.26 282.62,92.15 282.92,92.15 JDGFF4.B9
  IN2 w0.089: v2(291.44,93.29) 291.09,92.93 291.09,91.1 294.16,88.03 299.64,88.03 299.9,87.77 299.9,87.5 v2(300.15,87.24)
SW2_DP2_2_N1: length 30.1
  TOP w0.109: v2(281.79,89.5) 281.58,89.3 281.51,89.3 280.88,89.92 JDGFF4.C5 ; v2(302.24,86.26) 302.24,86.23 301.85,85.84 301.85,84.62 300.9,83.67 300.9,83.13 300.97,83.07 UV8.36
  IN2 w0.089: v2(281.79,89.5) 282.03,89.25 282.99,89.25 283.49,89.75 283.49,90.39 284.59,91.49 288.15,91.49 292.45,87.19 298.09,87.19 298.69,86.6 300.44,86.6 300.74,86.9 301.61,86.9 v2(302.24,86.26)
SW2_DP2_2_N2: length 37.5
  TOP w0.109: v2(303.86,87.02) 303.53,86.7 303.53,86.05 302.85,85.37 302.85,84.62 301.7,83.46 301.7,83.13 301.77,83.07 UV8.34 ; v2(281.63,92.22) 281.14,91.72 JDGFF4.C8
  IN2 w0.089: v2(303.86,87.02) 303.58,86.74 303.58,86.39 302.4,85.22 300.52,85.22 300.18,85.55 297.82,85.55 297.21,86.16 291.06,86.16 290.69,86.53 289.15,86.53 288.43,85.8 286.11,85.8 285.79,85.49 284.33,85.49 283.46,86.35 282.17,86.35 280.76,87.76 280.76,88.68 280.87,88.8 280.87,91.67 281.14,91.94 281.35,91.94 v2(281.63,92.22)
SW2_DP2_2_N3: length 48.4
  TOP w0.109: JDGFF4.F8 276.3,91.53 276.03,91.53 275.56,92 275.29,92 v2(275.07,92.22) ; UV8.31 302.97,83.07 302.9,83.13 302.9,83.33 303.28,83.71 303.71,83.71 303.85,83.85 304.4,84.4 304.4,84.72 v2(304.73,85.05)
  IN2 w0.089: v2(275.07,92.22) 274.82,91.97 274.52,91.97 274.27,92.22 274.27,92.98 275,93.72 276.15,93.72 277.52,92.34 279.6,92.34 281.29,94.03 298.08,94.03 304.53,87.58 304.53,86.76 305.25,86.03 305.25,84.6 305.08,84.42 304.48,84.42 304.25,84.65 304.25,85.71 304.37,85.83 304.62,85.83 304.73,85.72 v2(304.73,85.05)
SW2_DP2_2_P0: length 30.9
  TOP w0.109: v2(299.44,87.24) 299.67,87.01 299.67,83.85 299.43,83.62 299.43,83.13 299.37,83.07 UV8.40 ; JDGFF4.B8 282.93,91.88 282.51,91.88 282.25,92.15 282.25,93.84 282.79,94.38 287.33,94.38 289.11,92.61 290.51,92.61 290.7,92.8 290.7,93.06 v2(290.47,93.28)
  IN2 w0.089: v2(299.44,87.24) 299.69,87.49 299.69,87.68 299.55,87.82 294.08,87.82 290.88,91.02 290.88,92.87 v2(290.47,93.28)
SW2_DP2_2_P1: length 30.1
  TOP w0.109: UV8.37 300.57,83.07 300.63,83.13 300.63,83.78 301.59,84.73 301.59,85.93 v2(301.27,86.25) ; v2(281.79,88.79) 281.79,88.89 281.64,89.03 281.4,89.03 281.11,89.32 JDGFF4.C4
  IN2 w0.089: v2(281.79,88.79) 282.05,89.05 283.07,89.05 283.69,89.67 283.69,90.3 284.68,91.29 288.06,91.29 292.37,86.99 298.01,86.99 298.6,86.39 300.52,86.39 300.82,86.69 301.53,86.69 301.76,86.46 301.76,86.29 301.6,86.14 301.38,86.14 v2(301.27,86.25)
SW2_DP2_2_P2: length 37.6
  TOP w0.109: UV8.35 301.37,83.07 301.43,83.13 301.43,83.57 302.59,84.73 302.59,85.48 303.27,86.16 303.27,86.7 v2(302.95,87.02) ; v2(281.63,91.45) 281.29,91.45 280.96,91.12 JDGFF4.C7
  IN2 w0.089: v2(302.95,87.02) 302.95,87.34 303.06,87.44 303.28,87.44 303.37,87.35 303.37,86.47 302.32,85.42 300.6,85.42 300.27,85.75 297.9,85.75 297.29,86.36 291.15,86.36 290.78,86.73 289.07,86.73 288.34,86.01 286.02,86.01 285.71,85.69 284.41,85.69 283.55,86.55 282.25,86.55 280.96,87.84 280.96,88.6 281.07,88.71 281.07,91.59 281.22,91.73 281.53,91.73 281.63,91.63 v2(281.63,91.45)
SW2_DP2_2_P3: length 48.3
  TOP w0.109: v2(275.07,91.5) 275.31,91.74 275.45,91.74 275.93,91.26 276.35,91.26 JDGFF4.F7 ; UV8.32 302.57,83.07 302.63,83.13 302.63,83.44 303.17,83.97 303.6,83.97 304.14,84.51 304.14,84.68 v2(303.77,85.05)
  IN2 w0.089: v2(275.07,91.5) 274.81,91.76 274.43,91.76 274.06,92.13 274.06,93.06 274.92,93.92 276.23,93.92 277.6,92.55 279.52,92.55 281.21,94.24 298.16,94.24 304.73,87.67 304.73,86.84 305.46,86.12 305.46,84.51 305.16,84.22 304.4,84.22 304.05,84.56 304.05,84.77 v2(303.77,85.05)
SW3_4PH: length 33.4
  TOP w0.254: PR1148.1 298.3,52.45 v2(298.3,53.13) ; v2(280.87,37.61) 281,37.61 281.01,37.61 PL1204.2
  IN2 w0.254: v2(298.3,53.13) 298.3,53.48 297.66,54.12 295.48,54.12 293.06,51.7 293.06,49.34 292.02,48.3 292.02,40.17 289.46,37.61 v2(280.87,37.61)
  BOTTOM w0.254: v2(298.3,53.13) PR1163.1
SW3_DP1_AUXN: length 25.2
  TOP w0.102: RV855.1 50.05,56.3 50.05,56.62 v2(50.34,56.91)
  IN2 w0.081: v2(50.34,56.91) 50.34,55.86 49.8,55.32 48.59,55.32 47.83,56.09 42.81,56.09 42.11,56.78 40.87,56.78 39.89,55.8 39.89,55.43 39.36,54.89 37.34,54.89 36.9,55.32 v2(36.9,56.15)
  BOTTOM w0.076: 53.4,56.04 53.41,56.02 53.67,56.02 54.12,55.57 54.12,55.3 54,55.18 UV66.57
  BOTTOM w0.109: v2(36.9,56.15) CT19.2 ; 53.4,56.04 51.78,57.66 50.57,57.66 50.34,57.43 v2(50.34,56.91)
SW3_DP1_AUXN_C: length 3.2
  BOTTOM w0.076: UT1.N2 37.77,52.22 arc(37.68,52.34) 37.66,52.49 37.66,52.8 37.58,52.88 37.58,53.04
  BOTTOM w0.102: 37.58,53.04 37.58,53.27 37.19,53.65 37.19,54.52 arc(37.16,54.67) 37.08,54.79 CT19.1
SW3_DP1_AUXP: length 25.2
  TOP w0.102: RV890.1 49.87,56.34 49.87,56.66 v2(49.63,56.91)
  IN2 w0.081: v2(49.63,56.91) 49.43,56.71 49.43,56.58 49.53,56.48 49.66,56.48 49.8,56.34 49.8,56.08 49.58,55.86 48.82,55.86 48.05,56.62 43.03,56.62 42.33,57.32 40.65,57.32 39.35,56.03 39.35,55.65 39.13,55.43 37.56,55.43 37.44,55.55 37.44,56.05 v2(37.54,56.15)
  BOTTOM w0.076: UV66.58 54.4,55.17 54.27,55.29 54.27,55.63 53.76,56.14 53.76,56.4
  BOTTOM w0.109: v2(37.54,56.15) CT18.2 ; 53.76,56.4 51.99,58.17 50.35,58.17 49.82,57.64 49.82,57.11 v2(49.63,56.91)
SW3_DP1_AUXP_C: length 3.2
  BOTTOM w0.076: UT1.N1 37.81,52.64 37.81,52.86 37.75,52.92 37.75,53.06 37.77,53.07
  BOTTOM w0.102: CT18.1 37.76,54.97 37.85,54.88 37.85,54.65 37.74,54.53 37.47,54.53 37.38,54.44 v3(37.38,54.09) 37.38,53.73 37.77,53.35 37.77,53.07
SW3_DP1_HPD: length 14.1
  TOP w0.109: v1(51.37,50.28) 51.56,50.47 v2(51.56,51.02)
  IN3 w0.102: v2(43.67,53.08) 46.33,53.08 47.33,52.07 49.9,52.07 50.01,51.96 50.62,51.96 v2(51.56,51.02)
  BOTTOM w0.076: 41.77,52.76 41.77,52.33 UT1.AA2
  BOTTOM w0.109: v2(51.56,51.02) 51.86,51.32 UV66.49 ; 41.77,52.76 42.09,53.08 v2(43.67,53.08)
SW3_DP1_N0: length 9.8
  BOTTOM w0.076: 51.23,52.86 51.25,52.86 51.43,53.04 52.56,53.04 52.68,52.92 UV66.53
  BOTTOM w0.109: CT11.2 44.82,50.08 46.87,50.08 v3(47.45,50.65) 47.89,51.09 49.66,52.86 51.23,52.86
SW3_DP1_N0_C: length 2.6
  BOTTOM w0.076: UT1.AB7 42.11,49.71 arc(42.24,49.63) 42.39,49.6 42.65,49.6 42.87,49.81 43.33,49.81 43.79,50.27 43.94,50.27 CT11.1
SW3_DP1_N1: length 9.8
  BOTTOM w0.076: 50.93,51.66 50.94,51.66 51.13,51.84 52.56,51.84 52.68,51.72 UV66.50
  BOTTOM w0.109: CT13.2 44.88,48.72 47.13,48.72 v3(49.18,50.77) 50.08,51.66 50.93,51.66
SW3_DP1_N1_C: length 2.5
  BOTTOM w0.076: UT1.AC9 42.33,48.89 42.26,48.82 42.26,48.73 42.31,48.67 42.65,48.67 42.82,48.83 44.06,48.83 CT13.1
SW3_DP1_N2: length 9.9
  BOTTOM w0.076: 50.93,50.39 50.94,50.39 51.13,50.57 51.25,50.57 51.34,50.48 52,50.48 52.16,50.64 52.56,50.64 52.68,50.52 UV66.47
  BOTTOM w0.109: 50.93,50.39 50.44,50.39 48.97,48.92 47.48,47.44 v3(46.54,47.44) 44.86,47.44 CT15.2
SW3_DP1_N2_C: length 2.6
  BOTTOM w0.076: CT15.1 43.97,47.62 43.7,47.62 43.39,47.92 42.85,47.92 42.66,47.74 42.25,47.74 UT1.AB11
SW3_DP1_N3: length 9.9
  BOTTOM w0.076: 51.62,49.26 51.64,49.26 51.82,49.44 52.56,49.44 52.68,49.32 UV66.44
  BOTTOM w0.109: 51.62,49.26 50.94,49.26 47.8,46.12 v3(45.77,46.12) 44.86,46.12 CT17.2
SW3_DP1_N3_C: length 2.7
  BOTTOM w0.076: UT1.AC13 42.33,47.05 42.26,46.99 42.26,46.88 42.32,46.83 42.74,46.83 42.87,46.96 42.99,46.96 43.64,46.3 43.97,46.3 CT17.1
SW3_DP1_P0: length 9.8
  BOTTOM w0.076: 51.23,53.37 51.25,53.37 51.43,53.19 52.56,53.19 52.68,53.32 UV66.54
  BOTTOM w0.109: 51.23,53.37 49.44,53.37 46.66,50.59 v3(45.84,50.59) 44.84,50.59 CT10.2
SW3_DP1_P0_C: length 2.6
  BOTTOM w0.076: CT10.1 43.94,50.42 43.72,50.42 43.27,49.96 42.8,49.96 42.71,50.06 42.32,50.06 42.26,49.99 42.26,49.89 42.33,49.81 UT1.AC7
SW3_DP1_P1: length 9.8
  BOTTOM w0.076: 50.93,52.17 50.94,52.17 51.13,51.99 52.56,51.99 52.68,52.12 UV66.51
  BOTTOM w0.109: 50.93,52.17 49.86,52.17 48.82,51.13 46.92,49.23 v3(46.24,49.23) 44.88,49.23 CT12.2
SW3_DP1_P1_C: length 2.5
  BOTTOM w0.076: CT12.1 43.92,48.98 42.82,48.98 42.7,49.11 42.36,49.11 arc(42.24,49.09) 42.14,49.02 UT1.AB9
SW3_DP1_P2: length 9.9
  BOTTOM w0.076: 50.93,50.91 50.94,50.91 51.13,50.73 51.31,50.73 51.41,50.63 51.94,50.63 52.1,50.79 52.56,50.79 52.68,50.92 UV66.48
  BOTTOM w0.109: 50.93,50.91 50.23,50.91 v3(48.6,49.29) 47.27,47.95 44.86,47.95 CT14.2
SW3_DP1_P2_C: length 2.6
  BOTTOM w0.076: CT14.1 43.97,47.77 43.76,47.77 43.46,48.07 42.83,48.07 42.7,48.2 42.32,48.2 42.26,48.14 42.26,48.03 42.32,47.97 UT1.AC11
SW3_DP1_P3: length 9.9
  BOTTOM w0.076: UV66.45 52.68,49.72 52.56,49.59 51.82,49.59 51.64,49.77 51.62,49.77
  BOTTOM w0.109: CT16.2 44.86,46.63 47.59,46.63 v3(48.45,47.5) 48.67,47.71 50.73,49.77 51.62,49.77
SW3_DP1_P3_C: length 2.7
  BOTTOM w0.076: UT1.AB13 42.24,47.28 42.74,47.28 42.91,47.11 43.05,47.11 43.71,46.45 43.97,46.45 CT16.1
SW4_4PH: length 41.7
  TOP w0.254: PR1149.1 296.95,53.18 v2(296.92,53.2)
  TOP w0.381: PL1205.2 280.78,26.92 v2(280.74,26.89)
  IN2 w0.254: v2(280.74,26.89) 281.05,26.58 287.96,26.58 288.9,27.52 288.9,31.41 289.51,32.02 290.27,32.02 291.67,33.42 291.67,36.29 292.73,37.35 292.81,37.35 293.04,37.58 293.04,48.25 293.65,48.86 293.65,51.3 295.55,53.2 v2(296.92,53.2)
  BOTTOM w0.254: PR1164.1 296.95,53.18 v2(296.92,53.2)
SW4_DP2_AUXN: length 41.3
  TOP w0.076: RV869.1 68.86,54.02 68.78,53.94 67.17,53.94 66.99,54.12 66.98,54.12
  TOP w0.109: 66.98,54.12 66.31,54.12 66.06,53.87 63.78,53.87 63.28,53.37 63.28,52.84 v2(63.16,52.73) ; UV67.57 70.9,52.49 70.77,52.61 70.77,53.07 69.86,53.98 69.37,53.98 RV869.1
  IN3 w0.081: v2(38.17,56.15) 38.28,56.26 38.28,57.05 38.44,57.21 38.58,57.35 39.06,57.35 39.25,57.55 41.22,57.55 41.35,57.42 42.24,57.42 42.81,56.84 44.48,56.84 46.35,58.71 49.71,58.71 50.42,58 51.69,58 52.67,57.02 55.69,57.02 58.16,54.55 59.69,54.55 61.95,52.29 62.92,52.29 63.16,52.52 v2(63.16,52.73)
  BOTTOM w0.109: v2(38.17,56.15) CT184.2
SW4_DP2_AUXN_C: length 3.2
  BOTTOM w0.076: UT1.P2 38.1,52.35 38.1,52.84 38.22,52.96 38.22,54.42 38.42,54.61 38.42,54.73 CT184.1
SW4_DP2_AUXP: length 41.3
  TOP w0.076: 66.98,53.61 67,53.61 67.18,53.79 68.78,53.79 68.86,53.71 RV889.1
  TOP w0.109: RV889.1 69.1,53.47 69.64,53.47 70.26,52.85 70.26,52.4 70.57,52.09 UV67.58 ; v2(63.87,52.73) 63.79,52.81 63.79,53.16 63.99,53.36 66.27,53.36 66.52,53.61 66.98,53.61
  IN3 w0.081: v2(38.89,56.15) 38.89,56.32 38.8,56.41 38.58,56.41 38.44,56.55 38.44,56.99 38.55,57.1 38.64,57.19 39.09,57.19 39.27,57.01 41,57.01 41.13,56.88 42.01,56.88 42.59,56.3 44.7,56.3 46.57,58.17 49.48,58.17 50.19,57.46 51.46,57.46 52.44,56.48 55.47,56.48 57.94,54.01 59.47,54.01 61.75,51.73 63.13,51.73 63.87,52.47 v2(63.87,52.73)
  BOTTOM w0.109: CT178.2 38.81,56.07 v2(38.89,56.15)
SW4_DP2_AUXP_C: length 3.2
  BOTTOM w0.076: UT1.P1 38.33,52.45 38.39,52.39 38.5,52.39 38.55,52.44 38.55,52.85 38.38,53.02 38.38,54.36 38.57,54.55 38.57,54.73 CT178.1
SW4_DP2_HPD: length 38.2
  TOP w0.109: v2(74.6,54.32) 74.67,54.24 UV67.49 ; v1(40.99,51.81) v2(40.99,51.09)
  IN4 w0.102: v2(40.99,51.09) 41.75,51.86 44.5,51.86 44.79,51.57 53.27,51.57 53.76,52.06 60.22,52.06 61.29,53.13 65.83,53.13 66.7,52.26 71.4,52.26 71.91,52.77 73.05,52.77 v2(74.6,54.32)
  BOTTOM w0.109: v2(40.99,51.09) UT1.Y4
SW4_DP2_N0: length 60.4
  TOP w0.076: 72.91,55.46 72.83,55.38 72.83,53.92 72.9,53.85 73,53.85 73.07,53.77 UV67.53
  TOP w0.109: 72.91,55.46 72.91,58.02 v2(73.01,58.12)
  IN1 w0.102: v2(28.51,53.98) 28.51,54.14 28.44,54.21 28.28,54.21 28.09,54.02 28.09,53.78 27.93,53.61 27.75,53.61 27.09,54.27 27.09,56.15 30.53,59.59 36.64,59.59 37.46,58.77 40.27,58.77 40.52,58.51 41.91,58.51 42.72,57.7 44.37,57.7 44.56,57.51 45.54,57.51 45.92,57.89 49.56,57.89 50.06,57.39 51.99,57.39 52.65,56.73 59.54,56.73 60.12,57.32 64.84,57.32 65.29,57.77 67.17,57.77 67.38,57.56 70.29,57.56 70.65,57.2 72.32,57.2 73.01,57.89 v2(73.01,58.12)
  BOTTOM w0.109: CT187.2 29.31,53.81 28.67,53.81 v2(28.51,53.98)
SW4_DP2_N0_C: length 5
  BOTTOM w0.076: 31.08,52.81 31.08,52.79 30.94,52.56 30.94,52.21 32.19,50.97 32.46,50.97 32.66,50.88 UT1.B5
  BOTTOM w0.109: 31.08,52.81 31.08,53.54 v3(30.9,53.72) 30.63,53.99 30.08,53.99 CT187.1
SW4_DP2_N1: length 60
  TOP w0.076: 74.05,55.3 73.93,55.18 73.93,54.98 74.03,54.88 74.03,53.89 74.09,53.82 74.22,53.82 74.27,53.77 UV67.50
  TOP w0.109: v2(74.29,58.74) 74.05,58.5 74.05,55.3
  IN1 w0.102: v2(28.3,54.82) 28.37,54.9 29.72,54.9 30.65,55.82 30.65,57.5 31.18,58.03 34.92,58.03 36.05,56.9 36.83,56.9 37.31,57.38 39.39,57.38 39.85,56.92 41.84,56.92 42.57,56.19 47.46,56.19 47.81,55.84 50.51,55.84 51.22,55.13 52.27,55.13 52.7,55.56 60.07,55.56 60.6,56.1 66.11,56.1 66.34,55.87 69.42,55.87 69.58,56.03 72.82,56.03 74.19,57.4 74.19,58.64 v2(74.29,58.74)
  BOTTOM w0.109: CT180.2 29.84,54.92 28.4,54.92 v2(28.3,54.82)
SW4_DP2_N1_C: length 5.4
  BOTTOM w0.076: 31.24,54.28 31.24,54.26 31.42,54.08 31.42,53.86 31.7,53.58 31.7,52.16 32.07,51.8 32.07,51.71 31.93,51.58 31.93,51.47 31.99,51.41 32.51,51.41 32.56,51.47 32.56,51.59 32.5,51.65 UT1.A3
  BOTTOM w0.109: 31.24,54.28 31.24,54.52 30.86,54.9 30.74,54.9 CT180.1
SW4_DP2_N2: length 55.1
  TOP w0.076: 75.59,55.13 75.59,55.11 75.47,54.99 UV67.47
  TOP w0.109: v2(75.92,58.13) 75.69,57.91 75.69,55.23 75.59,55.13
  IN1 w0.102: v2(33.25,55.58) 33.09,55.73 33.09,56 33.54,56.45 34.84,56.45 36.34,54.96 38.22,54.96 39.32,53.86 41.95,53.86 42.89,54.8 43.86,54.8 44.81,53.85 47.97,53.85 48.41,54.3 50.02,54.3 51.36,52.95 52.66,52.95 53.95,54.24 57.6,54.24 58.06,53.79 66.8,53.79 67.21,54.19 72.5,54.19 73.18,54.88 73.83,54.88 75.69,56.74 75.69,57.9 v2(75.92,58.13)
  BOTTOM w0.109: v2(33.25,55.58) 33.21,55.54 33.21,55.03 CT179.2
