# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PRX_DTX_P14: length 117.9
  TOP w0.102: v2(143.93,25.81) 143.99,25.87 UH1.C47
  BOTTOM w0.102: JNGFF6.31 131.78,96.62 131.87,96.54 131.96,96.54 132.03,96.61 132.13,96.61 132.24,96.5 132.24,96.4 131.82,95.98 130.15,95.98 129.24,95.06 124.76,95.06 118.1,88.41 118.1,85.68 116.88,84.46 116.88,83.09 117.59,82.39 117.59,82.33 118,81.92 118.06,81.92 123.06,76.92 123.06,75.59 123.66,74.99 123.66,69.03 123.9,68.79 123.9,67.37 125.98,65.29 126.39,65.29 127.06,64.62 127.06,64.21 127.5,63.77 133.77,63.77 135.43,62.11 136.87,62.11 139.09,59.9 140.98,59.9 142.69,58.18 144.83,58.18 146.77,56.24 150.72,56.24 151.9,55.05 151.9,52.53 152.6,51.83 152.6,50.05 153.63,49.02 153.63,44.75 153.11,44.23 153.11,28.42 152.86,28.17 152.07,27.38 146.09,27.38 144.09,25.39 143.58,25.39 143.32,25.65 143.32,26.09 143.51,26.28 143.99,26.28 144.09,26.17 144.09,25.97 v2(143.93,25.81)
PCIE_PRX_DTX_P15: length 118.9
  TOP w0.102: v2(142.87,27.14) 143.42,27.14 UH1.E45
  BOTTOM w0.102: v2(142.87,27.14) 143,27.02 143.18,27.02 143.28,27.11 143.28,27.28 143.04,27.52 142.66,27.52 142.47,27.33 142.47,25.54 143.06,24.95 144.33,24.95 145.09,25.71 146.12,25.71 147.13,26.71 152.76,26.71 153.87,27.83 153.87,44.07 154.42,44.62 154.42,49.36 153.43,50.35 153.43,52.26 152.54,53.15 152.54,55.44 151.14,56.83 147.02,56.83 144.78,59.07 143.14,59.07 141.11,61.1 139.25,61.1 137.6,62.75 135.64,62.75 134.02,64.37 129.24,64.37 128.01,65.6 127.9,65.6 127.4,65.6 127.11,65.89 126.22,65.89 124.53,67.58 124.53,69 124.26,69.27 124.26,75.24 123.66,75.84 123.66,78.98 122.76,79.88 122.76,81.37 122.1,82.03 v3(122.1,82.64) 122.1,84.26 123.28,85.44 123.28,88.26 123.9,88.88 123.9,91.15 127.16,94.41 129.55,94.41 130.25,95.12 134.04,95.12 135.19,96.27 135.19,96.54 135.1,96.62 135.01,96.62 134.97,96.58 134.86,96.58 134.78,96.65 JNGFF6.19
PCIE_PRX_DTX_P16: length 127
  TOP w0.102: UH1.M40 139.98,29.4 v2(140.23,29.15)
  BOTTOM w0.102: JNGFF6.7 137.78,96.77 137.65,96.63 137.65,96.48 137.72,96.4 137.86,96.4 138.01,96.55 138.11,96.55 138.17,96.49 138.17,96.22 137.65,95.7 135.54,95.7 134.16,94.31 130.49,94.31 129.99,93.82 127.41,93.82 124.51,90.92 124.51,88.24 123.98,87.7 123.98,85.14 123.24,84.4 123.24,83.89 123.2,83.85 123.2,83.26 123.24,83.23 123.24,82.61 124.19,81.66 124.19,80.14 124.26,80.08 124.26,76.09 124.94,75.41 124.94,70.75 125.59,70.09 125.59,68.26 127.65,66.2 128.28,66.2 129.45,65.03 135.37,65.03 136.38,64.02 137.29,64.02 138.82,62.5 141.11,62.5 142.63,60.97 143.72,60.97 146.01,58.69 148.39,58.69 149.65,57.43 151.45,57.43 153.11,55.77 154.4,55.77 155.92,54.25 155.92,44.55 154.63,43.26 154.63,27.19 153.53,26.09 147.99,26.09 146.35,24.45 145.17,24.45 145.03,24.31 142.66,24.31 141.82,25.16 141.82,29.3 141.32,29.8 140.72,29.8 140.41,29.49 140.41,29.33 v2(140.23,29.15)
PCIE_PRX_DTX_P17: length 266.5
  TOP w0.102: UH1.K44 140.71,27.44 v2(140.49,27.66)
  IN1 w0.102: v2(366.58,23.45) 366.39,23.26 366.39,23.05 366.13,22.79 359.72,22.79 356.06,26.45 324.46,26.45 314.83,16.82 314.4,16.82 309.75,12.17 301.4,12.17 298.41,9.19 256.98,9.19 256.13,10.03 246.37,10.03 241.77,5.43 169.32,5.43 149.33,25.41 145.52,25.41 144.71,24.6 143.33,24.6 140.96,26.97 140.96,27.8 140.86,27.91 140.74,27.91 v2(140.49,27.66)
  BOTTOM w0.102: v2(366.58,23.45) 366.37,23.23 366.37,19.5 369.77,16.09 370.64,16.09 371.67,15.06 372.31,15.06 374.1,13.28 374.1,11.1 374.25,10.95 JNGFF4.41
PCIE_PRX_DTX_P18: length 271.9
  TOP w0.094: v2(138.35,29.58) 138.48,29.46 138.77,29.46 UH1.R40
  IN1 w0.102: v2(138.35,29.58) 137.95,29.18 137.95,26.51 139.39,25.07 139.39,22.82 140.72,21.49 146.49,21.49 148.49,19.5 148.49,19.29 149.14,18.64 153.55,18.64 168.54,3.65 242.62,3.65 247.22,8.25 255.4,8.25 256.24,7.4 299.61,7.4 302.6,10.39 312.34,10.39 326.62,24.67 355.12,24.67 358.85,20.93 367.83,20.93 367.99,20.77 367.99,20.59 v2(367.75,20.35)
  BOTTOM w0.102: v2(367.75,20.35) 367.99,20.1 367.99,19.46 369.86,17.59 370.56,17.59 372.06,16.09 372.7,16.09 374.76,14.04 375.88,14.04 376.9,13.01 376.9,11.1 376.75,10.95 JNGFF4.31
PCIE_PRX_DTX_P19: length 271.6
  TOP w0.102: UH1.N42 139.62,28.16 v2(138.98,28.16)
  IN1 w0.102: v2(369.68,20.99) 369.94,21.25 369.94,21.44 369.78,21.6 359.12,21.6 355.46,25.26 326.35,25.26 312.07,10.98 302.07,10.98 299.09,8 256.48,8 255.64,8.84 246.95,8.84 242.35,4.24 168.79,4.24 153.13,19.9 149,19.9 147.12,21.79 147.12,22.31 146.02,23.41 142.47,23.41 140.33,25.56 139.91,25.56 138.6,26.87 138.6,27.65 138.98,28.03 v2(138.98,28.16)
  BOTTOM w0.102: JNGFF4.19 379.75,10.95 379.9,11.1 379.9,13.07 377.14,15.84 374.93,15.84 373.28,17.49 372.67,17.49 369.94,20.22 369.94,20.73 v2(369.68,20.99)
PCIE_PRX_DTX_P20: length 279.3
  TOP w0.102: v2(139.1,30.76) 138.85,30.76 UH1.R37
  IN1 w0.102: v2(371.29,23.53) 371.43,23.53 371.82,23.15 371.82,22.9 371.3,22.38 359.5,22.38 355.84,26.04 325.25,26.04 310.97,11.77 301.58,11.77 298.59,8.78 256.81,8.78 255.97,9.62 246.6,9.62 242,5.02 169.15,5.02 150.07,24.1 143.11,24.1 139.8,27.41 139.8,29.15 138.6,30.35 138.6,31.05 138.69,31.14 139.04,31.14 139.13,31.05 139.13,30.96 v2(139.1,30.76)
  BOTTOM w0.102: v2(371.29,23.53) 371.43,23.53 371.78,23.19 371.78,20.68 375.43,17.03 377.63,17.03 380.55,14.11 381.48,14.11 382.9,12.69 382.9,11.1 382.75,10.95 JNGFF4.7
PCIE_PRX_DTX_P21: length 241.5
  TOP w0.102: UH1.R44 138.1,27.76 137.73,27.76 v2(137.54,27.57)
  IN1 w0.102: v2(137.54,27.57) 137.54,27.77 137.39,27.92 137.04,27.92 136.92,27.8 136.92,26.94 138.95,24.92 138.95,22.83 140.24,21.53 140.24,20.97 141.03,20.18 141.98,20.18 142.9,21.1 146.03,21.1 149.27,17.86 149.6,17.86 151.85,15.61 151.85,13.53 159.82,5.56 166.02,5.56 168.34,3.24 242.84,3.24 247.43,7.84 255.23,7.84 256.99,6.08 287.54,6.08 288.46,7 300.14,7 303.12,9.98 313.11,9.98 320.13,16.99 321.26,16.99 321.7,17.44 321.7,17.69 321.4,18 321.28,18 v2(321.16,17.87)
  BOTTOM w0.102: v2(321.16,17.87) 321.27,17.99 321.27,18.25 320.96,18.56 320.96,31.62 321.8,32.45 321.8,35.17 321.31,35.66 321.31,42.31 320.53,43.08 320.53,46.95 320.32,47.16 319.97,47.16 319.91,47.11 319.91,46.92 319.85,46.85 JNGFF5.43
PCIE_PRX_DTX_P22: length 248.7
  TOP w0.102: UH1.U41 137.77,28.88 137.77,29.1 137.65,29.21 137.16,29.21 v2(137,29.06)
  IN1 w0.102: v2(322.4,17.39) 322.57,17.39 322.73,17.22 322.73,16.97 322.06,16.3 320.29,16.3 313.38,9.39 305.28,9.39 300.26,4.37 257.86,4.37 254.98,7.25 247.77,7.25 243.17,2.65 168.08,2.65 166.25,4.48 159.99,4.48 151.1,13.36 151.1,15.07 149.92,16.26 149.11,16.26 147.41,17.96 146.37,17.96 144.84,19.5 140.67,19.5 139.66,20.51 139.66,21.4 138.39,22.67 138.39,24.66 136.38,26.67 136.38,29.17 136.55,29.34 136.93,29.34 137,29.27 v2(137,29.06)
  BOTTOM w0.102: v2(322.4,17.39) 322.57,17.39 322.69,17.52 322.69,18.19 321.99,18.89 321.99,31.66 322.4,32.07 322.4,35.45 321.92,35.93 321.92,42.54 321.13,43.33 321.13,49.58 320.55,50.16 320,50.16 319.93,50.1 319.93,49.94 319.85,49.85 JNGFF5.31
PCIE_PRX_DTX_P23: length 253.4
  TOP w0.102: UH1.W44 136.8,27.48 136.5,27.78 135.88,27.78 v2(135.71,27.61)
  IN1 w0.102: v2(135.71,27.61) 135.71,27.8 135.58,27.94 135.19,27.94 134.96,27.71 134.96,26.45 135.22,26.19 136.04,26.19 137.74,24.48 137.74,22.59 139.01,21.33 139.01,20.21 140.99,18.23 143.09,18.23 145.12,16.2 147.45,16.2 149.19,14.46 149.19,13.92 159.86,3.25 166.6,3.25 167.8,2.05 243.45,2.05 248.05,6.65 254.73,6.65 257.61,3.78 301.16,3.78 305.77,8.38 313.34,8.38 320.49,15.53 322.37,15.53 323.71,16.87 323.71,18.11 323.49,18.33 323.49,18.71 323.34,18.86 v2(323.16,18.86)
  BOTTOM w0.102: JNGFF5.19 319.88,52.85 319.93,52.91 319.93,53.11 319.99,53.16 320.81,53.16 321.73,52.25 321.73,43.8 322.57,42.97 322.57,36.25 323.01,35.8 323.01,19.81 323.48,19.34 323.48,18.99 323.35,18.86 v2(323.16,18.86)
PCIE_PRX_DTX_P24: length 262.5
  TOP w0.102: UH1.Y41 136.41,29.03 136.22,29.22 135.73,29.22 v2(135.58,29.08)
  IN1 w0.102: v2(324.81,17.92) 325.03,17.92 325.11,17.84 325.11,17.06 322.86,14.81 320.9,14.81 313.88,7.79 306.02,7.79 301.41,3.18 257.36,3.18 254.49,6.06 248.33,6.06 243.73,1.46 167.34,1.46 166.37,2.43 158.05,2.43 143.9,16.58 141.12,16.58 138.88,18.82 138.88,19.46 137.42,20.92 137.42,21.41 136.62,22.21 136.62,24.72 135.73,25.61 134.95,25.61 134.22,26.34 134.22,27.94 134.86,28.57 134.86,29.28 135.03,29.46 135.52,29.46 135.58,29.39 v2(135.58,29.08)
  BOTTOM w0.102: v2(324.81,17.92) 325.04,17.92 325.12,18 325.12,18.4 324.65,18.87 324.65,21.08 323.62,22.11 323.62,34.73 325.24,36.36 325.24,38.7 323.17,40.77 323.17,43.2 322.32,44.05 322.32,54.43 320.59,56.16 319.98,56.16 319.93,56.12 319.93,55.92 319.87,55.85 JNGFF5.7
PCIE_PRX_TTX_N1: length 120.7
  TOP w0.102: UH1.G17 v2(142.97,40.43)
  IN4 w0.102: v2(142.97,40.43) 142.82,40.58 142.76,40.58 142.37,40.19 142.37,38.96 142.03,38.62 142.03,37.84 140.69,36.49 140.69,34.8 140.79,34.7 140.79,33.89 140.33,33.43 139.22,33.43 138.81,33.02 137.57,33.02 136.63,32.09 133.14,32.09 131.94,33.29 130.87,33.29 130.58,33.59 127.74,33.59 125.2,36.12 124.84,36.12 122.76,38.2 119.2,38.2 118.55,37.56 117.03,37.56 116.02,38.56 114.75,38.56 113.79,39.52 111.68,39.52 110.3,40.91 103.91,40.91 100.91,43.91 98.79,43.91 97.28,45.42 84.27,45.42 83.22,46.47 74.56,46.47 73.83,47.2 70.83,47.2 70.7,47.07 68.84,47.07 66.72,44.95 62.19,44.95 61.15,43.91 59.7,43.91 59.33,43.54 55.88,43.54 53.06,40.72 49.43,40.72 49.16,40.45 47.83,40.45 46.05,38.68 43.9,38.68 43.57,38.34 43.57,37.16 43.68,37.05 v2(44.05,37.05)
  BOTTOM w0.102: CT7.1 43.63,38.67 43.63,37.47 v2(44.05,37.05)
PCIE_PRX_TTX_N2: length 119.7
  TOP w0.102: v2(139.22,38.16) UH1.R21
  IN4 w0.102: v2(41.49,36.98) 41.15,36.98 41.03,37.1 41.03,38.29 41.49,38.75 43.11,38.75 46.74,42.37 48.26,42.37 49.19,41.44 52.83,41.44 55.59,44.2 58.85,44.2 59.22,44.57 60.93,44.57 62.04,45.67 66.59,45.67 68.71,47.79 83.3,47.79 84.08,48.58 85.34,48.58 86.7,49.94 92.58,49.94 95.16,52.52 102.05,52.52 103.3,53.76 104.78,53.76 107.56,50.98 109.48,50.98 111.15,49.32 111.15,44.88 113.73,42.3 114.55,42.3 114.99,41.85 119.88,41.85 120.58,41.15 122.58,41.15 123.01,40.72 124.92,40.72 125.34,40.29 126.41,40.29 126.87,39.83 133.94,39.83 134.01,39.77 135.09,39.77 135.29,39.97 136.16,39.97 137.02,39.11 138.31,39.11 138.63,38.78 139.07,38.78 139.22,38.63 v2(139.22,38.16)
  BOTTOM w0.102: v2(41.49,36.98) 41.1,37.37 41.1,38.68 CT9.1
PCIE_PRX_TTX_N3: length 125.2
  TOP w0.102: UH1.K18 v2(140.53,40.57)
  IN4 w0.102: v2(140.53,40.57) 140.65,40.69 140.77,40.69 140.91,40.55 140.91,40.21 140.74,40.05 138.07,40.05 137.9,39.88 137.34,39.88 135.85,41.37 133.42,41.37 133.18,41.12 127.47,41.12 126.91,41.68 126.07,41.68 125.64,42.12 125.09,42.12 124.71,41.73 123.85,41.73 122.71,42.87 120.32,42.87 119.7,43.5 117.27,43.5 116.93,43.16 114.08,43.16 111.93,45.31 111.93,49.64 109.22,52.35 107.3,52.35 105.11,54.54 102.95,54.54 102.31,53.9 94.84,53.9 92.14,51.2 86.46,51.2 85.19,49.93 84,49.93 82.76,48.69 68.49,48.69 66.93,47.12 65.64,47.12 64.26,48.5 61.77,48.5 60.95,47.68 60.95,46.85 59.96,45.86 59.13,45.86 58.4,45.14 55.23,45.14 53.29,43.19 46.39,43.19 42.77,39.57 39.15,39.57 38.26,38.68 38.26,37.62 v2(37.96,37.33)
  BOTTOM w0.102: v2(37.96,37.33) 38.37,37.73 38.37,38.63 CT128.1
PCIE_PRX_TTX_N4: length 128.5
  TOP w0.094: UH1.N18 139.37,40.49 v2(139.32,40.54)
  IN4 w0.102: v2(35.48,37.53) 35.48,38.39 36.64,39.54 37.97,39.54 38.63,40.21 42.54,40.21 46.8,44.46 52,44.46 53.81,46.27 55.94,46.27 56.48,46.8 56.48,47.13 56.85,47.51 57.67,47.51 58.69,46.49 59.65,46.49 60.11,46.96 60.11,47.9 61.44,49.22 64.22,49.22 64.51,49.52 68.29,49.52 69.05,50.28 82.84,50.28 83.74,51.18 85.39,51.18 86.25,52.04 91.66,52.04 94.28,54.66 102.18,54.66 102.66,55.14 105.35,55.14 107.48,53.01 109.44,53.01 112.52,49.92 112.52,45.63 113.88,44.27 115.05,44.27 115.69,44.92 119.34,44.92 120.67,43.59 121.43,43.59 124.08,43.59 124.99,42.68 125.41,42.68 126.07,43.35 126.64,43.35 128.65,45.35 131.62,45.35 133.16,43.81 134.37,43.81 135.24,42.94 135.74,42.94 136.15,43.36 137.2,43.36 137.56,42.99 137.56,41.01 137.74,40.84 138.05,40.84 138.31,41.1 138.95,41.1 139.15,40.9 139.15,40.71 v2(139.32,40.54)
  BOTTOM w0.102: CT130.1 35.75,38.7 35.75,37.8 v2(35.48,37.53)
PCIE_PRX_TTX_P1: length 120.7
  TOP w0.102: UH1.F16 142.93,40.88 142.74,40.88 142.57,41.05 v2(142.57,41.16)
  IN4 w0.102: v2(142.57,41.16) 142.57,40.65 142.19,40.27 142.19,39.04 141.85,38.7 141.85,37.91 140.5,36.57 140.5,34.72 140.6,34.62 140.6,33.96 140.26,33.62 139.14,33.62 138.73,33.21 137.49,33.21 136.55,32.27 133.22,32.27 132.02,33.48 130.95,33.48 130.65,33.77 127.82,33.77 125.28,36.31 124.91,36.31 122.84,38.39 119.12,38.39 118.48,37.75 117.1,37.75 116.1,38.75 114.83,38.75 113.87,39.71 111.76,39.71 110.38,41.1 103.99,41.1 100.99,44.09 98.87,44.09 97.36,45.61 84.35,45.61 83.3,46.66 74.64,46.66 73.91,47.39 70.75,47.39 70.62,47.26 68.76,47.26 66.64,45.14 62.12,45.14 61.07,44.09 59.62,44.09 59.26,43.73 55.8,43.73 52.98,40.91 49.35,40.91 49.08,40.64 47.75,40.64 45.97,38.86 43.82,38.86 43.38,38.42 43.38,37.37 v2(43.07,37.06)
  BOTTOM w0.102: v2(43.07,37.06) 43.44,37.43 43.44,38.64 CT6.1
PCIE_PRX_TTX_P2: length 119.7
  TOP w0.102: UH1.P21 139.18,38.84 139.18,39.12 139.44,39.38 v2(139.58,39.38)
  IN4 w0.102: v2(40.5,37) 40.84,37.34 40.84,38.37 40.97,38.5 41.41,38.94 43.04,38.94 46.66,42.56 48.33,42.56 49.26,41.63 52.75,41.63 55.51,44.39 58.77,44.39 59.14,44.75 60.85,44.75 61.96,45.86 66.51,45.86 68.63,47.98 83.22,47.98 84.01,48.77 85.26,48.77 86.62,50.13 92.5,50.13 95.08,52.7 101.98,52.7 103.22,53.95 104.86,53.95 107.64,51.17 109.56,51.17 111.34,49.39 111.34,44.96 113.81,42.49 114.62,42.49 115.07,42.04 119.96,42.04 120.66,41.34 122.65,41.34 123.09,40.91 124.99,40.91 125.42,40.48 126.49,40.48 126.95,40.02 134.02,40.02 134.09,39.95 135.01,39.95 135.21,40.16 136.23,40.16 137.1,39.29 138.38,39.29 138.71,38.97 139.16,38.97 v2(139.58,39.38)
  BOTTOM w0.102: CT8.1 40.9,38.63 40.9,37.4 v2(40.5,37)
PCIE_PRX_TTX_P3: length 125.2
  TOP w0.102: UH1.J18 141.35,40.23 141.27,40.31 v2(141.27,40.6)
  IN4 w0.102: v2(141.27,40.6) 141.1,40.43 141.1,40.14 140.82,39.86 138.15,39.86 137.98,39.69 137.26,39.69 135.77,41.18 133.5,41.18 133.26,40.93 127.39,40.93 126.83,41.49 126,41.49 125.56,41.93 125.17,41.93 124.79,41.54 123.77,41.54 122.63,42.69 120.24,42.69 119.62,43.31 117.35,43.31 117,42.97 114,42.97 111.74,45.23 111.74,49.56 109.14,52.16 107.22,52.16 105.03,54.36 103.03,54.36 102.38,53.71 94.92,53.71 92.21,51.01 86.53,51.01 85.26,49.74 84.07,49.74 82.84,48.5 68.57,48.5 67,46.94 65.56,46.94 64.18,48.32 61.85,48.32 61.14,47.6 61.14,46.78 60.03,45.67 59.21,45.67 58.48,44.95 55.31,44.95 53.36,43.01 46.47,43.01 42.85,39.38 39.23,39.38 38.44,38.6 38.44,37.36 38.54,37.26 v2(38.89,37.26)
  BOTTOM w0.102: CT127.1 38.56,38.68 38.56,37.59 v2(38.89,37.26)
PCIE_PRX_TTX_P4: length 128.4
  TOP w0.094: v2(138.6,40.54) UH1.R18
  IN4 w0.102: v2(36.19,37.56) 36.19,37.85 36.09,37.95 35.77,37.95 35.67,38.05 35.67,38.31 36.72,39.36 38.05,39.36 38.71,40.02 42.62,40.02 46.88,44.28 52.08,44.28 53.89,46.08 56.02,46.08 56.67,46.73 56.67,47.06 56.93,47.32 57.59,47.32 58.61,46.31 59.73,46.31 60.3,46.88 60.3,47.82 61.52,49.04 64.3,49.04 64.59,49.33 68.36,49.33 69.13,50.09 82.92,50.09 83.82,50.99 85.47,50.99 86.33,51.86 91.74,51.86 94.36,54.47 102.26,54.47 102.74,54.95 105.28,54.95 107.4,52.82 109.36,52.82 112.34,49.85 112.34,45.55 113.8,44.09 115.13,44.09 115.77,44.73 119.26,44.73 120.59,43.41 120.67,43.41 121.05,43.41 124.01,43.41 124.91,42.5 125.49,42.5 126.15,43.16 126.72,43.16 128.73,45.17 131.54,45.17 133.08,43.63 134.29,43.63 135.16,42.75 135.81,42.75 136.23,43.17 137.12,43.17 137.38,42.91 137.38,40.93 137.66,40.65 138.13,40.65 138.39,40.91 138.87,40.91 138.96,40.82 138.96,40.64 138.86,40.54 v2(138.6,40.54)
  BOTTOM w0.102: CT129.1 35.94,38.61 35.94,37.8 v2(36.19,37.56)
PCIE_PTX_C_DRX_N5: length 2.9
  TOP w0.102: CL6.2 153.34,134.72 153.34,135.43 v3(153.08,135.69) 152.87,135.9 152.87,136.21 152.98,136.32 UL1.42
PCIE_PTX_C_DRX_N6: length 5.8
  BOTTOM w0.102: CR205.2 25.03,18.56 24.22,18.56 24.17,18.61 23.71,18.61 23.08,17.98 23.02,17.98 22.88,17.83 22.62,17.83 v3(22.2,17.41) 21.94,17.15 21.53,16.74 21.07,16.74 20.96,16.63 UR1.5
PCIE_PTX_C_DRX_N7: length 3
  BOTTOM w0.102: JNGFF1.29 119.75,103.89 119.61,103.75 119.61,102.34 CZ13.2
PCIE_PTX_C_DRX_N8: length 3.9
  BOTTOM w0.102: JNGFF2.39 156.74,106.09 156.89,105.94 156.89,105.83 156.76,105.7 v3(156.76,104.85) 156.76,103.73 CZ10.2
PCIE_PTX_C_DRX_N9: length 3.3
  BOTTOM w0.102: JNGFF3.11 318.5,29.54 318.35,29.39 317.51,29.39 317.5,29.4 316.7,29.4 CN65.2
PCIE_PTX_C_DRX_N10: length 3.3
  BOTTOM w0.102: CN67.2 316.65,26.39 318.35,26.39 318.5,26.54 JNGFF3.23
PCIE_PTX_C_DRX_N11: length 3.3
  BOTTOM w0.102: JNGFF3.35 318.5,23.54 318.35,23.39 316.73,23.39 CN69.2
PCIE_PTX_C_DRX_N12: length 3.3
  BOTTOM w0.102: JNGFF3.47 318.5,20.54 318.35,20.39 317.46,20.39 317.33,20.26 316.69,20.26 CN71.2
PCIE_PTX_C_DRX_N13: length 3.6
  BOTTOM w0.102: JNGFF6.47 127.78,98.21 127.63,98.37 127.63,98.51 127.9,98.78 128.62,98.78 128.92,99.08 128.92,99.86 CN214.2
PCIE_PTX_C_DRX_N14: length 3.1
  BOTTOM w0.102: CN212.2 131.14,99.89 131.14,99.07 130.63,98.56 130.63,98.31 130.78,98.16 JNGFF6.35
PCIE_PTX_C_DRX_N15: length 2.9
  BOTTOM w0.102: CN210.2 133.63,99.88 133.63,98.6 133.78,98.45 JNGFF6.23
PCIE_PTX_C_DRX_N16: length 2.9
  BOTTOM w0.102: CN208.2 136.63,99.86 136.63,98.34 136.78,98.18 JNGFF6.11
PCIE_PTX_C_DRX_N17: length 2.4
  BOTTOM w0.102: JNGFF4.47 372.75,10.95 372.6,11.1 372.6,11.89 CN186.2
PCIE_PTX_C_DRX_N18: length 2.4
  BOTTOM w0.102: CN184.2 375.6,11.85 375.6,11.1 375.75,10.95 JNGFF4.35
PCIE_PTX_C_DRX_N19: length 2.4
  BOTTOM w0.102: JNGFF4.23 378.75,10.95 378.6,11.1 378.6,11.92 CN182.2
PCIE_PTX_C_DRX_N20: length 2.4
  BOTTOM w0.102: JNGFF4.11 381.75,10.95 381.6,11.1 381.6,11.88 CN180.2
PCIE_PTX_C_DRX_N21: length 2.8
  BOTTOM w0.102: JNGFF5.47 317.93,45.85 317.78,45.7 316.58,45.7 CN200.2
PCIE_PTX_C_DRX_N22: length 2.8
  BOTTOM w0.102: JNGFF5.35 317.93,48.85 317.78,48.7 316.58,48.7 CN198.2
PCIE_PTX_C_DRX_N23: length 2.8
  BOTTOM w0.102: JNGFF5.23 317.93,51.85 317.78,51.7 316.58,51.7 CN196.2
PCIE_PTX_C_DRX_N24: length 2.8
  BOTTOM w0.102: CN194.2 316.58,54.7 317.78,54.7 317.93,54.85 JNGFF5.11
PCIE_PTX_C_DRX_P5: length 2.9
  TOP w0.102: CL5.2 153.15,134.72 153.15,135.3 152.68,135.76 152.68,136.25 152.58,136.36 UL1.41
PCIE_PTX_C_DRX_P6: length 5.8
  BOTTOM w0.102: CR203.2 25.03,18.75 24.29,18.75 24.25,18.8 23.58,18.8 v3(23.12,18.34) 22.8,18.02 22.55,18.02 22.3,17.78 22.25,17.78 21.83,17.36 21.83,17.31 21.46,16.93 21.05,16.93 20.96,17.03 UR1.4
PCIE_PTX_C_DRX_P7: length 3
  BOTTOM w0.102: CZ12.2 119.42,102.38 119.42,103.75 119.26,103.91 JNGFF1.27
PCIE_PTX_C_DRX_P8: length 3.9
  BOTTOM w0.102: JNGFF2.41 157.24,106.09 157.09,105.94 157.09,105.75 156.95,105.62 156.95,105.18 156.99,105.15 156.99,104.56 156.95,104.52 156.95,103.78 CZ11.2
PCIE_PTX_C_DRX_P9: length 3.3
  BOTTOM w0.102: JNGFF3.13 318.5,29.04 318.35,29.2 317.43,29.2 317.43,29.21 316.7,29.21 CN66.2
PCIE_PTX_C_DRX_P10: length 3.3
  BOTTOM w0.102: CN68.2 316.74,26.2 318.35,26.2 318.5,26.04 JNGFF3.25
PCIE_PTX_C_DRX_P11: length 3.3
  BOTTOM w0.102: CN70.2 316.66,23.2 318.35,23.2 318.5,23.04 JNGFF3.37
PCIE_PTX_C_DRX_P12: length 3.3
  BOTTOM w0.102: JNGFF3.49 318.5,20.04 318.35,20.2 317.54,20.2 317.41,20.07 316.7,20.07 CN72.2
PCIE_PTX_C_DRX_P13: length 3.6
  BOTTOM w0.102: CN215.2 128.72,99.83 128.72,99.15 128.54,98.97 127.82,98.97 127.44,98.59 127.44,98.32 127.28,98.16 JNGFF6.49
PCIE_PTX_C_DRX_P14: length 3.1
  BOTTOM w0.102: JNGFF6.37 130.28,98.17 130.44,98.33 130.44,98.64 130.95,99.15 130.95,99.88 CN213.2
PCIE_PTX_C_DRX_P15: length 2.9
  BOTTOM w0.102: JNGFF6.25 133.28,98.45 133.44,98.6 133.44,99.88 CN211.2
PCIE_PTX_C_DRX_P16: length 2.9
  BOTTOM w0.102: CN209.2 136.44,99.91 136.44,98.35 136.28,98.19 JNGFF6.13
PCIE_PTX_C_DRX_P17: length 2.4
  BOTTOM w0.102: CN187.2 372.4,11.85 372.4,11.1 372.25,10.95 JNGFF4.49
PCIE_PTX_C_DRX_P18: length 2.4
  BOTTOM w0.102: CN185.2 375.4,11.9 375.4,11.1 375.25,10.95 JNGFF4.37
PCIE_PTX_C_DRX_P19: length 2.4
  BOTTOM w0.102: JNGFF4.25 378.25,10.95 378.4,11.1 378.4,11.82 CN183.2
PCIE_PTX_C_DRX_P20: length 2.4
  BOTTOM w0.102: CN181.2 381.4,11.87 381.4,11.1 381.25,10.95 JNGFF4.13
PCIE_PTX_C_DRX_P21: length 2.8
  BOTTOM w0.102: JNGFF5.49 317.93,45.36 317.78,45.51 316.58,45.51 CN201.2
PCIE_PTX_C_DRX_P22: length 2.8
  BOTTOM w0.102: JNGFF5.37 318,48.35 317.85,48.51 316.58,48.51 CN199.2
PCIE_PTX_C_DRX_P23: length 2.8
  BOTTOM w0.102: JNGFF5.25 317.99,51.35 317.83,51.51 316.58,51.51 CN197.2
PCIE_PTX_C_DRX_P24: length 2.8
  BOTTOM w0.102: CN195.2 316.58,54.51 317.78,54.51 317.93,54.35 JNGFF5.13
PCIE_PTX_C_TRX_N1: length 6.1
  BOTTOM w0.076: UT1.Y22 41.09,42.84 41.32,42.61 41.32,42.2 41.44,42.09 41.9,42.09 41.92,42.11 41.94,42.11
  BOTTOM w0.102: CT3.1 45.02,39.46 44.85,39.63 44.85,40.38 v3(44.68,40.55) 43.12,42.11 41.94,42.11
PCIE_PTX_C_TRX_N2: length 5.3
  BOTTOM w0.076: UT1.T22 39.25,42.84 39.49,42.6 39.49,42.04 39.63,41.91 39.65,41.91 39.67,41.89
  BOTTOM w0.102: CT5.1 42.33,39.69 42.33,39.95 v3(41.77,40.52) 41.44,40.84 40.77,40.84 40.23,41.38 40.18,41.38 39.67,41.89
PCIE_PTX_C_TRX_N3: length 4.6
  BOTTOM w0.076: UT1.M22 37.41,42.84 37.65,42.6 37.65,42.05 37.79,41.9 37.82,41.9 37.83,41.89
  BOTTOM w0.102: CT124.1 39.78,39.7 39.78,39.94 39.41,40.31 39.41,40.37 39,40.78 38.94,40.78 38.21,41.51 37.83,41.89
PCIE_PTX_C_TRX_N4: length 4.3
  BOTTOM w0.076: UT1.H22 35.57,42.85 35.36,42.63 35.36,42.24 35.5,42.1 35.5,42 35.86,41.63 35.86,41.47 35.88,41.45 35.88,41.42 35.89,41.41
  BOTTOM w0.102: 35.89,41.41 36.53,40.78 36.53,40.38 37.08,39.83 37.08,39.69 CT126.1
PCIE_PTX_C_TRX_P1: length 6.1
  BOTTOM w0.076: UT1.Y23 40.99,42.55 40.9,42.55 40.87,42.52 40.87,42.28 40.99,42.15 41.16,42.15 41.37,41.94 41.9,41.94 41.92,41.92 41.94,41.92
  BOTTOM w0.102: CT2.1 44.66,39.69 44.66,40.25 44.31,40.6 44.31,40.65 43.04,41.92 41.94,41.92
PCIE_PTX_C_TRX_P2: length 5.3
  BOTTOM w0.076: 39.53,41.76 39.53,41.78 39.03,42.29 39.03,42.58 39.07,42.62 39.14,42.62 39.25,42.51 UT1.T23
  BOTTOM w0.102: CT4.1 42.14,39.68 42.14,39.87 41.87,40.15 41.81,40.15 41.31,40.65 40.64,40.65 v3(40.27,41.01) 39.53,41.76
PCIE_PTX_C_TRX_P3: length 4.6
  BOTTOM w0.076: UT1.M23 37.41,42.55 37.35,42.62 37.24,42.62 37.18,42.56 37.18,42.3 37.68,41.8 37.68,41.77 37.7,41.76
  BOTTOM w0.102: 37.7,41.76 38.08,41.37 v3(39.04,40.41) 39.59,39.86 39.59,39.66 CT123.1
PCIE_PTX_C_TRX_P4: length 4.3
  BOTTOM w0.076: 36.03,41.54 36.01,41.56 36.01,41.7 35.65,42.06 35.65,42.12 35.81,42.28 35.81,42.56 35.73,42.64 35.65,42.64 35.57,42.56 UT1.H23
  BOTTOM w0.102: 36.03,41.54 36.72,40.85 36.72,40.46 37.27,39.91 37.27,39.68 CT125.1
PCIE_PTX_DRX_N5: length 120.4
  TOP w0.076: UH1.B21 145.15,38.6 145.38,38.83 146.5,38.83 146.58,38.75 147.05,38.75 147.07,38.77 147.09,38.77
  TOP w0.102: v2(153.6,132.39) 153.34,132.66 153.34,133.44 CL6.1 ; 147.09,38.77 150.19,38.77 150.4,38.56 150.4,38.29 v2(150.55,38.14)
  IN1 w0.102: v2(150.55,38.14) 150.21,38.48 150.21,38.83 149.59,39.45 147.83,39.45 147.03,40.25 147.03,40.72 147.34,41.04 151.13,41.04 153.42,43.33 153.42,48.82 155.9,51.3 155.9,53.23 157.49,54.81 157.49,57.42 158.06,57.99 158.06,65.35 156.96,66.45 156.96,69.14 156.49,69.61 156.49,71.69 155.91,72.27 155.91,74.38 153.82,76.47 153.82,77.07 153.29,77.6 153.29,92.68 156.61,96 156.61,99.42 154.6,101.44 154.6,102.14 148.92,107.82 148.92,108.8 148.17,109.55 148.17,113.47 148.65,113.95 148.65,120.83 150.26,122.44 150.26,124.3 153.34,127.37 153.34,132.13 v2(153.6,132.39)
PCIE_PTX_DRX_N6: length 177.2
  TOP w0.102: UH1.D21 144.13,38.37 144.33,38.18 145.04,38.18 145.25,37.97 145.77,37.97 145.99,38.18 148.16,38.18 149.07,37.27 151.69,37.27 v2(151.87,37.09)
  IN4 w0.102: v2(26.72,18.46) 26.92,18.66 27.42,18.66 27.87,19.11 27.87,19.73 26.37,21.23 26.37,22.6 27.7,23.93 28.05,23.93 28.77,24.64 28.77,25.59 29.54,26.37 29.54,26.88 31.38,28.72 32.52,28.72 33.07,28.17 34.79,28.17 40.67,34.06 46.17,34.06 48.57,36.45 57.9,36.45 59.78,38.33 62.23,38.33 63.5,39.6 73.95,39.6 74.56,40.21 89.11,40.21 90.88,41.98 93.95,41.98 96.43,39.5 96.43,36.95 98.59,34.79 101.28,34.79 101.76,35.27 104.72,35.27 106.19,33.8 107.22,33.8 109.59,31.42 110.51,31.42 111.34,32.25 113.51,32.25 114.49,31.27 114.49,30.8 115.26,30.03 117.51,30.03 117.88,29.66 118.6,29.66 119.01,29.25 119.01,28.36 119.46,27.91 119.46,26.05 121,24.5 121,23.24 121.9,22.34 122.79,22.34 123.74,23.3 124.53,23.3 124.85,23.61 126.48,23.61 127.36,22.73 130.55,22.73 130.98,22.3 131.85,22.3 132.16,22.61 138.34,22.61 139.31,23.58 140.39,23.58 140.89,24.08 143.31,24.08 143.7,24.48 144.51,24.48 145.44,25.4 146.33,25.4 147.09,26.16 147.09,30.47 147.47,30.85 148.41,30.85 148.98,31.42 151.33,31.42 152,32.09 152,33.71 151.37,34.34 151.37,37.25 151.47,37.35 151.61,37.35 v2(151.87,37.09)
  BOTTOM w0.102: CR205.1 26.35,18.6 26.59,18.6 v2(26.72,18.46)
PCIE_PTX_DRX_N7: length 88.9
  TOP w0.102: UH1.C23 144.48,37.65 144.7,37.49 145.06,37.49 145.38,37.17 146.52,37.17 146.8,37.45 146.8,37.62 v2(146.99,37.81)
  IN1 w0.102: v2(121.77,101.78) 122.04,101.52 122.34,101.52 122.88,102.06 124.69,102.06 129,97.75 129,93.47 129.81,92.65 129.81,85.74 128.89,84.81 128.89,83.98 129.59,83.28 129.59,75.75 129.87,75.48 129.87,72.36 130.68,71.54 130.68,69.41 131.31,68.78 131.31,68.39 133.51,66.2 133.51,65.18 134.53,64.16 137.18,64.16 137.64,63.7 137.64,62.63 139.44,60.82 141.81,60.82 142.77,59.86 142.77,54.1 143.08,53.79 143.08,50.28 142.2,49.4 142.2,47.76 142.49,47.47 142.49,46.19 143.3,45.38 144.47,45.38 145.41,44.44 145.41,40.03 146.76,38.69 146.76,38.04 v2(146.99,37.81)
  BOTTOM w0.102: CZ13.1 119.39,100.88 119.39,100.8 119.48,100.71 120.26,100.71 120.95,101.4 121.41,101.4 121.77,101.75 v2(121.77,101.78)
PCIE_PTX_DRX_N8: length 84.8
  TOP w0.102: UH1.B24 v2(144.16,37)
  IN1 w0.102: v2(144.16,37) 144.16,37.23 144.41,37.48 145.02,37.48 145.3,37.2 150.74,37.2 151.39,37.85 151.39,38.68 155.52,42.8 155.52,48.66 156.88,50.03 156.88,52.2 157.11,52.43 159.1,54.42 159.1,59.43 159.26,59.58 159.26,65.28 158.66,65.88 158.66,67.21 158.28,67.6 158.28,69.54 157.1,70.72 157.1,74.18 154.46,76.82 154.46,77.39 153.89,77.96 153.89,92.44 157.84,96.39 157.84,99.05 155.6,101.3 155.6,102.23 155.78,102.41 156.72,102.41 156.86,102.27 156.86,102.17 v2(156.34,101.65)
  BOTTOM w0.102: CZ10.1 156.69,102.57 156.69,102 v2(156.34,101.65)
PCIE_PTX_DRX_N9: length 202.5
  TOP w0.076: 147.7,33.51 147.68,33.51 147.67,33.52 147.34,33.52 146.08,32.26 144.77,32.26 144.46,31.95 144.39,31.95 144.33,32.01 UH1.C34
  TOP w0.102: 147.7,33.51 151.71,33.51 153.55,31.66 156.7,31.66 157.76,30.61 158.07,30.61 158.25,30.42 v2(158.25,30.27)
  IN4 w0.102: v2(313.18,29.72) 313.18,29.56 313.28,29.45 313.49,29.45 313.84,29.1 313.84,28.04 310.67,24.87 310.67,23.22 302.26,14.81 294.88,14.81 292.94,12.88 292.94,12.13 291.64,10.84 271.1,10.84 270.4,11.53 266.57,11.53 265.97,12.14 261.81,12.14 260.84,13.1 259.9,13.1 257.44,15.56 256.14,15.56 255.9,15.8 245.22,15.8 242.23,12.81 241.84,12.81 238.69,9.67 174.17,9.67 168.71,15.13 168.71,21.77 159.85,30.62 158.61,30.62 v2(158.25,30.27)
  BOTTOM w0.102: CN65.1 315.41,29.4 313.5,29.4 v2(313.18,29.72)
PCIE_PTX_DRX_N10: length 201.1
  TOP w0.076: 147.93,33.06 147.91,33.06 147.89,33.08 147.35,33.08 146.64,32.38 146.64,32.02 146.37,31.74 145.1,31.74 144.94,31.59 144.68,31.59 144.63,31.64 UH1.C35
  TOP w0.102: 147.93,33.06 151.28,33.06 153.52,30.83 155.65,30.83 156.46,30.01 157.17,30.01 157.31,29.87 v2(157.31,29.68)
  IN4 w0.102: v2(157.31,29.68) 157.31,29.9 157.21,30 157,30 156.75,29.76 156.75,29.36 156.75,29.36 156.75,29.28 156.92,29.11 157.77,29.11 159.15,27.73 159.15,27.13 162.11,24.17 165.49,24.17 167.96,21.71 167.96,15.14 173.87,9.22 238.82,9.22 241.37,11.77 241.77,11.77 245.38,15.39 255.72,15.39 258.8,12.31 260.87,12.31 262.24,10.94 269.94,10.94 270.45,10.43 291.85,10.43 293.4,11.98 293.4,12.76 295.01,14.37 302.44,14.37 311.91,23.84 311.91,24.77 313.25,26.11 314.18,26.11 314.49,26.42 v2(314.49,26.6)
  BOTTOM w0.102: CN67.1 315.34,26.28 314.81,26.28 v2(314.49,26.6)
PCIE_PTX_DRX_N11: length 197.4
  TOP w0.076: 151.08,31.33 151.06,31.33 151.04,31.35 146.69,31.35 146.61,31.43 145.23,31.43 145.15,31.34 145.15,31.23 145.19,31.18 145.19,31.13 145.09,31.03 145.01,31.03 UH1.B36
  TOP w0.102: 151.08,31.33 152.11,31.33 153.22,30.22 155.31,30.22 156.62,28.9 156.62,28.68 157.38,27.92 157.38,27.68 157.26,27.56 v2(157,27.56)
  IN4 w0.102: v2(312.81,23.92) 312.81,23.77 313.03,23.55 313.3,23.55 313.54,23.31 313.54,22.63 313.13,22.23 311.46,22.23 302.12,12.88 297.38,12.88 296.29,11.79 294.35,11.79 292.21,9.65 269.78,9.65 269.33,10.09 259.88,10.09 256.54,13.43 245.94,13.43 240.91,8.4 173.59,8.4 166.59,15.4 166.59,21.93 165.63,22.89 162.1,22.89 157.42,27.56 v2(157,27.56)
  BOTTOM w0.102: v2(312.81,23.92) 313.21,23.51 315.49,23.51 CN69.1
PCIE_PTX_DRX_N12: length 194.2
  TOP w0.076: 151.18,30.63 151.16,30.63 151.14,30.64 150.56,30.64 150.17,31.03 145.55,31.03 145.21,30.69 144.35,30.69 144.29,30.75 143.89,30.75 143.83,30.69 143.83,30.57 143.88,30.52 UH1.D38
  TOP w0.102: v2(155.77,26.81) 155.77,27.1 155.43,27.45 154.9,27.45 151.72,30.63 151.18,30.63
  IN4 w0.102: v2(310.66,20.64) 310.66,20.37 310.78,20.26 311.21,20.26 311.4,20.07 311.4,19.62 310.93,19.16 309.26,19.16 303.26,13.16 303.26,12.36 302.1,11.2 294.6,11.2 292.46,9.05 269.49,9.05 269.04,9.5 259.27,9.5 256.25,12.52 245.87,12.52 241.16,7.8 173.26,7.8 159.9,21.17 159.9,22.93 156.67,26.16 156.67,26.34 156.2,26.81 v2(155.77,26.81)
  BOTTOM w0.102: CN71.1 315.41,20.25 311.05,20.25 v2(310.66,20.64)
PCIE_PTX_DRX_N13: length 103.8
  TOP w0.076: UH1.B38 145.19,30.3 146.61,30.3 147.17,30.87 149,30.87 149.14,30.73 149.14,30.34 149.24,30.24 149.4,30.24 v2(149.47,30.31)
  IN4 w0.102: v2(130.29,102.39) 130.06,102.16 130.06,101.68 130.39,101.35 130.39,100.23 133.49,97.13 133.49,95.98 134.64,94.82 135.15,94.82 135.66,94.31 136.42,94.31 140.1,90.63 145.94,90.63 152.54,84.04 152.54,82.22 153.13,81.63 153.13,79.54 154,78.68 154,76.37 155.91,74.45 155.91,72.21 155.12,71.41 155.12,68.12 156.37,66.87 156.37,62.7 155.55,61.88 155.24,61.88 154.66,61.29 154.66,59.6 148.08,53.02 148.08,50.52 152.59,46.02 152.59,32.02 151.49,30.92 149.54,30.92 149.22,30.6 149.22,30.56 v2(149.47,30.31)
  BOTTOM w0.102: CN214.1 128.92,100.83 128.92,101.06 129.4,101.54 129.6,101.54 130.03,101.97 130.03,102.13 v2(130.29,102.39)
PCIE_PTX_DRX_N14: length 102.4
  TOP w0.076: v2(150.96,30.09) 150.77,29.89 150.77,29.51 150.52,29.26 148.4,29.26 147.83,29.83 144.57,29.83 144.48,29.74 144.18,29.74 144.12,29.79 144.12,29.9 144.19,29.97 UH1.C39
  IN4 w0.102: v2(131.43,101.63) 131.13,101.34 131.13,100.96 135.14,96.96 135.14,95.98 135.6,95.52 138.29,95.52 139.87,93.93 140.99,93.93 143.44,91.48 146.38,91.48 148.79,89.07 150.8,89.07 151.66,88.2 151.66,85.77 153.14,84.3 153.14,82.56 153.85,81.85 153.85,79.75 154.61,78.98 154.61,76.67 157.15,74.13 157.15,72.51 156.96,72.32 156.96,60.82 155.52,59.37 155.52,58.13 154.89,57.5 153.62,57.5 151.27,55.15 151.27,48.2 153.22,46.25 153.22,31.77 151.94,30.49 150.88,30.49 150.8,30.42 150.8,30.25 v2(150.96,30.09)
  BOTTOM w0.102: CN212.1 131.15,101.15 131.15,101.36 v2(131.43,101.63)
PCIE_PTX_DRX_N15: length 102.4
  TOP w0.076: v2(148.17,28.93) 148.1,28.86 147.98,28.86 147.83,29.02 147.83,29.32 147.54,29.61 UH1.B40
  IN4 w0.102: v2(148.17,28.93) 147.93,29.16 147.93,29.3 148.01,29.39 149.28,29.39 149.44,29.23 151.52,29.23 153.81,31.52 153.81,46.75 151.94,48.61 151.94,54.88 153.74,56.68 154.91,56.68 157.6,59.37 157.6,64.97 158.21,65.57 158.35,65.71 158.35,67.46 158.22,67.59 158.22,69.49 157.6,70.1 157.6,71.99 157.74,72.12 157.74,74.99 157.35,75.38 157.35,76.07 155.2,78.22 155.2,79.41 154.51,80.1 154.51,82.08 153.79,82.79 153.79,84.62 152.61,85.81 152.61,88.12 150.95,89.78 148.99,89.78 146.63,92.14 143.63,92.14 142.62,93.16 142.62,94.91 140.27,97.26 136.21,97.26 133.6,99.86 133.6,101.41 v2(133.86,101.67)
  BOTTOM w0.102: CN210.1 133.97,100.82 133.61,101.18 133.61,101.2 133.6,101.2 133.6,101.41 v2(133.86,101.67)
PCIE_PTX_DRX_N16: length 106.5
  TOP w0.076: v2(150.07,28.84) 149.8,28.84 149.73,28.77 149.73,28.44 149.52,28.23 147.44,28.23 146.56,29.11 145.21,29.11 145.09,29 144.95,29 UH1.B41
  IN4 w0.102: v2(150.07,28.84) 149.8,28.57 149.8,28.41 149.91,28.3 151.17,28.3 154.22,31.35 154.22,48.57 152.45,50.34 152.45,54.73 153.73,56.01 155.02,56.01 158.01,59.01 158.01,64.47 158.8,65.26 158.8,67.69 158.69,67.8 158.69,70.07 158.08,70.68 158.08,71.71 158.67,72.3 158.67,73.65 158.57,73.75 158.57,74.72 158.85,75 158.85,77.57 156.41,80.01 155.76,80.01 155.04,80.73 155.04,82.21 154.22,83.03 154.22,84.81 153.15,85.88 153.15,88.32 151.23,90.24 149.2,90.24 146.62,92.82 144.42,92.82 143.47,93.76 143.47,95.2 140.72,97.94 136.7,97.94 135.97,98.68 135.97,99.64 134.9,100.71 134.9,102.03 135.22,102.34 136.41,102.34 136.66,102.1 136.66,101.78 v2(136.9,101.54)
  BOTTOM w0.102: v2(136.9,101.54) 136.65,101.29 136.65,101.17 CN208.1
PCIE_PTX_DRX_N17: length 265.7
  TOP w0.076: UH1.A42 145.38,28.44 145.31,28.37 145.31,28.29 145.4,28.21 146.47,28.21 147.52,27.15 148.44,27.15 148.45,27.17 148.54,27.17
  TOP w0.102: v2(153.9,24.36) 153.9,24.2 153.72,24.02 153.48,24.02 153.27,24.22 153.27,25.34 151.44,27.17 148.54,27.17
  IN4 w0.102: v2(365.4,25.26) 365.29,25.37 365.29,25.83 365.01,26.11 358.84,26.11 358.5,26.45 342.4,26.45 338.11,22.15 332.08,22.15 326.06,16.13 317.69,16.13 311.18,9.63 308.2,9.63 303.01,4.44 295.36,4.44 294.31,5.49 268,5.49 267.35,4.84 257.76,4.84 253.55,9.05 247.37,9.05 242.69,4.37 169,4.37 155.71,17.66 155.71,21.45 154.55,22.61 154.55,23.83 154.34,24.04 154,24.04 153.9,24.14 v2(153.9,24.36)
  BOTTOM w0.102: CN186.1 372.68,13.05 372.68,13.57 372.27,13.97 371.63,13.97 370.31,15.29 369.35,15.29 364.74,19.9 364.74,23.95 365.4,24.61 v2(365.4,25.26)
PCIE_PTX_DRX_N18: length 269.5
  TOP w0.076: UH1.C42 144.33,28.24 144.29,28.28 144.29,28.37 144.45,28.53 145.21,28.53 145.43,28.76 146.46,28.76 147.49,27.72 148.58,27.72 148.6,27.7 148.62,27.7
  TOP w0.102: v2(155.19,22.68) 154.94,22.93 154.73,22.93 154.49,23.17 154.49,25.31 152.1,27.7 148.62,27.7
  IN4 w0.102: v2(367.58,26.08) 367.31,25.81 367.31,25.58 367.1,25.37 366.61,25.37 365.46,26.52 359.5,26.52 359.16,26.86 342.23,26.86 338.06,22.68 331.94,22.68 325.89,16.64 317.56,16.64 311.25,10.33 308.25,10.33 304.86,6.94 295.02,6.94 293.98,5.9 257.41,5.9 253.82,9.49 247.22,9.49 242.54,4.8 169.19,4.8 156.17,17.82 156.17,22.34 155.57,22.95 155.45,22.95 v2(155.19,22.68)
  BOTTOM w0.102: v2(367.58,26.08) 367.58,22.16 367.15,21.74 367.15,19.55 369.79,16.92 370.66,16.92 371.89,15.69 372.53,15.69 374.59,13.63 375.41,13.63 375.62,13.42 375.62,13.15 CN184.1
PCIE_PTX_DRX_N19: length 273.5
  TOP w0.076: 146.32,27.22 146.2,27.34 146.2,27.35 146.2,27.35 145.85,27.71 145.07,27.71 144.9,27.88 144.59,27.88 144.48,27.77 144.48,27.73 UH1.C44
  TOP w0.102: 146.32,27.22 150.87,22.67 150.87,21.91 150.7,21.75 150.52,21.75 v2(150.42,21.85)
  IN4 w0.102: v2(369.37,23.41) 369.37,24.03 369.2,24.21 358.43,24.21 357.38,25.26 342.9,25.26 338.58,20.95 334.85,20.95 329.17,15.27 328.23,15.27 327.35,14.39 317.67,14.39 310.48,7.2 308.69,7.2 306.97,5.49 306.21,5.49 303.97,3.25 294.43,3.25 294.03,3.65 257.27,3.65 253.13,7.79 247.88,7.79 243.25,3.16 168.31,3.16 166.76,4.72 160.58,4.72 156.35,8.94 156.35,11.86 154.28,13.93 154.28,20.21 151.92,22.56 151.01,22.56 150.81,22.36 150.81,22.03 150.63,21.85 v2(150.42,21.85)
  BOTTOM w0.102: v2(369.37,23.41) 369.37,22.11 369.11,21.85 369.11,20.16 372.38,16.88 373.03,16.88 374.68,15.23 376.88,15.23 378.54,13.57 378.54,13.15 CN182.1
PCIE_PTX_DRX_N20: length 273.7
  TOP w0.076: 146.17,26.79 146.14,26.79 145.78,27.15 145.78,27.43 145.67,27.54 145.55,27.54 145.48,27.46 145.48,27.38 UH1.A44
  TOP w0.102: v2(149.7,22.17) 149.45,22.43 149.45,23.51 146.17,26.79
  IN4 w0.102: v2(149.7,22.17) 149.45,22.17 149.32,22.3 149.32,22.63 149.76,23.07 152.33,23.07 154.88,20.52 154.88,17.36 168.65,3.59 243.06,3.59 247.7,8.23 253.26,8.23 257.44,4.06 267.92,4.06 268.54,4.68 293.58,4.68 294.6,3.66 303.8,3.66 308.65,8.5 311.19,8.5 317.52,14.84 326.74,14.84 327.82,15.92 328.56,15.92 334.02,21.37 338.43,21.37 342.73,25.67 357.94,25.67 358.99,24.62 370.81,24.62 370.99,24.79 370.99,25.26 v2(371.15,25.41)
  BOTTOM w0.102: v2(371.15,25.41) 370.88,25.15 370.88,22.57 371.13,22.33 371.13,20.76 375.26,16.63 377.46,16.63 380.4,13.69 381.28,13.69 381.59,13.38 381.59,13.15 CN180.1
PCIE_PTX_DRX_N21: length 228.7
  TOP w0.076: 143.25,24.32 143.24,24.34 143.24,24.36 143.15,24.46 143.15,25.23 142.99,25.38 142.99,25.73 UH1.G47
  TOP w0.102: v2(144.81,22.46) 145.16,22.81 145.16,23.41 145.04,23.53 144.05,23.53 143.84,23.73 143.25,24.32
  IN4 w0.102: v2(314.7,46.01) 314.7,45.89 314.8,45.79 315.53,45.79 315.96,45.36 315.96,40.71 317.1,39.57 317.1,17.96 313.07,13.92 310.05,13.92 306.31,10.19 305.27,10.19 304.49,9.41 295.34,9.41 293.08,7.15 268.55,7.15 267.98,7.71 257.28,7.71 254.3,10.69 246.63,10.69 241.94,6.01 169.67,6.01 157.42,18.26 157.42,22.82 155.7,24.53 155.35,24.53 154.47,25.41 152.09,25.41 151.3,24.63 148.59,24.63 146.96,23 146.96,22.77 146.05,21.86 145.22,21.86 144.98,22.1 144.98,22.3 v2(144.81,22.46)
  BOTTOM w0.102: CN200.1 315.29,45.7 315.01,45.7 v2(314.7,46.01)
PCIE_PTX_DRX_N22: length 237.2
  TOP w0.076: UH1.H47 141.62,25.69 141.62,25.37 141.33,25.09 141.33,24.68 141.31,24.66 141.31,24.64
  TOP w0.102: 141.31,24.64 141.31,24.11 141.22,24.02 141.22,23.68 v2(141,23.46)
  IN4 w0.102: v2(141,23.46) 141.16,23.3 141.16,21.96 141.97,21.15 146.6,21.15 149.38,23.93 151.59,23.93 152.46,24.81 154.23,24.81 155.11,23.93 155.44,23.93 156.79,22.58 156.79,18.04 169.42,5.41 242.21,5.41 246.9,10.09 254.06,10.09 257.03,7.12 267.55,7.12 268.12,6.55 293.52,6.55 295.78,8.82 304.79,8.82 305.39,9.43 306.46,9.43 308.6,11.56 311.6,11.56 317.27,17.24 318.3,17.24 318.73,17.67 318.73,45.34 315.24,48.83 314.92,48.83 v2(314.7,49.04)
  BOTTOM w0.102: v2(314.7,49.04) 315.05,48.7 315.29,48.7 CN198.1
PCIE_PTX_DRX_N23: length 233.1
  TOP w0.102: UH1.G49 142.53,25.07 142.61,25.15 142.7,25.15 142.78,25.08 142.78,24.04 143.77,23.04 143.77,22.7 v2(143.51,22.43)
  IN4 w0.102: v2(143.51,22.43) 143.68,22.6 143.68,23.1 144.19,23.61 146.35,23.61 148.94,26.2 154.79,26.2 155.67,25.31 156.03,25.31 158.2,23.14 158.2,18.58 169.98,6.8 241.62,6.8 246.31,11.49 254.61,11.49 257.6,8.5 268.36,8.5 268.86,7.99 292.81,7.99 295.02,10.19 302.79,10.19 303.9,11.31 305.95,11.31 311.49,16.86 313.75,16.86 316.28,19.38 316.28,38.27 313.27,41.28 313.27,51.25 313.74,51.72 314.46,51.72 v2(314.7,51.96)
  BOTTOM w0.102: CN196.1 315.29,51.7 314.95,51.7 v2(314.7,51.96)
PCIE_PTX_DRX_N24: length 240.8
  TOP w0.076: 142.13,24.28 142.13,24.3 142.11,24.32 142.11,25 142.43,25.32 142.43,26.2 142.33,26.31 142.33,26.49 142.42,26.59 142.52,26.59 UH1.G46
  TOP w0.102: 142.13,24.28 142.13,23.85 142.47,23.51 142.47,22.93 v2(142.74,22.67)
  IN4 w0.102: v2(314.7,55.07) 314.95,54.81 315.39,54.81 315.86,54.34 315.86,53.47 315.45,53.05 313.29,53.05 312.73,52.49 312.73,40.67 315.72,37.68 315.72,19.41 313.57,17.26 308.23,17.26 303.91,12.94 303.91,11.95 302.56,10.6 294.85,10.6 292.7,8.46 269.17,8.46 268.73,8.9 257.77,8.9 254.76,11.91 246.13,11.91 241.43,7.21 170.15,7.21 158.77,18.58 158.77,23.14 156.19,25.72 155.87,25.72 154.9,26.7 148.93,26.7 146.16,23.93 144.06,23.93 143.65,23.53 142.71,23.53 142.47,23.28 142.47,22.94 v2(142.74,22.67)
  BOTTOM w0.102: v2(314.7,55.07) 315.08,54.69 315.28,54.69 CN194.1
PCIE_PTX_DRX_P5: length 120.3
  TOP w0.076: 147.09,38.58 147.08,38.58 147.06,38.59 146.52,38.59 146.43,38.68 145.44,38.68 145.33,38.57 145.33,38.44 145.36,38.41 UH1.A22
  TOP w0.102: v2(152.88,132.39) 153.15,132.66 153.15,133.44 CL5.1 ; v2(149.72,38.14) 150.06,38.14 150.21,38.29 150.21,38.48 150.11,38.58 147.09,38.58
  IN1 w0.102: v2(152.88,132.39) 153.15,132.13 153.15,127.45 150.08,124.38 150.08,122.52 148.46,120.91 148.46,114.03 147.98,113.55 147.98,109.47 148.73,108.73 148.73,107.75 154.41,102.07 154.41,101.36 156.42,99.35 156.42,96.08 153.1,92.76 153.1,77.52 153.63,76.99 153.63,76.39 155.73,74.3 155.73,72.19 156.3,71.62 156.3,69.53 156.77,69.06 156.77,66.37 157.87,65.27 157.87,58.07 157.3,57.5 157.3,54.89 155.71,53.31 155.71,51.38 153.24,48.9 153.24,43.41 151.05,41.23 147.27,41.23 146.84,40.8 146.84,40.17 147.75,39.26 149.52,39.26 150.02,38.75 150.02,38.45 v2(149.72,38.14)
PCIE_PTX_DRX_P6: length 177.3
  TOP w0.102: UH1.C21 144.34,38.63 144.29,38.58 144.29,38.49 144.41,38.37 145.12,38.37 145.33,38.16 145.69,38.16 145.91,38.37 148.24,38.37 149.15,37.46 151.53,37.46 v2(151.87,37.8)
  IN4 w0.102: v2(151.87,37.8) 151.61,37.54 151.39,37.54 151.18,37.33 151.18,34.27 151.81,33.63 151.81,32.17 151.25,31.61 148.9,31.61 148.33,31.04 147.39,31.04 146.9,30.55 146.9,26.24 146.25,25.59 145.36,25.59 144.43,24.66 143.62,24.66 143.23,24.27 140.82,24.27 140.31,23.76 139.23,23.76 138.26,22.8 132.08,22.8 131.78,22.49 131.06,22.49 130.63,22.92 127.44,22.92 126.56,23.8 124.77,23.8 124.45,23.48 123.66,23.48 122.71,22.53 121.98,22.53 121.19,23.32 121.19,24.58 119.65,26.12 119.65,27.99 119.2,28.44 119.2,29.33 118.68,29.85 117.95,29.85 117.59,30.22 115.34,30.22 114.67,30.88 114.67,31.35 113.59,32.44 111.26,32.44 110.44,31.61 109.66,31.61 107.29,33.98 106.26,33.98 104.79,35.45 101.68,35.45 101.2,34.98 98.67,34.98 96.62,37.02 96.62,39.58 94.03,42.16 90.8,42.16 89.03,40.4 74.48,40.4 73.87,39.79 63.42,39.79 62.15,38.52 59.7,38.52 57.82,36.64 48.49,36.64 46.09,34.24 40.59,34.24 34.71,28.36 33.14,28.36 32.6,28.9 31.3,28.9 29.35,26.95 29.35,26.44 28.58,25.67 28.58,24.72 27.98,24.12 27.62,24.12 26.18,22.68 26.18,21.16 27.68,19.65 27.68,19.18 27.34,18.85 26.99,18.85 v2(26.71,19.12)
  BOTTOM w0.102: CR203.1 26.25,18.81 26.4,18.81 v2(26.71,19.12)
PCIE_PTX_DRX_P7: length 89
  TOP w0.102: v2(146.15,37.78) 146.26,37.9 146.49,37.9 146.61,37.78 146.61,37.53 146.44,37.36 145.46,37.36 145.14,37.68 144.76,37.68 144.65,37.76 144.65,37.84 144.73,37.92 UH1.B23
  IN1 w0.102: v2(121.77,101.06) 122.04,101.33 122.42,101.33 122.96,101.87 124.61,101.87 128.81,97.67 128.81,93.39 129.63,92.57 129.63,85.82 128.7,84.89 128.7,83.9 129.4,83.21 129.4,75.68 129.68,75.4 129.68,72.28 130.49,71.46 130.49,69.34 131.13,68.7 131.13,68.31 133.32,66.12 133.32,65.1 134.45,63.97 137.1,63.97 137.45,63.62 137.45,62.55 139.37,60.63 141.73,60.63 142.58,59.78 142.58,54.02 142.89,53.71 142.89,50.36 142.01,49.48 142.01,47.69 142.3,47.39 142.3,46.11 143.23,45.19 144.39,45.19 145.22,44.36 145.22,39.95 146.57,38.61 146.57,37.86 146.49,37.78 v2(146.15,37.78)
  BOTTOM w0.102: CZ12.1 119.2,101.28 119.2,100.73 119.4,100.52 120.34,100.52 121.03,101.21 121.63,101.21 v2(121.77,101.06)
PCIE_PTX_DRX_P8: length 84.8
  TOP w0.102: UH1.C24 144.17,37.42 143.93,37.66 v2(143.93,37.93)
  IN1 w0.102: v2(157.24,101.83) 157.05,102.01 157.05,102.35 156.8,102.6 155.71,102.6 155.41,102.31 155.41,101.22 157.65,98.98 157.65,96.47 153.7,92.51 153.7,77.88 154.27,77.31 154.27,76.75 156.91,74.11 156.91,70.64 158.09,69.46 158.09,67.52 158.48,67.14 158.48,65.8 159.07,65.21 159.07,59.66 158.92,59.5 158.92,54.5 156.69,52.27 156.69,50.1 155.33,48.74 155.33,42.88 151.2,38.76 151.2,37.92 150.67,37.39 145.38,37.39 145.1,37.66 144.19,37.66 v2(143.93,37.93)
  BOTTOM w0.102: CZ11.1 156.88,102.38 156.88,101.99 157.04,101.83 v2(157.24,101.83)
PCIE_PTX_DRX_P9: length 202.6
  TOP w0.076: UH1.D34 144.32,32.41 146.02,32.41 147.28,33.67 147.66,33.67 147.69,33.7 147.7,33.7
  TOP w0.102: v2(158.24,31.17) 158.24,30.9 158.14,30.8 157.84,30.8 156.78,31.85 153.63,31.85 151.79,33.7 147.7,33.7
  IN4 w0.102: v2(158.24,31.17) 158.6,30.81 159.93,30.81 164.41,26.33 168.9,21.85 168.9,15.21 174.25,9.86 238.62,9.86 241.76,13 242.15,13 245.15,15.99 255.97,15.99 256.22,15.75 257.52,15.75 259.98,13.29 260.92,13.29 261.89,12.32 266.05,12.32 266.65,11.72 270.48,11.72 271.17,11.02 291.57,11.02 292.75,12.21 292.75,12.96 294.8,15 302.18,15 310.48,23.3 310.48,24.95 313.65,28.12 313.65,29.02 313.41,29.26 313.29,29.26 313.18,29.15 v2(313.18,28.75)
  BOTTOM w0.102: CN66.1 315.41,29.21 313.63,29.21 v2(313.18,28.75)
PCIE_PTX_DRX_P10: length 201.1
  TOP w0.076: UH1.B35 144.71,31.8 144.67,31.85 144.67,31.92 144.83,32.08 144.98,32.08 145.03,32.03 145.03,31.95 145.08,31.9 146.31,31.9 146.49,32.08 146.49,32.44 147.29,33.24 147.89,33.24 147.91,33.25 147.93,33.25
  TOP w0.102: 147.93,33.25 151.36,33.25 153.59,31.02 155.73,31.02 156.54,30.2 157.12,30.2 v2(157.31,30.4)
  IN4 w0.102: v2(314.49,25.63) 314.2,25.92 313.33,25.92 312.1,24.69 312.1,23.76 302.51,14.18 295.08,14.18 293.59,12.68 293.59,11.9 291.92,10.24 270.37,10.24 269.87,10.75 262.16,10.75 260.79,12.12 258.72,12.12 255.64,15.2 245.46,15.2 241.85,11.58 241.45,11.58 238.9,9.03 173.8,9.03 167.77,15.06 167.77,21.63 165.41,23.98 162.04,23.98 158.97,27.05 158.97,27.65 157.69,28.92 156.85,28.92 156.56,29.2 156.56,29.44 156.57,29.44 156.57,29.83 156.92,30.19 157.1,30.19 v2(157.31,30.4)
  BOTTOM w0.102: CN68.1 315.48,26.09 314.95,26.09 v2(314.49,25.63)
PCIE_PTX_DRX_P11: length 197.5
  TOP w0.076: 151.08,31.52 151.06,31.52 151.04,31.5 146.75,31.5 146.67,31.58 145.16,31.58 144.96,31.37 144.8,31.37 UH1.C36
  TOP w0.102: v2(157.7,28.31) 157.26,28.31 156.81,28.76 156.81,28.98 155.39,30.41 153.3,30.41 152.19,31.52 151.08,31.52
  IN4 w0.102: v2(157.7,28.31) 157.46,28.31 157.3,28.15 157.3,27.95 162.17,23.08 165.71,23.08 166.77,22.01 166.77,15.48 173.66,8.59 240.83,8.59 245.86,13.62 256.62,13.62 259.96,10.28 269.41,10.28 269.86,9.83 292.13,9.83 294.28,11.98 296.21,11.98 297.3,13.07 302.04,13.07 311.39,22.42 313.05,22.42 313.35,22.71 313.35,23.23 313.22,23.36 312.93,23.36 312.81,23.24 v2(312.81,22.91)
  BOTTOM w0.102: CN70.1 315.33,23.32 312.88,23.32 312.81,23.24 v2(312.81,22.91)
PCIE_PTX_DRX_P12: length 194.3
  TOP w0.076: 151.18,30.82 151.16,30.82 151.14,30.8 150.62,30.8 150.24,31.18 145.49,31.18 145.15,30.84 144.41,30.84 144.35,30.9 143.82,30.9 143.66,30.74 UH1.E37
  TOP w0.102: 151.18,30.82 151.8,30.82 154.98,27.64 155.5,27.64 155.98,27.16 156.16,27.16 v2(156.42,27.43)
  IN4 w0.102: v2(310.54,19.78) 310.83,20.07 311.14,20.07 311.21,19.99 311.21,19.7 310.86,19.34 309.18,19.34 303.07,13.23 303.07,12.44 302.02,11.38 294.52,11.38 292.38,9.24 269.56,9.24 269.12,9.69 259.35,9.69 256.33,12.7 245.79,12.7 241.08,7.99 173.34,7.99 160.08,21.25 160.08,23.01 156.86,26.24 156.86,26.42 156.19,27.08 156.19,27.19 v2(156.42,27.43)
  BOTTOM w0.102: v2(310.54,19.78) 310.54,19.96 310.65,20.06 315.41,20.06 CN72.1
PCIE_PTX_DRX_P13: length 103.8
  TOP w0.076: v2(148.78,30.31) 148.99,30.51 148.99,30.67 148.94,30.71 147.23,30.71 146.67,30.15 144.92,30.15 UH1.C38
  IN4 w0.102: v2(129.58,102.39) 129.87,102.1 129.87,101.6 130.2,101.27 130.2,100.15 133.3,97.05 133.3,95.9 134.56,94.63 135.07,94.63 135.58,94.12 136.34,94.12 140.02,90.44 145.87,90.44 149.11,87.2 149.92,86.39 152.35,83.96 152.35,82.14 152.95,81.55 152.95,79.46 153.81,78.6 153.81,76.29 155.73,74.37 155.73,72.29 154.93,71.49 154.93,68.05 156.18,66.79 156.18,62.78 155.47,62.07 155.17,62.07 154.47,61.37 154.47,59.68 147.89,53.1 147.89,50.44 152.4,45.94 152.4,32.09 151.41,31.1 149.46,31.1 149.03,30.67 149.03,30.56 v2(148.78,30.31)
  BOTTOM w0.102: CN215.1 128.72,100.84 128.72,101.14 129.32,101.73 129.52,101.73 129.84,102.05 129.84,102.13 v2(129.58,102.39)
PCIE_PTX_DRX_P14: length 102.4
  TOP w0.076: v2(150.28,30.09) 150.53,30.09 150.62,30 150.62,29.57 150.46,29.42 148.46,29.42 147.89,29.98 144.67,29.98 144.46,30.19 144.16,30.19 UH1.D39
  IN4 w0.102: v2(150.28,30.09) 150.28,30.09 150.61,30.42 150.61,30.5 150.8,30.68 151.87,30.68 153.03,31.85 153.03,46.17 151.08,48.12 151.08,55.23 153.54,57.69 154.81,57.69 155.33,58.21 155.33,59.45 156.78,60.9 156.78,72.4 156.96,72.58 156.96,74.05 154.42,76.59 154.42,78.91 153.66,79.67 153.66,81.78 152.95,82.48 152.95,84.22 151.48,85.69 151.48,88.12 150.72,88.88 148.71,88.88 146.3,91.29 143.37,91.29 140.91,93.74 139.8,93.74 138.21,95.33 135.52,95.33 134.95,95.9 134.95,96.88 130.95,100.88 130.95,101.4 v2(130.71,101.63)
  BOTTOM w0.102: CN213.1 130.96,101.18 130.96,101.38 v2(130.71,101.63)
PCIE_PTX_DRX_P15: length 102.5
  TOP w0.076: v2(147.48,28.93) 147.67,29.12 147.67,29.26 147.48,29.46 145.02,29.46 144.96,29.39 144.72,29.39 UH1.C40
  IN4 w0.102: v2(147.48,28.93) 147.74,29.19 147.74,29.38 147.94,29.58 149.35,29.58 149.52,29.42 151.44,29.42 153.62,31.6 153.62,46.67 151.76,48.53 151.76,54.96 153.67,56.87 154.83,56.87 157.42,59.45 157.42,65.04 158.08,65.71 158.17,65.79 158.17,67.38 158.03,67.52 158.03,69.41 157.42,70.02 157.42,72.06 157.55,72.2 157.55,74.91 157.16,75.3 157.16,75.99 155.01,78.14 155.01,79.33 154.32,80.02 154.32,82 153.61,82.72 153.61,84.54 152.42,85.73 152.42,88.04 150.87,89.59 148.92,89.59 146.55,91.95 143.56,91.95 142.43,93.08 142.43,94.83 140.19,97.07 136.13,97.07 133.41,99.79 133.41,101.41 v2(133.15,101.67)
  BOTTOM w0.102: CN211.1 133.41,101.14 133.41,101.41 v2(133.15,101.67)
PCIE_PTX_DRX_P16: length 106.6
  TOP w0.076: v2(149.38,28.84) 149.58,28.64 149.58,28.51 149.46,28.39 147.51,28.39 146.63,29.27 145.15,29.27 145.04,29.16 144.77,29.16 UH1.C41
  IN4 w0.102: v2(136.19,101.54) 136.47,101.82 136.47,102.02 136.33,102.15 135.29,102.15 135.09,101.95 135.09,100.79 136.15,99.72 136.15,98.76 136.78,98.13 140.8,98.13 143.66,95.27 143.66,93.84 144.5,93 146.69,93 149.28,90.42 151.31,90.42 153.34,88.4 153.34,85.95 154.4,84.89 154.4,83.11 155.23,82.29 155.23,80.81 155.84,80.2 156.49,80.2 159.04,77.65 159.04,74.92 158.76,74.64 158.76,73.83 158.86,73.73 158.86,72.23 158.27,71.63 158.27,70.76 158.88,70.15 158.88,67.88 158.99,67.77 158.99,65.18 158.2,64.39 158.2,58.93 155.09,55.82 153.81,55.82 152.64,54.66 152.64,50.42 154.4,48.65 154.4,31.27 151.25,28.12 149.83,28.12 149.62,28.33 149.62,28.6 v2(149.38,28.84)
  BOTTOM w0.102: CN209.1 136.46,101.16 136.46,101.26 v2(136.19,101.54)
PCIE_PTX_DRX_P17: length 265.7
  TOP w0.076: 148.55,26.98 148.54,26.98 148.52,27 147.46,27 146.41,28.05 145.33,28.05 145.12,28.27 UH1.B42
  TOP w0.102: 148.55,26.98 151.36,26.98 153.08,25.26 153.08,24.14 153.4,23.83 153.72,23.83 153.9,23.65 v2(153.9,23.64)
  IN4 w0.102: v2(153.9,23.64) 154.11,23.86 154.26,23.86 154.37,23.75 154.37,22.53 155.52,21.37 155.52,17.58 168.92,4.19 242.77,4.19 247.45,8.87 253.47,8.87 257.68,4.65 267.42,4.65 268.07,5.3 294.23,5.3 295.29,4.25 303.09,4.25 308.28,9.44 311.26,9.44 317.76,15.94 326.13,15.94 332.16,21.97 338.19,21.97 342.48,26.26 358.42,26.26 358.76,25.92 364.93,25.92 365.1,25.76 365.1,25.54 364.82,25.26 v2(364.68,25.26)
  BOTTOM w0.102: v2(364.68,25.26) 364.82,25.26 365.21,24.88 365.21,24.69 364.55,24.03 364.55,19.82 369.27,15.1 370.23,15.1 371.55,13.78 372.19,13.78 372.49,13.49 372.49,13.26 CN187.1
