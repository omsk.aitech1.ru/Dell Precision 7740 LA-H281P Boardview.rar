# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5V_ALW_R on TOP (solid shape): 292.4,24.25 292.4,22.77 291.82,22.19 290.98,22.19 290.73,22.44 290.73,22.9 290.88,23.19 290.73,23.49 290.73,24.12 290.8,24.2 291.34,24.2 291.51,24.37 292.28,24.37
+5V_ALW_R on TOP (solid shape): 375.94,44.74 375.94,40.81 375.44,40.3 373.07,40.3 372.87,40.5 372.87,41.19 372.92,41.24 373.4,41.24 373.43,41.26 373.43,41.98 373.4,42 372.92,42 372.9,42.03 372.9,42.41 372.92,42.43 373.43,42.43 373.43,43.17 373.4,43.19 372.97,43.19 372.9,43.27 372.9,43.83 372.92,43.85 372.92,44.81 373.31,45.2 375.48,45.2
+5V_ALW_R on TOP (solid shape): 363.89,13.98 363.89,13.49 363.9,13.47 363.9,12.77 363.8,12.66 363.04,12.66 362.76,12.94 362.76,13.27 362.38,13.65 362.33,13.72 362.23,13.81 362.11,13.81 361.74,13.81 361.69,13.86 361.69,14.37 361.85,14.52 363.35,14.52
+5V_ALW_R on TOP (solid shape): 292.64,35.29 292.64,34.61 292.78,34.61 292.78,33.39 292.55,33.16 291.41,33.16 290.9,33.67 290.9,34.16 290.94,34.18 291.16,34.56 290.85,34.86 290.83,34.86 290.73,34.97 289.74,34.97 289.66,35.04 289.66,35.27 289.74,35.35 292.58,35.35
+5V_ALW_R on TOP (solid shape): 302.16,66.54 302.16,65.75 301.63,65.23 299.14,65.23 299.05,65.32 299.05,65.66 299.03,65.67 299.03,66.69 299.11,66.77 299.79,66.77 299.92,66.64 299.99,66.64 300,66.63 300.44,66.71 300.47,67.15 300.45,67.17 300.3,67.32 299.08,67.32 299.03,67.38 299.03,67.55 299.08,67.6 301.09,67.6
+5V_ALW_R on TOP (solid shape): 291.79,14.47 292.35,14.47 292.55,14.26 292.55,12.51 292.28,12.23 291.54,12.23 291.42,12.35 291.46,12.4 291.36,12.97 290.85,12.67 290.85,12.61 290.42,12.61 290.27,12.77 290.27,13.43 290.5,13.65 290.52,13.65 290.7,13.83 290.7,14.47 290.8,14.57 291.69,14.57
+5V_ALW_R on TOP (solid shape): outline of 124 points within 377.82,56.14 383.11,59.08
+5V_ALW_R on IN4 (solid shape): 363.42,14.24 363.42,13.94 363.01,13.53 361.77,13.53 361.67,13.63 361.42,13.63 361.42,14.3 361.62,14.49 363.17,14.49
+5V_ALW_R on IN1: outline of 98 points within 359.39,11.2 376.72,33.88
+5V_ALW_R on IN3: outline of 260 points within 289.61,12.38 296.52,65.89
+5V_ALW_R on IN4: outline of 235 points within 290.2,29.09 390.5,69.7
+5V_ALW_RP on TOP (solid shape): 366.92,44.46 366.92,43.99 367.22,43.69 372.71,43.69 372.72,43.68 372.72,43.04 372.73,43.04 373.23,43.04 373.28,42.99 373.28,42.67 373.2,42.6 372.75,42.6 372.72,42.57 372.72,41.86 372.74,41.84 373.26,41.84 373.27,41.82 373.27,41.42 373.24,41.39 372.75,41.39 372.74,41.38 372.74,40.74 372.04,40.04 364.32,40.04 363.98,40.38 363.98,44.64 364.18,44.85 366.54,44.85
+5V_ALWP on TOP (solid shape): 46.06,9.45 46.06,4.18 45.79,3.92 40.22,3.92 40.16,3.98 40.16,4.77 41.3,5.91 41.31,5.91 41.31,6.72 41.3,6.73 40.77,6.73 40.77,6.73 40.77,7.19 40.78,7.2 41.31,7.2 41.31,7.21 41.31,7.89 41.28,7.92 40.75,7.92 40.75,8.38 40.77,8.39 41.3,8.39 41.32,8.41 41.32,9.05 42,9.73 45.78,9.73
+5V_ALWP on BOTTOM (solid shape): 45.08,7.23 45.08,4.28 44.6,3.8 39.93,3.8 39.72,4 39.72,5.2 42.14,7.61 44.7,7.61
+5V_DGFF on TOP (solid shape): 294.36,66.28 294.36,65.34 294.41,65.29 294.84,65.29 294.89,65.24 294.89,65.06 294.38,65.06 294.36,65.04 294.36,64.53 294.38,64.51 294.87,64.51 294.89,64.48 294.89,64.3 294.87,64.28 294.38,64.28 294.36,64.25 294.36,63.74 294.13,63.51 293.11,63.51 292.78,63.85 292.78,64.43 292.78,66.13 293.22,66.56 294.08,66.56
+5V_DGFF on TOP (solid shape): 236.25,94.23 236.25,93.77 236.25,93.77 236.25,93.35 236.17,93.28 235.4,93.28 235.29,93.17 235.29,93.11 235.28,93.1 235.23,92.97 235.24,92.83 235.24,92.82 235.24,92.42 235.23,92.37 235.23,92.29 235,92.07 234.36,92.07 233.99,92.44 233.99,92.6 234.39,93.01 234.39,93.11 234.54,93.26 234.57,93.26 234.91,93.53 234.73,93.93 234.67,94.02 234.7,94.13 234.96,94.39 236.09,94.39
+5V_DGFF on BOTTOM (solid shape): 236.48,93.64 236.48,93.54 236.48,93.53 236.51,93.24 236.75,93.06 236.8,93.05 236.8,92.46 236.79,92.42 236.74,92.4 236.7,92.39 235.86,92.39 234.95,93.31 234.95,94.29 235.06,94.4 235.72,94.4
+5V_DGFF on IN1: outline of 319 points within 234.29,63.44 315.01,95.08
+5V_DGFF on VCC: 236.04,91.99 241.6,91.99 242.24,91.35 242.24,88.9 242.91,88.23 246.83,88.23 247.15,88.55 247.15,90.83 248.18,91.86 250.19,91.86 250.68,92.36 250.68,94.12 250.44,94.36 249.59,94.36 249.29,94.06 249.29,93.73 248.8,93.25 248.41,93.25 247.2,94.45 236.51,94.45 236.5,94.45 235.04,94.45 234.81,94.21 234.81,93.22
+5V_DGFF_PWR on TOP (solid shape): 297.76,66.69 297.76,66.16 297.33,65.72 297.33,64.09 296.66,63.41 294.74,63.41 294.49,63.66 294.49,64.05 294.54,64.1 295.07,64.1 295.07,64.63 295.04,64.66 294.56,64.66 294.51,64.71 294.51,64.89 294.54,64.91 295.02,64.91 295.07,64.96 295.07,65.42 295.02,65.47 294.59,65.47 294.51,65.55 294.51,66 295.04,66.54 296.11,66.54 296.34,66.77 297.69,66.77
+5V_HDD on TOP (solid shape): 368.35,12.79 368.35,12.28 368.36,12.27 368.36,12.26 368.87,12.26 369.09,12.26 369.92,11.42 369.92,11.31 370.22,10.81 370.59,11.26 370.61,11.34 370.68,11.39 370.8,11.42 370.91,11.5 370.98,11.54 371.06,11.51 371.39,11.17 371.39,11.15 371.5,10.91 371.73,10.81 371.75,10.81 372.34,10.23 373.81,10.23 374.9,9.13 374.9,7.96 374.86,7.95 374.55,7.69 374.53,7.28 374.54,7.25 374.42,7.13 372.77,7.13 372.56,7.33 372.56,7.71 372.62,7.77 372.63,7.77 372.95,8.03 372.97,8.44 372.97,8.45 372.97,8.57 372.62,8.93 369.92,8.93 367.61,11.24 367.61,12.21 367.66,12.26 368.13,12.26 368.13,12.82 368.32,12.82
+5V_HDD_UZ23 on TOP (solid shape): 367.99,13.6 368.63,13.6 368.75,13.48 368.75,12.97 368.75,12.97 368.75,12.38 368.48,12.38 368.48,12.84 368.46,12.86 368.46,12.92 368.4,12.92 368.38,12.94 368,12.94 368,12.38 367.75,12.38 367.75,12.48 367.66,12.56 367.66,12.64 367.48,12.82 366.29,12.82 366.04,12.57 365.35,12.57 365.32,12.57 365.12,12.77 365.12,13.43 365.25,13.55 365.99,13.55 366.29,13.86 366.29,14.37 366.42,14.49 367.1,14.49
+5V_RUN on TOP (solid shape): 163.85,103.39 163.85,102.63 163.68,102.45 161.67,102.45 161.29,102.83 161.29,103.62 161.47,103.8 163.45,103.8
+5V_RUN on TOP (solid shape): 232.66,94.99 232.66,94.43 232.31,94.07 230.52,94.07 230.43,94.16 230.43,95.06 230.55,95.19 232.46,95.19
+5V_RUN on TOP (solid shape): 376.75,37.59 376.75,36.79 377.43,36.11 377.43,33.25 377.26,33.08 376.54,33.08 376.54,32.53 376.29,32.53 376.29,33.08 375.74,33.08 375.74,32.53 375.49,32.53 375.49,33.08 374.89,33.08 374.62,33.34 374.62,34.22 373.47,35.37 373.47,36.16 372.93,36.16 372.93,36.61 373.47,36.61 373.47,37.36 372.93,37.36 372.93,37.81 373.47,37.81 373.47,38.71 373.62,38.85 375.49,38.85
+5V_RUN on TOP (solid shape): 277.93,94.78 277.93,94.12 277.85,93.8 277.92,93.47 277.93,93.46 277.93,93.32 278.26,92.99 278.77,92.99 278.97,92.78 278.97,92.27 278.71,92 278.15,92 278.06,91.92 277.16,91.92 277.03,92.05 277.03,92.18 277.05,92.2 277.05,93.5 277.03,93.52 277.03,93.54 276.76,93.8 276.21,93.8 276.02,93.99 276.02,94.81 276.1,94.88 277.82,94.88
+5V_RUN on TOP (solid shape): 304.58,73.55 304.82,73.41 305.07,73.55 305.67,73.55 305.95,73.27 305.95,72.49 305.86,72.4 305.48,72.4 305.13,72.04 305.13,70.93 306.04,70.02 307.57,70.02 307.97,69.61 307.97,68.95 307.11,68.09 305.74,68.09 305.73,68.09 303.82,68.09 303.35,68.56 303.35,72 303.35,72.66 304.06,73.37 304.28,73.37 304.46,73.55
+5V_RUN on TOP (solid shape): 122.76,80.36 122.76,79.92 122.78,79.9 122.78,78.83 122.22,78.27 122.22,77.21 121.89,76.88 121.21,76.88 121.15,76.93 120.85,76.93 120.75,77.03 120.75,77.08 120.5,77.32 120.5,77.34 120.19,77.59 119.84,77.39 119.84,77.39 119.75,77.29 118.7,77.29 118.69,77.28 118.04,77.28 117.94,77.3 117.84,77.28 116.89,77.28 116.77,77.35 116.66,77.46 116.58,77.46 116.56,77.47 116.3,77.54 116.05,77.47 116.03,77.46 115.86,77.46 115.7,77.62 115.7,77.86 115.69,77.87 115.69,78.53 115.82,78.65 119.39,78.65 120.41,79.67 120.41,80.38 120.47,80.44 122.68,80.44
+5V_RUN on IN1 (solid shape): 119.85,94.28 119.86,94.28 120.21,93.92 120.21,93.71 120.19,93.63 120.18,93.56 120.18,93.54 119.99,93.35 119.86,93.35 119.79,93.27 119.77,93.27 118.99,92.42 119.46,91.36 120.86,89.97 120.86,88.23 121.69,87.4 121.69,80.11 121.58,80 120.32,80 119.6,80.72 119.6,81.17 119.66,81.28 119.78,81.29 120.27,81.62 119.78,81.95 119.66,81.96 119.6,82.07 119.6,86.32 118.12,87.8 118.12,93.79 118.69,94.37 118.78,94.45 119.68,94.45
+5V_RUN on IN1 (solid shape): outline of 593 points within 276.55,87.66 303.77,94.98
+5V_RUN on IN1 (solid shape): outline of 926 points within 350.67,33.8 377.16,50.09
+5V_RUN on IN3 (solid shape): 162.86,104.51 162.86,103.11 162.61,102.86 161.44,102.86 160.78,103.52 160.78,104.87 161.16,105.25 162.13,105.25
+5V_RUN on IN3 (solid shape): 233.04,94.91 233.04,94.29 233.01,94.25 232.98,94.21 232.89,94.12 231.58,94.12 231.37,94.34 231.37,94.99 231.54,95.16 232.79,95.16
+5V_RUN on IN3 (solid shape): 277.92,94.68 277.92,94.12 277.85,93.81 277.91,93.5 277.92,93.46 277.7,93.23 276.71,93.23 275.79,94.15 272.97,94.15 272.29,94.83 272.29,95.24 272.31,95.26 277.34,95.26
+5V_RUN on IN3 (solid shape): 120.28,95.05 120.28,93.81 120.22,93.72 120.18,93.62 120.18,93.59 119.88,93.29 119.86,93.29 119.69,93.25 119.53,93.18 119.52,93.17 119.28,93.17 119.11,93.34 119.11,95.12 119.35,95.36 119.97,95.36
+5V_RUN on IN4: outline of 178 points within 297.29,47.16 356.51,90.04
+5V_RUN_AUDIO on TOP (solid shape): 379.1,33.23 379.1,31.57 379.1,31.48 379.18,31.39 379.98,31.39 380.21,31.17 380.21,30.27 380.08,30.14 379.1,30.14 379.02,30.23 375.28,30.23 374.89,30.62 374.89,32.9 374.92,32.93 375.34,32.93 375.34,32.38 375.89,32.38 375.89,32.93 376.14,32.93 376.14,32.38 376.69,32.38 376.69,32.93 377.58,32.93 378.02,33.37 378.96,33.37
+5V_RUN_CHG on TOP (solid shape): 354.25,52.72 354.25,51.92 354.12,51.79 351.98,51.79 351.76,52.01 351.76,52.73 351.99,52.96 354.01,52.96
+5V_RUN_PVDD_L on TOP (solid shape): 381.73,32.3 381.73,30.08 381.99,29.82 382.46,29.82 382.54,29.75 382.54,27.95 382.93,27.55 382.93,27.34 382.5,26.91 382.5,26.89 382.46,26.85 382.46,25.64 382.4,25.58 382.28,25.58 382.2,25.66 382.2,27.08 382.31,27.19 382.31,27.89 382.27,27.93 382.27,29.13 382.27,29.2 382.27,29.28 382.27,29.38 382.09,29.56 381.92,29.56 381.7,29.56 381.53,29.39 381.53,29.24 381.48,29.19 381.1,29.19 380.31,28.4 380.18,28.4 379.98,28.2 379.64,28.2 379.45,28.01 379.45,27.52 379.46,27.52 379.46,27.48 379.5,27.44 379.5,27.39 380.46,26.43 380.46,25.63 380.41,25.58 380.26,25.58 380.21,25.64 380.21,26.31 379.87,26.65 379.82,26.65 379.09,26.65 378.99,26.76 378.99,29.36 379.33,29.7 379.34,29.7 379.35,29.71 379.86,29.71 380.36,30.22 380.36,31.58 380.37,31.59 380.41,31.73 380.4,31.88 380.38,31.91 380.87,32.4 381.63,32.4
+5V_RUN_PVDD_L on IN1 (solid shape): outline of 251 points within 378.49,25.1 382.92,30.19
+5V_RUN_PWR on TOP (solid shape): 373.32,38.62 373.32,37.96 372.77,37.96 372.77,37.21 373.32,37.21 373.32,36.76 372.77,36.76 372.77,36.01 373.32,36.01 373.32,35.48 369.19,35.48 368.98,35.27 368.35,35.27 368.27,35.35 368.27,37.33 368.64,37.7 370.63,37.7 370.64,37.71 370.96,37.71 371.98,38.72 373.22,38.72
+5V_USB_PWR1 on TOP (solid shape): 383.17,63.26 383.17,63.08 383.13,63.05 383.13,61.33 383.14,61.3 383.15,61.23 383.11,61.18 381.49,61.18 381.19,61.48 381.19,62.66 381.94,63.42 383,63.42
+5V_USB_PWR1 on TOP (solid shape): outline of 126 points within 386.7,56.32 397.69,61.52
+5V_USB_PWR1 on BOTTOM (solid shape): 389.84,62.56 389.84,59.6 389.45,59.21 387.05,59.21 386.61,59.66 386.61,60.48 386.35,60.74 386.35,60.75 386.28,60.85 386.18,60.91 386.17,60.92 385.94,61.15 381.5,61.15 381.07,61.59 381.07,62.7 381.31,62.94 381.49,62.94 382.08,63.54 388.86,63.54
+5V_USB_PWR1 on IN1 (solid shape): outline of 122 points within 386.88,56.15 397.69,61.72
+5V_USB_PWR1 on IN2 (solid shape): outline of 325 points within 386.94,55.81 397.62,61.53
+5V_USB_PWR1 on IN3 (solid shape): outline of 244 points within 380.73,56.09 398.07,63.6
+5V_USB_PWR2 on TOP (solid shape): 385.47,37.99 385.47,37.67 384.61,36.81 383.39,36.81 383.3,36.9 383.3,37.92 383.47,38.09 385.37,38.09
+5V_USB_PWR2 on TOP (solid shape): outline of 107 points within 385.51,31.13 397.46,35.55
+5V_USB_PWR2 on IN1 (solid shape): outline of 236 points within 385.86,31.07 397.88,35.61
+5V_USB_PWR2 on IN3 (solid shape): outline of 366 points within 382.52,31.27 397.94,38.11
+5V_USB_PWR2 on IN4 (solid shape): outline of 160 points within 386.1,31.23 397.33,35.55
+5V_USB_PWR3 on TOP (solid shape): 116.83,155.02 116.83,154.1 115.84,153.1 115.84,152.86 115.8,152.83 115.8,152.01 115.8,151.97 115.81,151.93 115.82,151.9 115.77,151.84 114.58,151.84 114.2,152.22 114.2,153.15 114.83,153.78 114.83,153.87 114.83,153.88 114.85,153.98 114.83,154.08 114.83,154.09 114.83,155.01 115.05,155.24 116.61,155.24
+5V_USB_PWR3 on TOP (solid shape): outline of 143 points within 121.49,155.97 126.95,165.6
+5V_USB_PWR3 on IN1 (solid shape): outline of 150 points within 121.99,155.91 126.11,165.52
+5V_USB_PWR3 on IN2 (solid shape): outline of 211 points within 114.56,152.49 125.92,165.34
+5V_USB_PWR3 on IN3 (solid shape): outline of 151 points within 114.64,152.52 125.88,158.26
+5V_USB_PWR3 on IN4 (solid shape): outline of 250 points within 122.08,156.06 126.31,165.52
+5V_VBUS1 on TOP (solid shape): 39.37,30.72 39.37,30.18 39.34,30.15 39.32,30.11 38.95,29.74 38.95,29.58 38.94,29.45 38.95,29.34 38.95,28.23 38.62,27.9 38.52,27.86 38.43,27.92 37.88,27.98 37.91,27.44 37.92,27.44 38.4,26.95 38.4,26.8 38.4,26.8 38.4,26.73 38.16,26.49 36.53,26.49 36.34,26.68 35.71,27.31 35.71,30.8 35.99,31.08 39.01,31.08
+5V_VBUS2 on TOP (solid shape): 44.33,30.96 44.33,30.15 44.33,30.14 44.29,29.99 44.33,29.84 44.33,29.83 44.33,28.75 44,28.41 43.58,28.41 43.35,28.19 43.35,27.6 43.71,27.24 43.71,26.68 43.51,26.48 42.31,26.48 42.23,26.52 42.19,26.6 41.98,26.91 41.61,26.86 41.52,26.83 41.44,26.87 41.2,26.96 40.95,26.87 40.91,26.82 40.69,27.04 40.69,28.16 40.86,28.33 40.86,30.82 41.28,31.24 44.05,31.24
+13.5VB_BATT on TOP (solid shape): 77.29,7.48 77.29,6.28 77.29,6.28 76.74,6.28 76.39,5.92 76.74,5.57 77.34,5.57 77.34,2.58 76.46,1.7 68.48,1.7 67.5,2.68 67.5,4.31 66.2,5.61 66.2,7.46 67.16,8.42 76.35,8.42
+13.5VB_BATT on BOTTOM (solid shape): 74.99,8.22 74.99,7.11 74.52,6.64 71.37,6.64 70.95,7.06 70.95,8.24 71.26,8.55 74.66,8.55
+13.5VB_BATT_C on TOP (solid shape): 71.57,11.83 71.57,10.68 71.45,10.56 70.94,10.56 70.69,10.3 70.69,9.79 70.43,9.54 66.92,9.54 66.09,8.71 63.53,8.71 63.19,9.05 63.19,11.83 63.57,12.21 71.19,12.21
+13.5VB_BATT_C on BOTTOM (solid shape): 67.51,13.22 67.51,8.65 67.17,8.31 63.85,8.31 63.45,8.71 63.45,13.48 63.7,13.73 67,13.73
+13.5VB_CHG on TOP (solid shape): outline of 86 points within 78.16,3.93 86.64,16.02
+19.5V_DC_IN on BOTTOM (solid shape): 101.79,61.09 101.79,55.6 101.79,55.16 102.23,55.06 103.16,54.13 103.16,52.21 102.95,51.99 99.55,51.99 99.17,51.61 99.17,49.8 98.92,49.55 97.67,49.55 97.48,49.74 97.48,51.37 97.52,51.4 97.52,52.87 97.55,52.89 97.64,52.97 97.69,53.06 97.71,53.14 97.71,53.22 98.44,53.95 98.44,60.45 99.31,61.33 101.55,61.33
+19.5V_DC_IN_SS on BOTTOM (solid shape): 105.71,50.94 105.71,50.94 105.83,50.82 105.83,40.75 105.67,40.59 101.04,40.59 100.99,40.64 100.99,41.88 101.19,42.17 101.05,42.49 101.2,42.82 100.99,43.12 100.99,44.77 99.77,45.99 96.64,45.99 96.42,46.22 96.42,48.59 96.47,48.64 96.71,48.64 96.72,48.66 98.88,48.66 99.51,49.29 99.51,51.27 99.77,51.53 105.13,51.53
+19.5V_DCIN_JACK on BOTTOM: 87.7,57.67 87.83,57.8 94.97,57.8 95.22,58.05 95.22,62.64 95.75,63.17 95.75,64.82 95.96,65.03 97.71,65.03 98.19,64.54 98.19,54.22 96.18,52.21 87.78,52.21 87.7,52.29
+19.5V_SDC_IN on TOP (solid shape): 83.13,24.78 83.13,22.87 84.02,21.99 84.02,21.48 83.77,21.22 83,21.22 82.75,21.48 81.1,21.48 80.97,21.6 80.97,22.62 81.23,22.87 81.86,22.87 82.24,23.26 82.24,24.78 82.37,24.91 83,24.91
+19.5V_SDC_IN on TOP (solid shape): 59.06,32.61 59.06,30.71 60.07,29.7 60.07,28.97 59.4,28.3 58.76,28.3 58.37,28.69 58.37,29.52 58.14,29.74 56.4,29.74 56.22,29.93 56.22,30.7 56.58,31.07 56.6,31.07 56.82,31.17 56.88,31.4 56.87,31.44 56.96,31.53 56.96,32.54 57.32,32.9 58.77,32.9
+19.5V_SDC_IN on TOP (solid shape): outline of 88 points within 81.43,30.39 87.04,40.78
+19.5V_SDC_IN on BOTTOM (solid shape): 59.38,32.27 59.38,32.02 60.53,30.88 61.29,30.88 61.41,30.75 61.41,29.86 61.29,29.73 59.26,29.73 59,29.48 58.37,29.48 57.86,29.99 57.86,32.4 57.99,32.53 59.13,32.53
+19.5V_SDC_IN on BOTTOM: 93.62,35.51 93.58,35.49 93.26,35.49 93.24,35.5 93.08,35.54 92.91,35.5 92.89,35.49 90.2,35.49 89.94,35.6 89.68,35.49 88.75,35.49 87.7,34.44 87.7,32.11 87.53,31.93 86.57,31.93 86.31,31.66 81.56,31.66 81.43,31.79 81.43,40.48 81.85,40.89 82.21,40.89 83.46,42.14 84.88,42.14 85.29,42.56 95.14,42.56 95.67,43.09 95.67,43.79 95.67,43.79 95.67,44.01 96.37,44.71 98.56,44.71 98.98,44.29 99.86,44.29 100.49,43.66 100.49,42.29 100.48,42.2 100.49,42.12 100.49,40.86 100.17,40.54 98.65,40.54
+19.5V_SDC_IN_CR on BOTTOM (solid shape): 92.72,35.14 92.74,35.05 92.79,34.97 92.79,33.42 92.54,33.17 92.08,33.17 91.88,32.96 91.88,32.43 91.32,32.43 90.97,32.07 91.32,31.71 91.88,31.71 91.88,31.17 91.87,31.16 89.94,31.16 89.91,31.12 89.04,31.12 88.92,31.24 88.92,32.76 88.99,32.87 89.01,33 89.04,33.08 89.12,33.13 89.42,33.5 89.08,33.84 89,33.87 88.96,33.96 88.96,34.46 89.7,35.2 92.72,35.2
+19.5VB on TOP (solid shape): 116.18,143.74 116.18,142.47 116.1,142.39 114.24,142.39 114.09,142.54 114.09,143.7 114.23,143.83 116.09,143.83
+19.5VB on TOP (solid shape): 100.87,39.07 100.87,35.21 100.84,35.17 100.19,35.17 99.83,35.53 99.83,36.26 98.98,37.11 98.44,37.11 98.23,37.31 98.23,39.4 98.42,39.59 100.35,39.59
+19.5VB on TOP (solid shape): 222.48,88.9 222.48,88.67 220.82,87.01 219.03,87.01 217.92,85.89 217.46,85.89 215.73,87.62 215.73,88.51 217.09,89.87 217.44,90.22 221.17,90.22
+19.5VB on TOP (solid shape): 90.66,15.64 90.66,14.7 90.06,14.1 90.06,11.77 89.03,10.74 85.01,10.74 85.01,10.74 84.57,10.74 84.31,11 84.31,15.38 84.69,15.75 90.54,15.75
+19.5VB on TOP (solid shape): 347.04,48.07 347.04,45.99 347.06,45.96 347.57,45.96 347.62,45.91 347.62,45.73 347.6,45.71 347.09,45.71 347.06,45.68 347.06,45.2 347.11,45.15 347.55,45.15 347.6,45.1 347.6,44.95 347.57,44.92 347.06,44.92 347.06,44.39 347.01,44.34 347.01,42.81 346.99,42.79 345.16,42.79 344.37,43.58 344.37,47.89 344.82,48.35 346.76,48.35
+19.5VB on TOP (solid shape): 58.47,14.82 58.47,14.47 58.6,14.34 58.6,12.3 57.98,11.68 55.46,11.68 55.05,12.1 55.05,13.24 55.22,13.42 55.26,13.41 55.61,13.5 55.7,13.85 55.69,13.88 55.72,13.92 55.72,14.68 56.01,14.98 58.32,14.98
+19.5VB on TOP (solid shape): 143.75,115.71 145.37,115.71 145.69,115.4 145.69,113.39 145.51,113.22 143.22,113.22 142.96,113.47 142.96,114.28 142.95,114.29 142.41,114.29 142.4,114.3 142.4,114.55 142.42,114.57 142.94,114.57 142.97,114.59 142.97,115.07 142.94,115.1 142.42,115.1 142.42,115.1 142.42,115.35 142.42,115.35 142.96,115.35 142.96,115.36 142.96,115.83 142.98,115.85 143.62,115.85
+19.5VB on TOP (solid shape): 116.09,87.92 116.09,84.74 116.04,84.69 115.06,84.69 114.64,84.74 114.47,84.35 114.45,84.24 114.35,84.19 111.33,84.19 110.12,85.39 110.12,87.71 110.82,88.41 115.61,88.41
+19.5VB on TOP (solid shape): outline of 94 points within 104.11,1.02 118.53,6.36
+19.5VB on TOP (solid shape): outline of 2363 points within 158.39,1.18 325.65,54.59
+19.5VB on BOTTOM (solid shape): 151.91,1.5 143.91,1.5 143.91,9.5 151.91,9.5
+19.5VB on BOTTOM (solid shape): 225.26,1.39 217.26,1.39 217.26,9.39 225.26,9.39
+19.5VB on BOTTOM (solid shape): 58.65,14.87 58.65,12.79 57.86,12 57.86,10.96 57.66,10.76 56.8,10.76 56.21,11.35 56.21,12.13 56.19,12.15 56.19,12.21 56.13,12.21 56.11,12.24 56.09,12.24 55.67,12.24 55.66,12.24 55.62,12.24 55.62,12.21 55.62,12.21 55.62,11.7 55.6,11.69 55.6,11.68 55.59,11.67 55.36,11.67 55.34,11.68 55.34,12.2 55.31,12.23 54.81,12.23 54.8,12.22 54.8,11.71 54.76,11.68 54.53,11.68 54.53,11.69 54.53,12.14 54.53,12.15 54.53,12.21 54.51,12.22 54.45,12.22 54.44,12.23 54.03,12.23 53.9,12.36 53.9,12.97 54.23,13.29 54.23,13.32 54.26,13.36 54.43,13.36 54.71,13.22 54.99,13.36 55.45,13.36 55.48,13.39 55.5,13.4 55.62,13.48 55.71,13.61 55.71,13.62 55.84,13.75 55.84,14.8 56.15,15.11 58.41,15.11
+19.5VB on BOTTOM (solid shape): outline of 201 points within 165.86,87.06 222.48,114.5
+19.5VB on BOTTOM (solid shape): outline of 2440 points within 87.39,1.02 301.44,15.97
+19.5VB on IN1 (solid shape): outline of 1248 points within 88.94,1.22 118.44,15.86
+19.5VB on IN2 (solid shape): outline of 2113 points within 88.42,1.11 163.72,15.9
+19.5VB on IN3 (solid shape): 111.76,137.78 111.76,132.81 111.07,132.12 109.42,132.12 109.17,132.37 109.17,138.29 109.24,138.37 111.17,138.37
+19.5VB on IN3 (solid shape): 116.86,143.66 116.86,143.25 114.29,140.68 113.46,140.68 112.28,141.87 112.28,142.67 114.58,144.96 115.56,144.96
+19.5VB on IN3 (solid shape): 113.33,89.68 113.33,89.19 113.29,89.18 113.02,88.83 113.29,88.49 113.33,88.48 113.33,88.23 113.51,88.05 113.51,86.4 111.83,84.72 110.77,84.72 109.92,85.58 109.92,88.8 111.83,90.72 112.29,90.72
+19.5VB on TOP: 143.17,137.27 143.17,135.66 142.91,135.4 142.09,135.4 141.53,134.84 139.67,134.84 139.31,135.21 139.31,136.06 139.55,136.3 140.46,136.3 140.67,136.51 142.1,136.51 142.14,136.54 142.14,137.28 142.27,137.41 143.03,137.41
+19.5VB on BOTTOM: outline of 134 points within 89.54,27.19 113.54,88.03
+19.5VB on IN2: 344.37,44.08 341.25,47.21 341.09,47.21 341.07,47.24 340.76,47.41 340.46,47.24 340.44,47.21 340.13,47.21 339.84,47.36 339.55,47.21 337.73,47.21 337.44,47.36 337.14,47.21 332.1,47.21 331.54,47.77 324.43,47.77 322.83,49.37 322.83,50.46 321.92,51.37 321.92,55.06 324.16,57.3 324.18,57.31 324.7,57.54 324.93,58.05 324.93,58.08 326.74,59.89 338.92,59.89 340.73,58.08 344.22,58.08 347.29,55.01 347.29,45.13 346.25,44.08
+19.5VB on VCC: 88.97,31.13 94.18,31.13 94.82,30.49 94.82,29.86 93.8,28.84 93.8,26.43 90.37,23 90.37,17.96 92.53,15.8 92.53,12.43 91.55,11.44 76.65,11.44 74.88,13.22 74.88,15.51 88.21,28.84 88.21,30.37
+19.5VB on IN3: outline of 88 points within 137.96,111.31 167.31,136.49
+19.5VB on IN3: outline of 193 points within 55.67,1.72 110.18,31.11
+19.5VB_CHARGER on TOP (solid shape): outline of 300 points within 94.76,5.18 108.4,15.2
+19.5VB_CPU on TOP (solid shape): 291.34,61.89 291.34,61 290.52,60.19 290.52,58.66 290.35,58.49 289.58,58.49 289.38,58.28 289.38,56.96 289.28,56.86 288.11,56.86 287.98,56.99 287.98,59.7 287.81,59.88 287.07,59.88 286.64,60.31 286.64,61.15 286.89,61.41 289.68,61.41 290.42,62.14 291.08,62.14
+19.5VB_CPU on TOP (solid shape): 289.86,71.92 289.86,71.03 288.72,69.89 288.72,68.67 288.54,68.49 287.78,68.49 287.58,68.29 287.58,66.97 287.47,66.87 286.31,66.87 286.18,66.99 286.18,69.71 286,69.89 285.62,69.89 285.52,69.99 285.52,71.24 285.62,71.34 285.89,71.34 285.91,71.33 286.08,71.29 286.25,71.33 286.26,71.34 286.66,71.34 286.67,71.33 286.84,71.29 287.01,71.33 287.02,71.34 287.54,71.34 287.56,71.33 287.73,71.29 287.9,71.33 287.91,71.34 288.18,71.34 288.19,71.33 288.55,71.34 288.72,71.64 288.72,71.67 289.1,72.05 289.74,72.05
+19.5VB_CPU on TOP (solid shape): 292.02,41.49 292.02,40.4 291.11,39.49 291.11,38.65 290.42,37.96 289.74,37.96 289.58,37.81 289.58,37.75 289.58,37.74 289.57,37.66 289.58,37.59 289.58,37.58 289.58,37.25 289.58,37.24 289.57,37.16 289.58,37.09 289.58,37.08 289.58,36.75 289.57,36.68 289.57,36.62 289.58,36.59 289.38,36.39 288.19,36.39 288.08,36.49 288.08,39.28 287.65,39.72 287.65,40.78 287.86,40.98 288.05,40.98 288.07,40.98 288.24,40.93 288.41,40.98 288.42,40.98 288.81,40.98 288.83,40.98 289,40.93 289.17,40.98 289.18,40.98 289.58,40.98 289.59,40.98 289.76,40.93 289.93,40.98 289.95,40.98 290.21,40.98 290.23,40.98 290.49,40.95 290.71,41.11 290.71,41.12 291.23,41.65 291.87,41.65
+19.5VB_CPU on TOP (solid shape): outline of 362 points within 288.12,13.52 300.96,32.96
+19.5VB_CPU on BOTTOM (solid shape): 291.28,61.91 291.28,60.7 290.42,59.83 286.97,59.83 286.74,60.06 286.74,61.2 286.87,61.33 289.86,61.33 290.65,62.12 291.08,62.12
+19.5VB_CPU on BOTTOM (solid shape): 291.87,51.04 291.87,49.3 291.03,48.45 288.59,48.45 288.16,48.88 287.81,48.88 287.25,49.44 287.25,50.31 287.32,50.38 290.32,50.38 291.13,51.2 291.72,51.2
+19.5VB_CPU on BOTTOM (solid shape): 290.12,71.82 290.12,69.94 289.91,69.74 285.62,69.74 285.44,69.92 285.44,71.16 285.55,71.27 288.68,71.27 288.98,71.56 288.98,71.91 289.13,72.05 289.89,72.05
+19.5VB_CPU on BOTTOM (solid shape): 288.87,32.84 289.01,32.84 289.09,32.83 289.17,32.84 289.62,32.84 289.7,32.83 289.78,32.84 291.86,32.84 292.24,32.46 292.24,31.05 292.07,30.88 290.02,30.88 289.89,30.75 289.89,28.54 289.76,28.41 288.31,28.41 288.25,28.48 288.25,28.48 288.25,28.7 288.24,28.72 288.24,28.98 288.25,29.07 288.24,29.17 288.24,29.61 288.25,29.71 288.24,29.8 288.24,30.25 288.25,30.34 288.24,30.44 288.24,30.88 288.25,30.98 288.24,31.07 288.24,32.83 288.29,32.88 288.83,32.88
+19.5VB_CPU on BOTTOM (solid shape): 298.55,20 298.55,18.7 297.66,17.81 297.39,17.81 297.38,17.79 289.13,17.79 288.11,18.81 288.11,19.95 288.24,20.08 289.15,20.08 289.16,20.08 289.25,20.07 289.35,20.08 289.36,20.08 289.72,20.08 289.74,20.07 289.9,20.04 290.05,20.07 290.07,20.08 290.42,20.08 290.43,20.08 290.52,20.07 290.62,20.08 290.63,20.08 291.05,20.08 291.06,20.08 291.16,20.07 291.25,20.08 291.26,20.08 291.62,20.08 291.63,20.07 291.81,20.02 291.99,20.07 292,20.08 292.25,20.08 292.27,20.07 292.45,20.02 292.62,20.07 292.64,20.08 295.02,20.08 295.56,20.62 297.93,20.62
+19.5VB_CPU on BOTTOM (solid shape): 292.17,41.34 292.17,40.43 290.93,39.18 287.96,39.18 287.57,39.57 287.57,39.6 287.57,39.68 287.55,39.77 287.55,40.14 287.55,40.15 287.58,40.27 287.55,40.4 287.55,40.41 287.55,40.78 287.57,40.82 287.78,41.04 287.99,41.04 288.24,40.93 288.49,41.04 288.75,41.04 289,40.93 289.25,41.04 289.51,41.04 289.76,40.93 290.01,41.04 290.15,41.04 290.38,40.93 290.63,41.02 290.65,41.04 290.7,41.04 291.26,41.59 291.92,41.59
+19.5VB_CPU on TOP: 288.16,46.14 288.06,46.24 288.06,48.68 287.25,49.49 287.25,50.27 287.32,50.35 290.31,50.35 291.11,51.15 291.69,51.15 291.82,51.02 291.82,49.98 291.08,49.24 291.08,48.4 290.4,47.72 289.71,47.72 289.56,47.56 289.56,46.34 289.35,46.14
+19.5VB_CPU on VCC: 294.46,51.71 294.46,47.25 294.26,47.05 294.26,33.73 297.74,30.25 297.74,19.13 297.47,18.86 294.53,18.86 294.08,18.4 291.27,18.4 290.66,17.79 286.67,17.79 284.54,19.93 284.54,68.55 285.59,69.6 285.59,70.49 285.72,70.63 288.9,70.63 289.67,69.86 289.67,63.92 291.62,61.98 291.62,54.55
+19.5VB_DGFF on TOP (solid shape): outline of 135 points within 116.28,82.74 126.7,93.42
+19VB_1.2V on TOP (solid shape): 125.5,13.81 125.5,12.38 125.14,12.02 125.14,8.92 125.09,8.87 124.91,8.87 124.49,8.45 124.49,3.75 124.45,3.71 119.91,3.71 118.84,4.78 118.41,4.78 118.41,4.78 117.98,4.78 117.97,4.79 117.97,5.04 117.97,5.04 117.97,5.33 117.96,5.35 117.46,5.35 117.44,5.33 117.44,4.8 117.43,4.79 117.19,4.79 117.18,4.8 117.18,5.32 117.17,5.33 117.15,5.34 116.65,5.34 116.64,5.33 116.64,4.8 116.63,4.79 114.37,4.79 113.94,5.22 113.94,6.26 114.03,6.35 115.57,6.35 116.04,6.82 117.81,6.82 118.21,7.22 118.21,9.84 119.12,10.76 122.37,10.76 123.38,11.76 123.38,12.85 124.49,13.96 125.35,13.96
+19VB_1.2V on IN1 (solid shape): 114.5,6.59 114.5,5.22 114.25,4.97 112.29,4.97 112.16,5.09 112.16,6.52 112.37,6.72 114.37,6.72
+19VB_1V on TOP (solid shape): 104.63,41.19 104.63,38.91 105.14,38.4 105.14,35.15 105.03,35.04 104.48,35.04 104.24,34.8 104.24,33.83 104.16,33.75 102.67,33.75 102.63,33.78 102.63,34.11 101.57,35.17 101.57,38 101.1,38.47 101.1,41.04 101.61,41.54 104.28,41.54
+19VB_3V on TOP (solid shape): 142.82,115.85 142.82,115.51 142.82,115.5 142.29,115.5 142.27,115.48 142.27,114.97 142.28,114.96 142.82,114.96 142.82,114.95 142.82,114.7 142.82,114.69 142.29,114.69 142.27,114.68 142.27,114.18 142.29,114.16 142.81,114.16 142.83,114.15 142.83,113.33 142.66,113.17 139.03,113.17 137.76,111.9 136.97,111.9 136.92,111.94 136.92,113.33 136.92,113.33 136.92,113.52 138.27,114.88 139.87,114.88 140,114.74 141.23,114.74 141.47,114.98 141.47,115.77 141.57,115.87 142.81,115.87
+19VB_3V on BOTTOM (solid shape): 141.18,114.29 141.18,113.02 140.75,112.59 136.87,112.59 136.7,112.75 136.7,114 136.88,114.18 138.49,114.18 138.9,114.59 140.89,114.59
+19VB_3VR on TOP (solid shape): 322.65,8.9 322.91,8.9 323.29,8.52 323.29,7.63 323.16,7.51 321.76,7.51 321.51,7.76 320.11,7.76 319.73,7.38 316.56,7.38 316.43,7.25 314.65,7.25 314.53,7.38 314.53,9.14 315.02,9.64 316.68,9.64 317.71,10.66 318.2,10.66 318.21,10.65 318.21,10.12 318.22,10.11 318.76,10.11 318.76,10.66 318.77,10.67 319,10.67 319.01,10.65 319.01,10.12 319.02,10.11 319.56,10.11 319.57,10.12 319.57,10.68 320.88,10.68
+19VB_5V on TOP (solid shape): outline of 82 points within 54.35,8.37 58.93,11.43
+19VB_5V on BOTTOM (solid shape): outline of 82 points within 52.39,8.38 57.93,12.11
+19VB_5VR on TOP (solid shape): 354.42,44.49 355.24,44.49 355.57,44.16 355.57,44.16 355.57,43.37 355.5,43.3 354.02,43.3 353.67,43.65 352.78,43.65 352.4,43.27 349.5,43.27 349.02,42.79 347.39,42.79 347.29,42.89 347.29,44.29 347.22,44.36 347.22,44.74 347.77,44.74 347.77,45.3 347.75,45.33 347.22,45.33 347.22,45.56 347.77,45.56 347.77,46.12 347.22,46.12 347.22,46.5 347.6,46.88 352.03,46.88
+19VB_IO on TOP (solid shape): 312.56,57.14 314.89,57.14 315.11,56.92 315.11,55.86 315.07,55.76 314.97,55.73 314.66,55.7 314.41,55.54 313.81,55.54 313.46,55.18 313.46,54.57 313.05,54.17 312.42,54.17 312.39,54.19 312.39,54.73 311.86,54.73 311.86,54.17 311.6,54.17 311.6,54.73 311.05,54.73 311.05,54.19 311.02,54.17 309.15,54.17 309.01,54.31 309.01,54.83 309.22,55.04 310.26,55.04 310.47,54.97 310.69,55.04 310.83,55.32 310.69,55.61 310.69,55.72 310.7,55.74 310.79,55.98 310.69,56.21 310.69,57.43 310.35,57.77 309.57,57.77 309.48,57.86 309.48,58.04 309.53,58.09 311.61,58.09
+19VB_IO on BOTTOM (solid shape): 314.22,56.99 315.62,56.99 315.77,56.83 315.77,56.07 315.19,55.49 312.21,55.49 311.94,55.77 311.94,56.83 312.32,57.22 313.99,57.22
+20V_TBTA_VBUS on TOP (solid shape): 6.41,53.95 6.61,53.79 6.86,53.83 6.9,53.83 6.94,53.81 7.03,53.74 7.15,53.71 7.75,53.71 7.8,53.72 7.85,53.73 9.49,53.73 10.23,52.99 11.27,52.99 11.35,52.9 11.35,52.31 11.3,52.25 9.98,52.25 9.12,53.11 8.88,53.11 8.88,53.11 8.51,53.11 8.4,53.15 8.3,53.17 8.27,53.17 8.21,53.24 8.05,53.24 8,53.29 7.55,53.29 7.45,53.29 7.37,53.28 7.3,53.25 7.29,53.25 7.15,53.25 7.11,53.25 7.07,53.24 6.63,53.24 6.4,53.47 6.33,53.47 6.26,53.49 6.2,53.5 5.7,53.5 5.65,53.49 5.56,53.58 5.56,53.86 5.67,53.96 5.69,53.96 6.2,53.96 6.25,53.97 6.3,53.98 6.39,53.98
+20V_TBTA_VBUS on TOP (solid shape): 6.76,56.7 6.86,56.65 6.93,56.32 7.15,56.21 7.29,56.21 7.3,56.21 7.37,56.18 7.45,56.17 7.96,56.17 8.04,56.18 8.13,56.21 8.14,56.22 8.16,56.22 8.21,56.27 8.29,56.27 8.52,56.3 8.74,56.38 11.27,56.38 11.34,56.31 11.34,55.77 11.3,55.73 10.81,55.73 8.37,55.73 8.35,55.73 8,55.73 8,55.73 7.84,55.73 7.79,55.74 7.75,55.75 7.15,55.75 7.1,55.74 7.03,55.82 7.03,56.01 6.92,56.12 6.88,56.12 6.86,56.13 6.71,56.17 6.55,56.13 6.53,56.12 6.48,56.12 6.4,56.04 5.62,56.04 5.55,56.11 5.55,56.42 5.61,56.48 5.7,56.46 6.2,56.46 6.26,56.47 6.32,56.49 6.37,56.49 6.58,56.7
+20V_TBTA_VBUS on BOTTOM (solid shape): 7.13,56.47 11.23,56.47 11.39,56.31 11.39,55.78 11.29,55.69 7.68,55.69 7.2,56.16 6.77,56.16 6.72,56.17 6.66,56.17 6.45,56.38 6.45,56.66 6.49,56.7 6.9,56.7
+20V_TBTA_VBUS on BOTTOM (solid shape): 8.87,50.02 13.1,50.02 13.66,49.46 13.66,47.64 13.98,47.32 14.36,47.32 14.55,47.13 14.55,45.13 14.38,44.96 10.25,44.96 9.47,45.73 9.47,48.84 9.47,49.04 9.4,49.04 9.4,49.08 9.23,49.08 9.14,49.16 8.36,49.16 8.15,49.37 8.15,50.09 8.35,50.29 8.6,50.29
+20V_TBTA_VBUS on BOTTOM (solid shape): 6.66,53.78 6.69,53.78 6.98,53.78 7.07,53.69 9.07,53.69 9.25,53.51 9.62,53.51 9.88,53.25 9.88,53.07 10.14,52.81 11.28,52.81 11.36,52.73 11.36,52.68 11.37,52.67 11.37,52.3 11.35,52.28 9.95,52.28 9.58,52.65 9.56,52.65 9.03,53.18 8.35,53.18 8.26,53.27 7.02,53.27 7.01,53.28 6.4,53.28 6.4,53.61 6.59,53.8
+20V_TBTA_VBUS on IN2: 12.26,50.95 13.54,49.67 13.54,48.02 12.77,47.26 6.55,47.26 4.01,49.8 4.01,58.69 6.61,61.29 6.61,61.89 6.69,61.97 12.12,61.97 12.82,61.26 12.82,59.98 12.26,59.42
+20V_TBTA_VBUS on VCC: 6.1,57.06 6.1,53.47 8.33,51.24 8.33,48.54 8.33,48.53 8.33,48.5 9.7,47.13 12.99,47.13 13.98,48.12 13.98,56.24 12.99,57.23 6.28,57.23
+20V_TBTB_VBUS on TOP (solid shape): 22.58,67.66 22.83,67.66 23.01,67.83 23.42,67.83 23.87,67.38 23.87,67.19 21.54,64.86 20.76,64.86 19.73,65.89 19.73,68.52 20.32,69.1 21.13,69.1
+20V_TBTB_VBUS on TOP (solid shape): 6.46,70.08 6.48,70.07 6.66,69.98 6.86,70.03 6.89,70.03 6.94,70.01 7.03,69.94 7.15,69.91 7.75,69.91 7.82,69.92 7.88,69.95 7.9,69.95 9.53,69.95 11.81,67.67 11.81,67.48 11.47,67.13 11.36,67.13 9.07,69.43 8.39,69.43 8.12,69.43 8.07,69.49 7.45,69.49 7.37,69.48 7.3,69.45 7.29,69.45 7.15,69.45 7.11,69.44 7.06,69.43 6.8,69.43 6.72,69.45 6.65,69.45 6.62,69.45 6.38,69.68 6.29,69.68 6.24,69.69 6.2,69.7 5.7,69.7 5.65,69.7 5.56,69.79 5.56,70.12 5.61,70.18 5.7,70.16 6.2,70.16 6.26,70.17 6.32,70.19 6.35,70.19
+20V_TBTB_VBUS on TOP (solid shape): 6.67,72.86 6.73,72.87 6.85,72.83 6.88,72.72 6.94,72.51 7.15,72.41 7.28,72.41 7.36,72.38 7.45,72.36 8.02,72.36 8.31,72.4 8.58,72.51 8.64,72.45 8.81,72.45 9.01,72.65 11.87,72.65 12.88,71.64 12.88,71.44 12.39,70.94 12.04,70.94 10.97,72.02 9.02,72.02 8.94,71.94 8.31,71.94 8.31,71.93 7.84,71.93 7.79,71.94 7.75,71.95 7.26,71.95 6.85,72.36 6.82,72.36 6.81,72.36 6.69,72.38 6.58,72.36 6.57,72.36 6.5,72.36 6.32,72.17 6.28,72.18 6.24,72.19 6.2,72.2 5.7,72.2 5.66,72.2 5.59,72.27 5.59,72.56 5.69,72.66 6.2,72.66 6.29,72.68 6.37,72.72 6.45,72.79 6.53,72.83 6.61,72.87
+20V_TBTB_VBUS on BOTTOM (solid shape): 21.93,69.01 21.93,69.01 22.67,68.27 24.07,68.27 25.42,66.92 25.42,66.05 24.46,65.09 23.62,65.09 22.12,66.59 21.64,66.59 20.55,65.5 20.11,65.5 19.73,65.88 19.73,69.18 20.01,69.46 21.48,69.46
+20V_TBTB_VBUS on BOTTOM (solid shape): 6.6,72.87 6.68,72.86 6.76,72.87 6.77,72.88 7.16,72.88 7.17,72.87 7.47,72.87 7.48,72.86 8.6,72.86 8.79,72.67 10.41,72.67 10.43,72.7 11.99,72.7 12.85,71.84 12.85,71.44 12.5,71.09 11.93,71.09 10.92,72.1 8.71,72.1 8.42,72.39 6.67,72.39 6.5,72.56 6.5,72.88 6.59,72.88
+20V_TBTB_VBUS on BOTTOM (solid shape): 6.65,69.95 6.69,69.94 7.01,69.94 7.09,69.92 7.15,69.92 9.64,69.92 11.78,67.77 11.78,67.52 11.26,66.99 11.2,66.99 8.84,69.36 8.58,69.36 8.53,69.41 7.97,69.41 7.97,69.41 6.86,69.41 6.84,69.41 6.7,69.45 6.56,69.43 6.52,69.41 6.43,69.49 6.43,69.88 6.5,69.96 6.59,69.96
+20V_TBTB_VBUS on IN2: 5.96,73.66 5.96,68.48 9.4,65.04 20.63,65.04 21.98,66.39 21.98,68.1 15.85,74.23 6.53,74.23
+20V_VBUS_1 on TOP (solid shape): 49.51,32.15 49.51,31.22 50.03,30.7 50.03,29.69 49.43,29.1 46.17,29.1 45.74,29.53 45.74,30.55 47.24,32.04 48.54,32.04 48.66,32.15 49.5,32.15
+20V_VBUS_1 on TOP (solid shape): 38.36,34.23 39.49,34.23 39.51,34.22 39.89,34.22 40.13,33.97 40.13,32.78 40.73,32.18 40.73,28.38 40.23,27.88 40,27.88 39.74,27.99 39.47,27.88 39.25,27.88 39.22,27.9 39.06,28.06 39.06,28.15 39.08,28.18 39.08,29.69 39.4,30 39.46,30 39.46,30.06 39.5,30.1 39.5,30.78 39.49,30.78 39.49,31.07 39.29,31.27 37.19,31.27 37.09,31.38 37.09,32.69 37.11,32.72 36.8,33.03 36.8,34.09 36.96,34.25 38.34,34.25
+20V_VBUS_1 on BOTTOM (solid shape): 73.86,33.67 73.86,30.88 73.48,30.49 68.27,30.49 67.13,31.64 67.13,33.16 67.38,33.42 71.57,33.42 72.08,33.92 73.61,33.92
+20V_VBUS_1 on BOTTOM (solid shape): 14.93,44.36 14.93,42.05 14.32,41.44 13.08,41.44 12.6,41.92 11.79,41.92 11.45,43.03 10.87,44.03 10.87,44.52 11.07,44.72 14.58,44.72
+20V_VBUS_1 on BOTTOM (solid shape): 40.13,33.62 40.13,31.76 40.03,31.66 40.03,29.89 40.13,29.78 40.13,29.58 40.33,29.58 40.33,28.31 39.95,27.93 39.94,27.93 39.74,27.99 39.53,27.93 39.15,27.93 39.15,27.93 39.04,27.95 38.94,27.93 38.93,27.93 38.42,27.93 38.31,28.03 38.18,28.08 38.15,28.11 38.15,28.64 38.2,28.69 38.5,28.69 38.73,28.92 38.83,28.92 38.83,29.02 38.86,29.05 38.86,31.59 38.43,32.02 38.43,33.82 38.66,34.05 39.7,34.05
+20V_VBUS_1 on VCC: outline of 155 points within 9.22,19.7 70.7,45.86
+20V_VBUS_2 on TOP (solid shape): 46.35,34.03 46.35,32.15 45.76,31.55 42.15,31.55 42.09,31.61 42.09,31.61 42,31.7 42,32.99 41.88,33.11 41.37,33.11 41.2,33.29 41.2,34.64 41.81,35.24 45.13,35.24
+20V_VBUS_2 on TOP (solid shape): 25.25,66.44 25.25,66 24.76,65.52 24.76,65.14 26.49,63.41 26.49,62.55 25.2,61.26 24.29,61.26 23.95,60.93 23.5,60.93 23.34,61.09 23.34,62.42 22.07,63.69 22.07,64.76 24.28,66.97 24.71,66.97
+20V_VBUS_2 on TOP (solid shape): 73.99,35.7 73.99,32.02 73.73,31.76 70.81,31.76 70.79,31.79 70.76,31.91 70.69,32.01 70.68,32.05 70.69,32.1 70.8,32.41 70.6,32.67 70.56,32.69 70.56,33.29 70.3,33.54 68.4,33.54 67.89,34.05 67.89,35.96 68.27,36.34 73.35,36.34
+20V_VBUS_2 on BOTTOM: outline of 87 points within 42.7,25.85 71.83,38.95
+20V_VBUS_2 on IN2: 24.59,64.63 23.74,64.63 23.72,64.61 22.16,63.06 22.16,53.58 22.65,53.09 22.65,43.78 25.5,40.94 28.5,40.94 28.55,40.99 29.05,40.99 29.18,41.11 29.18,41.27 29.33,41.42 29.33,42.59 27.01,44.91 27.01,62.22
+20V_VBUS_2 on VCC: 25.25,31 22.38,33.87 21.71,33.87 16.08,39.51 16.08,55.89 16.08,55.98 16.9,56.8 16.9,62.39 19.17,64.66 24.84,64.66 25.66,63.84 25.66,58.46 25.14,57.95 25.14,46.98 29.58,42.55 29.58,42.55 31.02,41.1 33.2,41.1 35.7,43.6 60.04,43.6 63.98,39.66 71.5,39.66 72.08,39.08 72.08,33.42 71.7,33.03 66.88,33.03 64.84,31 ; 1 cut-out
+20V_VBUS_DC_SS1 on BOTTOM (solid shape): outline of 253 points within 75.77,30.29 81.23,40.27
+20V_VBUS_DC_SS2 on TOP (solid shape): outline of 307 points within 75.51,26.43 81.33,40.27
+VCC_CORE on TOP (solid shape): 239.25,56.36 239.45,56.27 239.66,56.32 239.67,56.33 239.7,56.33 239.75,56.38 240.36,56.38 240.38,56.35 240.38,55.23 240.18,55.03 239.11,55.03 238.99,55.16 238.99,55.36 239,55.38 239.17,55.59 239.15,55.86 239.14,55.88 239.14,55.92 238.96,56.1 238.96,56.27 239,56.29 239.06,56.33 239.11,56.38 239.23,56.38
+VCC_CORE on TOP (solid shape): 239.81,54 239.9,54.02 240.03,54.02 240.08,53.96 240.1,53.89 240.1,53.75 240.01,53.66 239.97,53.68 239.53,53.26 240.13,53.38 240.13,53.41 240.38,53.66 240.64,53.41 240.64,50.61 240.51,50.48 239.72,50.48 239.67,50.52 239.6,50.56 239.48,50.57 239.37,50.56 239.29,50.52 239.25,50.48 239.05,50.48 239,50.52 238.99,50.54 238.99,50.78 239.17,51.01 239.12,51.29 239.11,51.31 239.11,51.32 238.96,51.48 238.96,51.68 238.97,51.68 239.07,51.76 239.15,51.86 239.16,51.88 239.17,51.91 239.18,52.01 239.17,52.11 239.16,52.14 239.15,52.15 239.09,52.25 238.99,52.33 238.96,52.34 238.96,52.61 239,52.63 239.19,52.95 239,53.27 238.96,53.28 238.96,53.53 239,53.55 239.11,53.64 239.17,53.76 239.18,53.78 239.42,54.02 239.72,54.02
+VCC_CORE on TOP (solid shape): 240.02,59.96 240.02,59.74 239.99,59.33 240.37,59.17 240.49,59.05 240.49,58.65 240.3,58.47 240.3,58.45 240.29,58.4 240.27,58.37 240.15,58.25 239.98,58.25 239.5,58.06 239.81,57.66 239.86,57.65 239.9,57.62 239.88,57.54 239.88,57.45 239.88,57.42 239.84,57.38 239.81,57.38 239.67,57.35 239.56,57.27 239.4,57.27 239.37,57.3 239.32,57.33 239.2,57.46 239.2,57.49 239.15,57.71 238.98,57.85 238.94,57.87 238.94,58.09 238.97,58.11 239.19,58.44 238.97,58.76 238.94,58.78 238.94,59.01 238.97,59.02 239.19,59.35 238.97,59.68 238.94,59.69 238.94,59.92 238.98,59.93 239.03,59.96 239.08,60 239.16,60.03 239.25,60 239.53,59.91 239.78,60.06 239.92,60.06
+VCC_CORE on TOP (solid shape): outline of 2843 points within 251.08,24.6 278.08,60.21
+VCC_CORE on BOTTOM (solid shape): 239.25,60.05 239.48,59.95 239.72,60.05 239.81,60.05 239.9,59.96 239.9,59.3 240.5,58.7 240.5,58.13 240.63,58 248.79,58 248.92,58.13 248.92,58.48 249.36,58.91 250.56,58.91 250.92,58.55 250.92,57.78 251.1,57.6 251.1,57.08 251.1,57.07 251.08,56.96 251.1,56.86 251.1,56.85 251.1,56.81 250.87,56.57 248.91,56.57 248.72,56.39 239.88,56.39 239.83,56.44 239.83,56.81 239.16,57.47 239.16,57.5 239.1,57.71 238.93,57.83 238.88,57.84 238.88,58.12 238.93,58.13 239.15,58.44 238.93,58.74 238.88,58.75 238.88,59.03 238.93,59.05 239.15,59.35 238.93,59.65 238.88,59.67 238.88,59.9 238.95,59.96 238.96,59.97 239.02,60 239.08,60.05
+VCC_CORE on BOTTOM (solid shape): outline of 2235 points within 238.68,26.27 277.31,60.34
+VCC_CORE on IN1 (solid shape): outline of 2185 points within 252.53,41.57 277.4,59.25
+VCC_CORE on IN2: outline of 401 points within 238.4,25.85 278.13,59.88
+VCC_CORE on VCC: outline of 205 points within 238.83,25.67 280.3,60.04
+VCC_CORE on IN3: outline of 184 points within 239.13,25.77 281.08,61.8
+VCC_GT on TOP (solid shape): 239.86,35.35 239.9,35.31 239.98,35.24 240.01,35.24 240.1,35.22 240.19,35.22 240.22,35.23 240.54,34.91 240.54,34.66 239.91,34.04 239.87,34 239.75,33.87 239.11,33.87 238.94,34.05 238.94,34.28 239.09,34.43 239.09,34.45 239.1,34.46 239.16,34.66 239.1,34.86 239.09,34.87 239.09,34.89 238.96,35.02 238.96,35.3 239.01,35.35
+VCC_GT on TOP (solid shape): 239.26,38.1 239.51,38.01 239.74,38.11 240.33,38.11 240.51,37.94 240.51,36.31 240.43,36.24 240.05,36.24 239.99,36.29 239.91,36.33 239.9,36.34 239.57,36.67 239.16,36.67 239.01,36.82 239.01,37.07 239.11,37.18 239.12,37.2 239.18,37.48 239.01,37.71 239,37.72 238.96,37.76 238.96,37.98 239,38 239.07,38.05 239.14,38.11 239.24,38.11
+VCC_GT on TOP (solid shape): 240.69,42.1 240.69,39.21 240.5,39.02 240.46,39.02 240.3,39.03 240.15,38.97 240.14,38.95 240.07,38.95 240.05,38.98 239.99,39.04 239.9,39.08 239.88,39.11 239.88,39.36 239.83,39.41 239.82,39.42 239.74,39.54 239.62,39.62 239.6,39.64 239.6,39.82 239.66,39.88 239.67,39.89 239.85,40.2 239.67,40.51 239.66,40.51 239.62,40.55 239.62,41.62 240.18,42.18 240.61,42.18
+VCC_GT on TOP (solid shape): 242.9,32.83 243,32.78 243.02,32.66 243,32.45 243.11,32.27 243.11,32.12 242.99,31.88 243.11,31.63 243.11,31.44 243.02,31.23 243.11,31.02 243.11,30.77 243.03,30.55 243.15,30.35 243.15,30.16 243.08,30.09 243.04,30 243.01,29.96 242.97,29.95 242.56,29.6 242.97,29.25 243.01,29.24 243.04,29.2 243.08,29.11 243.15,29.04 243.15,28.86 243.03,28.64 243.13,28.41 243.13,28.19 243.03,27.98 243.13,27.76 243.13,27.54 243.08,27.49 243.04,27.42 243.04,27.41 242.73,27.1 242.7,27.11 242.32,26.91 242.4,26.49 242.42,26.47 242.42,26.38 242.31,26.38 242.29,26.4 242.01,26.52 241.74,26.38 240.71,26.38 240.54,26.56 240.54,30.92 240.61,31.03 240.75,31.01 241.16,31.03 241.15,31.44 241.15,31.63 241.24,31.99 240.94,32.2 240.92,32.2 240.84,32.27 241.4,32.83
+VCC_GT on TOP (solid shape): outline of 81 points within 246.64,30.09 251.48,32.83
+VCC_GT on TOP (solid shape): outline of 1690 points within 251.28,12.71 278.08,42.43
+VCC_GT on BOTTOM (solid shape): 240.87,42.31 240.87,41.35 240.87,41.35 241.21,41.01 246.65,41.01 247.03,40.64 247.03,39.13 246.74,38.84 245.01,38.84 244.91,38.94 244.91,39.96 244.64,40.23 242.07,40.23 241.77,39.93 241.77,39.16 241.41,38.8 241.22,38.8 241.2,38.78 240.67,38.78 240.66,38.81 240.45,38.99 240.18,38.94 240.1,38.92 240.02,38.95 239.96,39 239.89,39.02 239.87,39.03 239.77,39.12 239.79,39.16 239.81,39.35 239.72,39.51 239.72,39.97 239.81,40.16 239.77,40.36 239.75,40.44 239.79,40.52 239.87,40.74 239.75,40.95 239.72,40.97 239.72,41.43 239.9,41.61 239.9,42.08 240.24,42.42 240.75,42.42
+VCC_GT on BOTTOM (solid shape): outline of 818 points within 240.12,11.95 277.73,42.49
+VCC_GT on IN2 (solid shape): outline of 2435 points within 240.83,12.82 277.93,37.89
+VCC_GT on IN3 (solid shape): outline of 5138 points within 239.06,13.3 277.9,43.14
+VCC_GT on VCC: outline of 124 points within 239.09,12.99 274.35,43.17
+VCC_SA on TOP (solid shape): outline of 431 points within 251.94,60.09 277.52,68.26
+VCC_SA on BOTTOM (solid shape): outline of 345 points within 252.78,59.23 277.22,66.39
+VCC_SA on IN2 (solid shape): outline of 572 points within 252.68,59.99 277.19,66.99
+VCC_SA on VCC: outline of 82 points within 252.68,59.79 278.38,68.63
+VCC_SA on IN3: 254.1,59.79 254.09,59.8 254.03,59.82 253.97,59.83 252.95,59.83 252.68,60.1 252.68,60.46 252.68,60.47 252.68,61.95 252.83,62.1 253.64,62.1 254.03,62.5 258.05,62.5 258.13,62.46 258.15,62.37 258.5,61.93 258.84,62.37 258.86,62.46 258.94,62.5 259.33,62.5 259.56,62.26 264.96,62.26 266.62,63.92 266.62,65.38 266.73,65.48 273.47,65.48 273.84,65.86 273.88,65.86 274,65.98 274,66.84 274.05,66.9 278.16,66.9 278.38,66.68 278.38,61.31 276.9,59.83 258.73,59.83 258.67,59.82 258.61,59.8 258.6,59.79 258.37,59.79 258.3,59.8 258.23,59.79 258,59.79 257.99,59.8 257.93,59.82 257.87,59.83 257.43,59.83 257.37,59.82 257.31,59.8 257.3,59.79 257.07,59.79 257,59.8 256.93,59.79 256.7,59.79 256.69,59.8 256.63,59.82 256.57,59.83 256.13,59.83 256.07,59.82 256.01,59.8 256,59.79 255.77,59.79 255.7,59.8 255.62,59.79 255.12,59.79 255.05,59.8 254.97,59.79 254.47,59.79 254.4,59.8 254.32,59.79
+VCC_SFR_OC on BOTTOM (solid shape): 166.23,38.01 166.23,35.33 165.62,34.72 164.78,34.72 164.46,35.04 162.36,35.04 162.36,35.77 162.63,36.04 162.63,36.57 162.71,36.64 162.71,37.38 162.85,37.51 164.51,37.51 165.16,38.15 166.09,38.15
+VDD_SUPPLY on BOTTOM (solid shape): 24.59,43.74 24.63,43.64 24.57,43.55 24.51,42.99 25.06,43.05 25.16,43.11 25.26,43.08 25.68,42.66 25.68,42.5 25.58,42.38 25.54,42.22 25.57,42.05 25.68,41.92 25.68,40.44 25.59,40.35 24.66,40.35 24.48,40.52 24.48,41.9 22.15,44.24 22.15,44.98 22.27,45.09 23.24,45.09
+VDD_SUPPLY on IN4 (solid shape): outline of 2028 points within 11.63,27.68 27.49,41.26
DV33_18 on BOTTOM (solid shape): 15.41,13.36 15.41,12.57 15.07,12.23 14.56,12.23 14.51,12.29 14.51,13.26 14.68,13.43 15.33,13.43
GND on TOP (solid shape): 383.99,20.78 379.47,20.78 379.47,25.25 383.99,25.25
GND on TOP (solid shape): 63.92,58.63 63.92,57.05 63.78,56.91 59.23,56.91 59.18,56.96 59.18,58.49 59.54,58.84 63.7,58.84
GND on TOP (solid shape): 166.19,118.38 166.19,117.74 165.73,117.28 164,117.28 163.66,117.62 163.66,118.59 163.91,118.84 165.73,118.84
GND on TOP (solid shape): 170.91,112.74 170.91,110.08 170.72,109.89 167.04,109.89 166.9,110.03 166.9,112.72 167.3,113.12 170.53,113.12
GND on TOP (solid shape): 270.33,44.08 270.33,42.96 270.05,42.68 267.71,42.68 267.58,42.81 267.58,44.23 267.69,44.34 270.07,44.34
GND on TOP (solid shape): 270.45,48.59 270.45,47.47 270.18,47.19 267.84,47.19 267.71,47.32 267.71,48.74 267.81,48.85 270.2,48.85
GND on TOP (solid shape): 272.15,28.01 272.15,27.21 271.92,26.97 270.7,26.97 267.33,30.35 267.33,31.81 267.42,31.9 268.25,31.9
GND on TOP (solid shape): 294.13,24.22 294.13,21.96 293.82,21.66 293.09,21.66 292.58,22.16 292.58,24.3 292.71,24.42 293.93,24.42
GND on TOP (solid shape): 338.51,2.32 338.51,1.14 338.43,1.06 334.31,1.06 334.16,1.21 334.16,2.25 334.35,2.44 338.4,2.44
GND on TOP (solid shape): 371.19,39.56 371.19,38.44 370.57,37.83 367.56,37.83 367.31,38.07 367.31,39.65 367.47,39.81 370.93,39.81
GND on TOP (solid shape): 80.72,52.47 80.72,48.91 80.59,48.78 71.96,48.78 71.83,48.91 71.83,52.47 71.96,52.59 80.59,52.59
GND on TOP (solid shape): 294.38,45.28 294.64,45.02 294.64,42.94 294.56,42.86 293.22,42.86 292.94,43.14 292.94,45.3 292.99,45.35 294.38,45.35
GND on TOP (solid shape): 44.28,3.18 44.28,1.95 43.94,1.61 40.49,1.61 40.14,1.96 40.14,3.42 40.26,3.54 43.93,3.54
GND on TOP (solid shape): 113.94,133.33 113.94,130.64 113.19,129.9 111.63,129.9 111.39,130.14 111.39,131.36 112.09,132.06 112.09,133.42 112.32,133.64 113.62,133.64
GND on TOP (solid shape): 141.92,101.03 141.92,100.11 141.39,99.58 141.3,99.58 141.3,99.58 138.65,99.58 138.51,99.71 138.51,101.04 138.54,101.07 141.88,101.07
GND on TOP (solid shape): 168.18,16.99 168.18,13.45 167.6,12.87 164.16,12.87 163.29,13.73 163.29,16.91 163.49,17.1 168.07,17.1
GND on TOP (solid shape): 207.06,17.06 207.06,13.38 206.3,12.61 200.84,12.61 200.48,12.97 200.48,17.16 201.04,17.72 206.4,17.72
GND on TOP (solid shape): 270.33,53.15 270.33,51.83 270.25,51.75 267,51.75 266.74,52.01 266.74,53.18 266.82,53.27 270.22,53.27
GND on TOP (solid shape): 292.66,66.21 292.66,64.48 292.25,64.07 290.95,64.07 290.83,64.2 290.83,65.22 290.6,65.45 290.6,66.11 290.8,66.31 292.55,66.31
GND on TOP (solid shape): 302.64,31.18 302.64,26.89 302.38,26.63 300.56,26.63 299.74,27.45 299.74,31.31 299.82,31.38 302.44,31.38
GND on TOP (solid shape): 303.86,18.81 303.86,16.14 303.73,16.02 300.8,16.02 300.56,16.26 300.56,18.93 300.69,19.06 300.81,19.06 300.81,19.06 303.6,19.06
GND on TOP (solid shape): 365.45,48.15 365.45,47 365.28,46.83 363.94,46.83 363.83,46.94 363.83,48.35 363.88,48.4 365.2,48.4
GND on TOP (solid shape): 394.55,20.89 394.55,20.18 394.24,19.88 392.63,19.88 392.29,20.22 392.29,20.72 392.48,20.91 393,20.91 393.2,21.11 394.33,21.11
GND on TOP (solid shape): 395.56,17.12 395.56,16.31 395.39,16.13 393.28,16.13 393,16.41 393,16.88 393.52,17.4 395.29,17.4
GND on TOP (solid shape): 164.4,89.04 164.4,88.3 164.28,88.18 162.19,88.18 162.09,88.27 162.09,90.13 162.22,90.25 163.19,90.25
GND on TOP (solid shape): 166.69,139.35 166.69,133.64 166.06,133 164.41,133 163.68,133.73 163.68,136.25 163.64,136.29 163.64,136.56 163.9,136.81 163.9,139.48 164.15,139.73 166.31,139.73
GND on TOP (solid shape): 179.07,91.32 179.07,87.98 179.06,87.96 179.06,87.12 178.89,86.96 177.98,86.96 177.75,87.19 177.75,91.44 177.8,91.48 178.9,91.48
GND on TOP (solid shape): 210.12,89.73 210.12,82.21 208.06,80.15 201.09,80.15 200.8,80.44 200.8,84.82 201.19,85.21 203.22,85.21 204.61,86.6 204.61,89.5 205.61,90.5 209.35,90.5
GND on TOP (solid shape): 266.52,94.02 266.52,93.64 266.06,93.18 266.06,92.24 265.88,92.06 264.64,92.06 264.49,92.22 264.49,93.69 264.67,93.87 264.79,93.87 265.07,94.15 266.39,94.15
GND on TOP (solid shape): 270.38,56.98 270.38,55.73 270.25,55.6 267.09,55.6 266.74,55.96 266.74,57.1 266.86,57.23 270.14,57.23
GND on TOP (solid shape): 340.57,11.33 340.57,10.39 340.38,10.2 335.01,10.2 334.77,10.44 334.77,11.39 334.87,11.49 340.41,11.49
GND on TOP (solid shape): 378.75,29.92 378.75,28.58 378.62,28.45 378.48,28.45 378.48,28.46 377.64,28.46 377.62,28.48 375.72,28.48 375.38,28.82 375.38,29.97 375.45,30.03 378.64,30.03
GND on TOP (solid shape): 393.01,30.88 393.01,29.86 392.88,29.73 391.16,29.73 390.99,29.9 390.16,29.9 390.15,29.9 389.42,29.9 389.2,30.11 389.2,31.26 389.33,31.38 392.5,31.38
GND on TOP (solid shape): 70.1,48.88 70.1,48.4 69.97,48.27 67.61,48.27 67.38,48.05 67.37,48.05 67.37,48.03 66.7,47.36 66.29,47.36 66,47.66 66,48.18 66.85,49.04 69.95,49.04
GND on TOP (solid shape): 188.54,91.72 188.54,90.42 188.4,90.28 185.71,90.28 185.56,90.13 185.56,88.79 185.52,88.75 184.87,88.75 184.79,88.82 184.79,91.83 184.91,91.94 188.33,91.94
GND on TOP (solid shape): 200.38,91.09 200.38,89.2 199.46,88.28 197.4,88.28 197.29,88.16 196.27,88.16 196.16,88.27 196.16,91.33 196.35,91.52 199.96,91.52
