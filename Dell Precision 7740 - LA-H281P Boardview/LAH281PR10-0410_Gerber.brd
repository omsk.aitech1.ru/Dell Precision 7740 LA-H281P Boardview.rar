# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_DP1_N0_C: length 2.9
  BOTTOM w0.109: CV861.1 60.69,53.15 59.81,53.15 59.25,52.59 58.86,52.59 58.79,52.52 UV66.5
GPU_DP1_N1: length 217.4
  TOP w0.102: v2(240.42,88.61) 240.18,88.37 239.78,88.37 239.36,87.95 239.18,87.95 JDGFF1.A2
  IN3 w0.089: v2(240.42,88.61) 240.67,88.36 240.79,88.36 240.87,88.43 240.87,91.99 240.4,92.45 234.39,92.45 234.2,92.27 232.18,92.27 231.28,93.16 231.28,93.72 230.38,94.63 185.26,94.63 179.29,100.59 157.68,100.59 155.19,98.1 155.19,96.56 152.31,93.68 146.57,93.68 145.87,94.38 143.33,94.38 142.9,93.94 138.25,93.94 137.36,93.06 134.85,93.06 134.34,92.55 129.76,92.55 128.77,91.56 128.77,91.27 128.06,90.56 127.12,90.56 125.9,89.34 121.61,89.34 121.24,88.97 119.55,88.97 116.11,85.53 115.22,85.53 111.54,81.84 110.8,81.84 109.18,80.22 108.23,80.22 97.94,69.93 97.94,68.18 96.92,67.16 93.7,67.16 89.61,63.07 89.61,59.45 88,57.84 85.15,57.84 84.36,57.05 70.29,57.05 69.56,56.32 65.61,56.32 65.28,55.99 65.28,54.85 65.38,54.75 65.64,54.75 65.74,54.85 v2(65.74,55.14)
  BOTTOM w0.109: CV863.2 61.56,51.81 62.12,51.81 62.25,51.94 64.18,51.94 65.63,53.4 65.63,55.03 v2(65.74,55.14)
GPU_DP1_N1_C: length 2.8
  BOTTOM w0.109: UV66.8 58.7,51.32 58.76,51.38 59.15,51.38 59.67,51.9 v3(60.06,51.9) 60.68,51.9 CV863.1
GPU_DP1_N2: length 198.8
  TOP w0.109: JDGFF1.G3 229.28,88.55 229.58,88.55 229.9,88.23 229.9,87.98 229.99,87.89 230.15,87.89 v2(230.32,88.07)
  IN3 w0.089: v2(230.32,88.07) 230.04,88.07 229.94,87.97 229.94,87.69 229.82,87.57 229.64,87.57 227.02,90.18 227.02,90.8 226.52,91.3 224.25,91.3 223.6,91.95 184.14,91.95 178.85,97.24 166.73,97.24 166.3,96.8 159.53,96.8 153.64,90.91 142.3,90.91 140.64,89.25 131.02,89.25 130.41,88.64 129.8,88.64 129.14,87.97 128.19,87.97 126.97,86.75 122.79,86.75 118.6,82.56 117.08,82.56 113.47,78.96 112.06,78.96 101.55,68.44 101.55,67.3 94.9,60.66 94.9,60.08 86.63,51.81 81.2,51.81 81.06,51.67 69.96,51.67 67.92,49.62 63.76,49.62 62.92,50.46 62.92,50.92 v2(63.28,51.28)
  BOTTOM w0.109: v2(63.28,51.28) 63.06,51.06 63.06,50.92 62.59,50.44 61.08,50.44 CV865.2
GPU_DP1_N2_C: length 2.2
  BOTTOM w0.109: UV66.11 58.74,50.12 58.81,50.19 v3(59.48,50.19) 59.72,50.19 60.02,50.49 60.18,50.49 CV865.1
GPU_DP1_N3: length 197.8
  TOP w0.109: JDGFF1.G6 229.26,90.37 229.39,90.37 229.6,90.58 229.75,90.58 v2(230.01,90.84)
  IN3 w0.089: v2(230.01,90.84) 229.76,90.59 229.48,90.59 229.15,90.93 229.15,91.95 227.7,93.4 184.74,93.4 179.5,98.64 165.78,98.64 165.47,98.33 159.92,98.33 159.44,98.81 157.82,98.81 156.45,97.45 156.45,95.77 153.13,92.45 141.75,92.45 139.95,90.65 130.44,90.65 129.83,90.03 129.22,90.03 128.56,89.37 127.62,89.37 126.39,88.15 122.17,88.15 121.37,87.34 119.66,87.34 112.88,80.56 111.59,80.56 99.95,68.91 99.95,67.78 88.64,56.48 85.75,56.48 84.82,55.55 80.35,55.55 78.7,53.9 68.95,53.9 67.38,52.34 66.61,52.34 65.68,51.41 65.53,51.41 v2(65.12,51.82)
  BOTTOM w0.109: v2(65.12,51.82) 65.35,51.59 65.5,51.59 65.8,51.29 65.8,50.22 65.05,49.48 62.4,49.48 CV867.2
GPU_DP1_N3_C: length 3.4
  BOTTOM w0.109: CV867.1 61.44,49.49 60.59,49.49 60.51,49.4 58.85,49.4 58.77,49.32 UV66.13
GPU_DP1_P0: length 197.2
  TOP w0.109: v2(230.76,91.11) 230.96,91.31 231.3,91.31 JDGFF1.F7
  IN3 w0.089: v2(230.76,91.11) 230.76,91.13 230.52,91.37 230.37,91.37 229.67,92.08 229.67,92.16 227.91,93.92 184.96,93.92 179.02,99.86 157.96,99.86 155.91,97.81 155.91,96.26 152.62,92.97 143.89,92.97 143.63,93.23 138.71,93.23 136.62,91.14 130.24,91.14 129.62,90.53 129.02,90.53 128.35,89.86 127.41,89.86 126.19,88.64 121.9,88.64 121.51,88.26 119.85,88.26 112.69,81.1 111.37,81.1 99.39,69.12 99.39,67.97 88.47,57.05 85.51,57.05 84.79,56.33 73.82,56.33 72.04,54.55 66.71,54.55 66.17,54.01 64.57,54.01 64.44,54.14 63.57,54.14 63.25,54.46 63.25,54.62 v2(62.97,54.9)
  BOTTOM w0.109: CV860.2 61.64,53.42 62.52,53.42 63.41,54.3 63.41,54.9 63.29,55.02 63.1,55.02 v2(62.97,54.9)
GPU_DP1_P0_C: length 2.9
  BOTTOM w0.109: UV66.4 58.79,52.92 58.86,52.85 59.14,52.85 59.7,53.41 v3(60.04,53.41) 60.67,53.41 CV860.1
GPU_DP1_P1: length 217.4
  TOP w0.102: v2(240.42,87.92) 240.23,88.11 239.89,88.11 239.47,87.7 239.19,87.7 JDGFF1.A1
  IN3 w0.089: v2(64.79,55.16) 65.08,55.44 65.08,56.07 65.53,56.53 69.48,56.53 70.2,57.25 84.28,57.25 85.07,58.04 87.91,58.04 89.41,59.54 89.41,63.15 93.61,67.36 96.84,67.36 97.74,68.26 97.74,70.01 108.14,80.42 109.09,80.42 110.72,82.05 111.45,82.05 115.13,85.73 116.02,85.73 119.47,89.17 121.15,89.17 121.52,89.54 125.82,89.54 127.04,90.76 127.98,90.76 128.57,91.35 128.57,91.64 129.67,92.75 134.25,92.75 134.76,93.26 137.28,93.26 138.17,94.15 142.81,94.15 143.25,94.58 145.95,94.58 146.65,93.88 152.22,93.88 154.99,96.64 154.99,98.19 157.6,100.8 179.38,100.8 185.34,94.83 230.46,94.83 231.49,93.81 231.49,93.25 232.26,92.47 234.12,92.47 234.31,92.66 240.49,92.66 241.07,92.07 241.07,88.35 240.87,88.15 240.65,88.15 v2(240.42,87.92)
  BOTTOM w0.109: v2(64.79,55.16) 65.03,54.92 65.26,54.92 65.37,54.8 65.37,53.51 64.07,52.2 62.14,52.2 62.01,52.07 61.72,52.07 CV862.2
GPU_DP1_P1_C: length 2.8
  BOTTOM w0.109: UV66.7 58.73,51.72 58.8,51.64 59.04,51.64 59.56,52.16 60.69,52.16 CV862.1
GPU_DP1_P2: length 198.8
  TOP w0.109: v2(230.32,87.36) 230.04,87.63 229.88,87.63 229.64,87.87 229.64,88.12 229.47,88.29 229.28,88.29 JDGFF1.G2
  IN3 w0.089: v2(230.32,87.36) 230.31,87.37 229.55,87.37 226.82,90.1 226.82,90.71 226.43,91.1 224.16,91.1 223.52,91.74 184.06,91.74 178.77,97.04 166.82,97.04 166.38,96.6 159.61,96.6 153.72,90.71 142.39,90.71 140.73,89.05 131.11,89.05 130.49,88.43 129.89,88.43 129.22,87.77 128.28,87.77 127.06,86.55 122.87,86.55 118.69,82.36 117.16,82.36 113.56,78.75 112.15,78.75 101.75,68.36 101.75,67.22 95.11,60.57 95.11,59.99 86.72,51.6 81.29,51.6 81.15,51.46 70.05,51.46 68,49.42 63.67,49.42 62.72,50.37 62.72,50.9 v2(62.36,51.26)
  BOTTOM w0.109: v2(62.36,51.26) 62.48,51.38 62.66,51.38 62.8,51.24 62.8,51.02 62.48,50.7 61.18,50.7 61.05,50.83 61.05,50.83 CV864.2
GPU_DP1_P2_C: length 2.2
  BOTTOM w0.109: CV864.1 60.17,50.75 59.91,50.75 59.61,50.45 58.82,50.45 58.75,50.52 UV66.10
GPU_DP1_P3: length 197.8
  TOP w0.109: JDGFF1.G5 229.3,90.11 229.5,90.11 229.71,90.32 229.82,90.32 v2(230.01,90.13)
  IN3 w0.089: v2(230.01,90.13) 229.75,90.39 229.4,90.39 228.94,90.85 228.94,91.86 227.61,93.19 184.66,93.19 179.42,98.43 165.87,98.43 165.55,98.12 159.84,98.12 159.35,98.61 157.9,98.61 156.65,97.36 156.65,95.69 153.21,92.24 141.84,92.24 140.04,90.44 130.53,90.44 129.91,89.83 129.31,89.83 128.64,89.16 127.7,89.16 126.48,87.94 122.26,87.94 121.45,87.14 119.75,87.14 112.97,80.36 111.68,80.36 100.15,68.83 100.15,67.7 88.73,56.28 85.83,56.28 84.91,55.35 80.43,55.35 78.78,53.7 69.03,53.7 67.47,52.14 66.7,52.14 65.77,51.21 65.36,51.21 v2(65.05,50.89)
  BOTTOM w0.109: CV866.2 62.4,49.74 64.94,49.74 65.53,50.33 65.53,51.18 65.39,51.33 64.9,51.33 64.75,51.17 64.75,50.99 64.84,50.89 v2(65.05,50.89)
GPU_DP1_P3_C: length 3.4
  BOTTOM w0.109: UV66.12 58.75,49.72 58.81,49.66 60.4,49.66 60.49,49.75 61.45,49.75 CV866.1
GPU_DP2_AUXN: length 218.5
  TOP w0.102: JDGFF1.A5 239.23,89.7 240.09,89.7 v2(240.26,89.87)
  TOP w0.109: v2(65.36,48.83) 65.59,48.6 65.78,48.6 67.29,50.11 67.62,50.11 CV943.1
  IN3 w0.089: v2(65.36,48.83) 65.6,48.59 65.87,48.59 66.09,48.82 67.39,48.82 67.93,48.29 67.93,41.87 69.16,40.64 86.96,40.64 92.53,46.2 92.53,51.47 97.53,56.48 97.53,56.82 112.58,71.87 112.58,72.88 114.72,75.02 116.09,75.02 117.31,76.24 117.94,76.24 119.64,77.93 122.46,77.93 125.59,81.06 126.49,81.06 126.81,81.38 126.81,82.32 127.38,82.9 128.06,82.9 128.64,83.48 130.42,83.48 131.04,84.1 136.85,84.1 137.51,83.44 139.37,83.44 139.8,83.87 140.87,83.87 142.51,85.51 144.25,85.51 144.38,85.38 151.12,85.38 151.6,85.87 165.24,85.87 168.32,88.94 173.45,88.94 174.78,90.27 179.11,90.27 181.12,88.27 183.68,88.27 184.16,87.78 196.96,87.78 197.66,87.09 218.52,87.09 219.93,85.67 224.96,85.67 225.9,84.74 229.13,84.74 229.73,85.33 237.53,85.33 238.59,86.39 238.59,88.7 239.5,89.61 240,89.61 v2(240.26,89.87)
GPU_DP2_AUXP: length 218.5
  TOP w0.102: JDGFF1.A4 239.14,89.45 239.99,89.45 v2(240.26,89.18)
  TOP w0.109: CV944.1 67.64,49.85 67.4,49.85 65.89,48.33 65.57,48.33 v2(65.36,48.12)
  IN3 w0.089: v2(65.36,48.12) 65.63,48.39 65.95,48.39 66.18,48.62 67.31,48.62 67.72,48.2 67.72,41.78 69.08,40.43 87.05,40.43 92.73,46.12 92.73,51.39 97.74,56.39 97.74,56.73 112.79,71.78 112.79,72.8 114.81,74.82 116.18,74.82 117.4,76.04 118.03,76.04 119.72,77.73 122.55,77.73 125.67,80.86 126.57,80.86 127.01,81.3 127.01,82.23 127.47,82.69 128.14,82.69 128.73,83.28 130.5,83.28 131.13,83.9 136.76,83.9 137.42,83.24 139.46,83.24 139.89,83.67 140.96,83.67 142.59,85.31 144.17,85.31 144.29,85.18 151.2,85.18 151.69,85.66 165.33,85.66 168.4,88.74 173.53,88.74 174.86,90.07 179.03,90.07 181.04,88.06 183.59,88.06 184.07,87.58 196.87,87.58 197.57,86.88 218.43,86.88 219.85,85.47 224.88,85.47 225.81,84.53 229.22,84.53 229.81,85.13 237.61,85.13 238.79,86.31 238.79,88.62 239.58,89.41 240.03,89.41 v2(240.26,89.18)
GPU_DP2_C_AUXN: length 3.1
  TOP w0.109: CV943.2 68.81,50.15 69.64,50.15 70.31,50.82 70.78,50.82 70.85,50.89 UV67.61
GPU_DP2_C_AUXP: length 3.1
  TOP w0.109: CV944.2 68.87,49.89 69.75,49.89 v3(70.06,50.2) 70.42,50.56 70.79,50.56 70.86,50.49 UV67.62
GPU_DP2_HPD: length 274.4
  TOP w0.109: UV67.16 77.87,47.21 77.8,47.13 77.8,44.92 77.9,44.82 77.9,44.21 77.75,44.06 77.75,42.71 RV897.1 77.85,42.61 v2(77.85,41.62)
  IN1 w0.102: v2(88.85,40.97) 87.4,40.97 86.75,41.62 v2(77.85,41.62)
  IN2 w0.081: v2(168.92,73.45) 168.48,73.45 166.14,75.78 162.5,75.78 162.17,76.11 156.45,76.11 156.13,75.8 152.9,75.8 150.48,78.22 146.68,78.22 144.38,80.52 134.63,80.52 v2(134.16,80.99)
  VCC w0.086: v2(282.23,76.77) 280.16,76.77 278.41,75.02 276.65,75.02 275.94,75.72 271.18,75.72 266.82,71.36 261.45,71.36 257.79,75.02 256.34,75.02 255.12,73.8 238.55,73.8 237.93,74.43 234.05,74.43 232.1,72.47 222.66,72.47 211.85,83.28 196.53,83.28 195.16,84.64 183.57,84.64 182.87,83.94 180.4,83.94 178.78,85.56 171.94,85.56 168.64,82.25 168.64,78.48 167.61,77.45 167.61,74.53 168.69,73.45 v2(168.92,73.45)
  IN3 w0.081: v2(134.16,80.99) 132.84,80.99 132.22,80.37 129.89,80.37 129.42,80.84 127.42,80.84 126.25,79.67 125.35,79.67 122.73,77.05 120.93,77.05 120.34,76.47 119.83,76.47 119.06,75.69 119.06,74.97 118.71,74.61 118.16,74.61 117.56,74.02 117.56,73.03 116.15,71.62 114.03,71.62 108.07,65.66 108.07,62.75 104.39,59.07 101.25,59.07 93.53,51.35 93.53,44.96 89.55,40.97 v2(88.85,40.97)
  BOTTOM w0.109: v2(282.23,76.77) 282.23,75.96 282.74,75.45 282.74,74.53 282.85,74.41 284.3,74.41 284.41,74.53 v1(285.28,74.53) 286.1,73.7 DV33.2 289.59,74.58 289.43,74.74 289.43,75.76 289.32,75.87 UV61.2
GPU_DP2_HPD_GATE: length 93.5
  TOP w0.109: v2(292.55,74.31) 291.83,74.31 291.06,75.08 290.78,75.08 289.43,76.43 289.43,78.52 290.65,79.74 290.65,80.74 289.72,81.67 289.72,83.77 291.8,85.85 291.8,92.37 292.48,93.06 292.48,93.74 291.13,95.09 239.57,95.09 239.26,94.78 233.33,94.78 232.44,93.89 228.35,93.89 228.19,93.73 JDGFF1.H10
  BOTTOM w0.109: UV61.4 291.68,76.52 v1(292.34,75.85) 292.55,75.64 v2(292.55,74.31)
GPU_DP2_N0: length 206.8
  TOP w0.102: JDGFF1.A8 239.16,91.57 240.08,91.57 v2(240.31,91.8)
  TOP w0.109: CV884.2 71.25,44.61 71.25,44.08 v2(71.56,43.78)
  IN3 w0.089: v2(240.31,91.8) 240.05,91.54 239.25,91.54 237.89,90.18 237.89,86.75 237.21,86.07 229.22,86.07 228.59,85.44 226.24,85.44 225.06,86.62 220.18,86.62 218.95,87.85 197.95,87.85 197.17,88.64 184.35,88.64 183.97,89.02 181.36,89.02 178.97,91.4 169.41,91.4 164.96,86.96 157.73,86.96 156.83,87.86 152,87.86 150.3,86.16 144.94,86.16 144.68,86.43 142.31,86.43 141.08,85.19 137.85,85.19 137.52,84.86 129.04,84.86 127.77,83.59 127.09,83.59 126.46,82.96 124.58,82.96 122.64,81.02 122.64,79.27 122.06,78.69 118.58,78.69 115.64,75.76 113.74,75.76 112.1,74.12 112.1,73.64 110.39,71.92 110.39,70.66 96.84,57.11 96.84,56.77 91.63,51.56 91.63,46.6 87.25,42.22 72.2,42.22 71.17,43.25 71.17,43.76 71.29,43.88 71.45,43.88 v2(71.56,43.78)
GPU_DP2_N0_C: length 4.1
  TOP w0.109: UV67.5 73.47,47.68 73.4,47.62 73.4,47.44 v3(72.78,46.81) 72.52,46.55 72.21,46.24 71.67,46.24 71.5,46.08 71.22,45.8 71.22,45.62 CV884.1
GPU_DP2_N1: length 190.6
  TOP w0.109: v2(224.61,90.41) 224.61,90.2 224.49,90.09 224.26,90.09 224.15,89.98 224.15,89.79 225.53,88.41 226.79,88.41 227.07,88.13 227.52,88.13 227.75,87.9 227.97,87.9 JDGFF1.H2 ; v2(73.67,43.77) 73.44,44 73.44,45.02 CV886.2
  IN3 w0.089: v2(73.67,43.77) 73.34,44.09 73.34,44.69 74.77,46.11 81.62,46.11 82.13,45.6 87.24,45.6 89.23,47.59 89.23,53.12 95.81,59.7 95.81,60.28 102.64,67.12 102.64,68.21 112.25,77.82 113.64,77.82 117.27,81.45 118.8,81.45 123.2,85.85 127.35,85.85 128.57,87.07 129.51,87.07 130.18,87.73 130.78,87.73 131.32,88.27 132.43,88.27 133.14,87.57 136.86,87.57 137.11,87.82 140.57,87.82 142.68,89.93 154.92,89.93 158.23,93.24 158.23,94.19 159.94,95.9 168.09,95.9 168.41,95.58 170.25,95.58 170.84,96.17 178.59,96.17 183.85,90.91 185.06,90.91 185.36,90.61 195.6,90.61 196.04,91.05 222.45,91.05 223.75,89.74 224.2,89.74 224.35,89.89 224.35,90.15 v2(224.61,90.41)
GPU_DP2_N1_C: length 2.9
  TOP w0.109: UV67.8 74.67,47.69 74.6,47.62 74.6,47.24 74.13,46.77 v3(74.13,46.77) 73.44,46.07 73.44,45.94 73.61,45.77 CV886.1
GPU_DP2_N2: length 189.8
  TOP w0.109: v2(74.93,44.56) 74.67,44.83 74.67,44.98 CV888.2 ; JDGFF1.H5 227.79,89.92 227.72,89.85 227.72,89.67 227.62,89.58 227.04,89.58 226.81,89.35 226.15,89.35 225.63,89.87 225.63,90.1 225.74,90.21 225.91,90.21 225.98,90.28 v2(225.98,90.52)
  IN3 w0.089: v2(225.98,90.52) 225.73,90.27 225.73,89.37 225.18,88.83 223.68,88.83 222.16,90.35 196.38,90.35 195.91,89.87 185.06,89.87 184.72,90.21 183.55,90.21 178.37,95.39 173.3,95.39 172.03,94.12 168.6,94.12 167.52,95.2 160.28,95.2 159.03,93.94 159.03,92.88 155.26,89.11 142.94,89.11 140.96,87.12 137.53,87.12 137.27,86.87 132.32,86.87 132.16,87.04 130.47,87.04 129.49,86.06 128.55,86.06 127.64,85.15 123.66,85.15 121.16,82.65 121.16,81.93 119.94,80.71 117.58,80.71 116.85,79.98 116.85,79.14 116.02,78.31 115.18,78.31 113.89,77.03 113.1,77.03 109.85,73.78 109.48,73.78 107.31,71.61 107.31,70.69 106.23,69.61 105.03,69.61 103.34,67.92 103.34,66.83 96.51,59.99 96.51,59.41 90.04,52.95 90.04,46.98 87.82,44.76 81.56,44.76 81.02,45.3 74.99,45.3 74.77,45.07 74.77,44.73 v2(74.93,44.56)
GPU_DP2_N2_C: length 3.2
  TOP w0.109: CV888.1 74.69,45.96 74.69,46.24 74.81,46.36 75.25,46.36 75.37,46.49 v3(75.51,46.62) 75.8,46.92 75.8,47.43 75.87,47.5 UV67.11
GPU_DP2_N3: length 198.5
  TOP w0.102: v2(237.12,90.7) 237.39,90.43 237.49,90.43 237.57,90.35 237.7,90.35 237.87,90.52 JDGFF1.B6
  TOP w0.109: v2(76.27,43.87) 75.96,44.18 75.96,45 CV890.2
  IN3 w0.089: v2(237.12,90.7) 236.89,90.47 236.55,90.47 235.96,89.89 235.96,88.81 234.5,87.34 233.08,87.34 232.77,87.64 231.45,87.64 230.59,86.78 229.43,86.78 228.05,88.17 223.76,88.17 223.16,87.56 220.34,87.56 219.18,88.72 198.31,88.72 197.68,89.35 184.76,89.35 184.4,89.72 182.52,89.72 181.87,90.36 181.87,90.95 180.58,92.24 179.33,92.24 177.95,93.63 167.36,93.63 163.96,90.22 160.61,90.22 158.97,88.58 146.55,88.58 145.1,87.14 141.95,87.14 141.42,86.6 137.76,86.6 136.71,85.56 128.75,85.56 127.84,84.65 123.9,84.65 121.93,82.69 121.93,79.88 121.52,79.47 118.32,79.47 116.33,77.48 115.05,77.48 114.1,76.53 113.49,76.53 110.11,73.15 109.6,73.15 107.88,71.43 107.88,69.14 96.14,57.4 96.14,57.06 90.89,51.81 90.89,46.93 86.88,42.92 76.06,42.92 75.88,43.1 75.88,43.85 76,43.98 76.17,43.98 v2(76.27,43.87)
GPU_DP2_N3_C: length 2.7
  TOP w0.109: UV67.13 76.67,47.79 76.6,47.71 76.6,46.77 75.96,46.13 75.96,45.96 CV890.1
GPU_DP2_P0: length 206.8
  TOP w0.102: v2(240.31,91.11) 240.1,91.32 239.21,91.32 JDGFF1.A7
  TOP w0.109: CV883.2 70.99,44.63 70.99,44.08 v2(70.69,43.78)
  IN3 w0.089: v2(240.31,91.11) 240.08,91.34 239.34,91.34 238.09,90.1 238.09,86.67 237.29,85.87 229.31,85.87 228.67,85.23 226.16,85.23 224.97,86.42 220.09,86.42 218.86,87.64 197.87,87.64 197.08,88.43 184.26,88.43 183.88,88.81 181.28,88.81 178.89,91.2 169.49,91.2 165.05,86.76 157.65,86.76 156.75,87.66 152.09,87.66 150.39,85.96 144.86,85.96 144.59,86.22 142.4,86.22 141.17,84.99 137.93,84.99 137.6,84.66 129.12,84.66 127.85,83.39 127.18,83.39 126.54,82.76 124.66,82.76 122.84,80.94 122.84,79.19 122.14,78.49 118.66,78.49 115.73,75.55 113.82,75.55 112.3,74.04 112.3,73.55 110.59,71.84 110.59,70.58 97.04,57.02 97.04,56.68 91.83,51.47 91.83,46.51 87.34,42.02 72.12,42.02 70.97,43.17 70.97,43.5 v2(70.69,43.78)
GPU_DP2_P0_C: length 4.1
  TOP w0.109: CV883.1 70.96,45.54 70.96,45.91 v3(71.31,46.26) 71.56,46.5 72.1,46.5 73.14,47.55 73.14,47.66 73.07,47.73 UV67.4
GPU_DP2_P1: length 190.6
  TOP w0.109: CV885.2 73.18,44.99 73.18,43.99 v2(72.96,43.77) ; v2(223.89,90.41) 223.89,89.68 225.43,88.15 226.69,88.15 226.97,87.87 227.41,87.87 227.64,87.64 227.91,87.64 JDGFF1.H1
  IN3 w0.089: v2(223.89,90.41) 224.14,90.16 224.14,89.97 224.12,89.94 223.83,89.94 222.53,91.25 195.95,91.25 195.52,90.81 185.45,90.81 185.15,91.11 183.93,91.11 178.67,96.37 170.75,96.37 170.17,95.79 168.5,95.79 168.18,96.1 159.86,96.1 158.02,94.27 158.02,93.32 154.84,90.13 142.59,90.13 140.48,88.03 137.03,88.03 136.78,87.77 133.22,87.77 132.52,88.48 131.24,88.48 130.7,87.94 130.09,87.94 129.43,87.27 128.48,87.27 127.26,86.05 123.11,86.05 118.71,81.65 117.19,81.65 113.56,78.02 112.16,78.02 102.44,68.29 102.44,67.2 95.6,60.37 95.6,59.79 89.02,53.21 89.02,47.68 87.15,45.81 82.21,45.81 81.7,46.32 74.68,46.32 73.14,44.78 73.14,43.95 v2(72.96,43.77)
GPU_DP2_P1_C: length 3
  TOP w0.109: CV885.1 73.18,45.98 73.17,46.13 73.17,46.18 74.27,47.28 74.34,47.35 74.34,47.67 74.27,47.74 UV67.7
GPU_DP2_P2: length 189.9
  TOP w0.109: v2(225.26,90.52) 225.36,90.42 225.36,89.76 226.04,89.09 226.91,89.09 227.15,89.32 JDGFF1.H4 ; CV887.2 74.4,45.03 74.4,44.75 v2(74.22,44.56)
  IN3 w0.089: v2(225.26,90.52) 225.53,90.25 225.53,89.46 225.1,89.03 223.76,89.03 222.24,90.55 196.3,90.55 195.82,90.07 185.14,90.07 184.8,90.41 183.64,90.41 178.45,95.6 173.22,95.6 171.95,94.33 168.69,94.33 167.61,95.4 160.2,95.4 158.82,94.03 158.82,92.96 155.17,89.31 142.85,89.31 140.87,87.33 137.44,87.33 137.19,87.07 132.41,87.07 132.24,87.24 130.38,87.24 129.4,86.26 128.46,86.26 127.55,85.35 123.57,85.35 120.95,82.73 120.95,82.01 119.85,80.91 117.49,80.91 116.65,80.07 116.65,79.22 115.94,78.51 115.09,78.51 113.81,77.23 113.02,77.23 109.77,73.98 109.4,73.98 107.11,71.69 107.11,70.77 106.15,69.81 104.95,69.81 103.13,68 103.13,66.91 96.3,60.08 96.3,59.5 89.84,53.03 89.84,47.06 87.74,44.96 81.64,44.96 81.1,45.5 74.9,45.5 74.56,45.16 74.56,44.91 v2(74.22,44.56)
GPU_DP2_P2_C: length 3.2
  TOP w0.109: CV887.1 74.43,45.96 74.43,46.35 74.7,46.62 75.14,46.62 75.54,47.03 75.54,47.43 75.47,47.5 UV67.10
GPU_DP2_P3: length 198.4
  TOP w0.102: JDGFF1.B5 237.91,89.92 237.73,90.1 237.46,90.1 237.39,90.17 237.28,90.17 v2(237.12,90.01)
  TOP w0.109: v2(75.4,43.87) 75.7,44.17 75.7,45 CV889.2
  IN3 w0.089: v2(237.12,90.01) 236.86,90.27 236.63,90.27 236.17,89.8 236.17,88.72 234.58,87.14 232.99,87.14 232.69,87.44 231.54,87.44 230.68,86.58 229.35,86.58 227.97,87.96 223.85,87.96 223.24,87.36 220.26,87.36 219.1,88.52 198.23,88.52 197.6,89.15 184.68,89.15 184.31,89.51 182.43,89.51 181.67,90.27 181.67,90.86 180.49,92.04 179.25,92.04 177.86,93.42 167.45,93.42 164.04,90.02 160.69,90.02 159.05,88.38 146.63,88.38 145.18,86.93 142.03,86.93 141.5,86.4 137.84,86.4 136.8,85.36 128.84,85.36 127.93,84.45 123.98,84.45 122.13,82.6 122.13,79.8 121.6,79.26 118.4,79.26 116.42,77.28 115.13,77.28 114.18,76.33 113.57,76.33 110.2,72.95 109.68,72.95 108.08,71.35 108.08,69.05 96.34,57.31 96.34,56.97 91.09,51.73 91.09,46.85 86.97,42.72 75.97,42.72 75.67,43.02 75.67,43.6 v2(75.4,43.87)
GPU_DP2_P3_C: length 2.7
  TOP w0.109: UV67.12 76.27,47.82 76.33,47.76 76.33,46.87 75.7,46.24 75.7,45.96 CV889.1
GPU_EDP_AUXN: length 95.4
  TOP w0.109: JDGFF1.B9 237.89,92.32 237.74,92.17 237.66,92.17 237.5,92.32 237.5,93.6 237.27,93.83 237.05,93.83 v2(236.82,94.06) ; v2(164.81,120.89) 164.81,121.11 164.93,121.24 165.15,121.24 165.26,121.35 165.26,121.52 165,121.78 163.83,121.78 CV828.1
  IN4 w0.102: v2(236.82,94.06) 236.61,93.85 236.46,93.85 235.3,95.01 231.1,95.01 230.93,94.85 185.18,94.85 169.82,110.2 169.82,118.52 166.53,121.81 165.13,121.81 164.89,121.57 164.89,121.08 v2(164.81,120.89)
GPU_EDP_AUXN_C: length 3.5
  TOP w0.109: CV828.2 162.47,121.63 161.94,121.63 160.94,120.62 160.67,120.62 160.6,120.55 UV64.29
GPU_EDP_AUXP: length 95.3
  TOP w0.109: JDGFF1.B8 237.96,91.72 237.77,91.91 237.55,91.91 237.24,92.22 237.24,93.49 237.16,93.57 236.97,93.57 v2(236.82,93.41) ; CV827.1 163.53,122.04 165.11,122.04 165.52,121.63 v2(165.52,120.89)
  IN4 w0.102: v2(236.82,93.41) 236.59,93.64 236.37,93.64 235.21,94.8 231.19,94.8 231.02,94.63 185.09,94.63 169.6,110.11 169.6,118.43 166.44,121.59 165.22,121.59 165.11,121.48 165.11,121.28 165.19,121.2 165.44,121.2 165.52,121.11 v2(165.52,120.89)
GPU_EDP_AUXP_C: length 3.5
  TOP w0.109: UV64.30 160.6,120.95 160.67,120.88 160.83,120.88 v3(161.35,121.41) 161.83,121.89 162.47,121.89 CV827.2
GPU_EDP_HPD: length 100.1
  TOP w0.109: UV64.13 156.42,115.07 156.56,114.92 156.56,112.57 155.98,111.98 v2(155.98,111.24) ; JDGFF1.E1 232.41,87.16 v2(232.21,86.96)
  VCC w0.086: v2(232.21,86.96) 231.73,86.48 230.61,86.48 228.98,88.11 228.98,89.89 227.12,91.74 225.07,91.74 223.83,92.97 184.22,92.97 178.91,98.28 167.56,98.28 164.39,101.45 164.39,109.72 162.44,111.66 159.63,111.66 159.21,111.24 v2(155.98,111.24)
  BOTTOM w0.109: v1(232,86.27) 232,86.75 v2(232.21,86.96)
GPU_EDP_N0: length 88.3
  TOP w0.109: v2(229.88,93.35) 230.05,93.17 230.05,93.04 229.86,92.84 229.86,92.32 229.71,92.18 229.25,92.18 JDGFF1.G9 ; CV820.1 155.74,112.8 155.74,111.96 155.51,111.73 155.51,110.35 v2(155.73,110.12)
  IN4 w0.102: v2(155.73,110.12) 155.73,109.88 155.65,109.79 155.4,109.79 155.32,109.71 155.32,109.56 157.34,107.55 170.14,107.55 184.34,93.35 227.87,93.35 228.35,92.87 229.89,92.87 230.05,93.03 230.05,93.17 v2(229.88,93.35)
GPU_EDP_N0_C: length 3.2
  TOP w0.109: CV820.2 155.78,113.97 155.78,114.62 155.95,114.79 155.95,116.15 156.02,116.22 UV64.12
GPU_EDP_N1: length 102.7
  TOP w0.109: JDGFF1.B3 237.92,88.55 237.59,88.55 237.27,88.23 237.27,87.86 237.15,87.74 237.03,87.74 v2(236.84,87.93) ; v2(158.38,104.7) 158.46,104.78 158.94,104.78 159.25,105.08 159.25,106.73 157.36,108.61 157.36,110.61 CV822.1
  IN4 w0.102: v2(236.84,87.93) 236.71,87.8 235.77,87.8 233.99,86.02 232.64,86.02 231.86,86.79 230.18,86.79 229.31,87.67 229.31,90.24 228.29,91.25 224.56,91.25 223.88,91.94 183.41,91.94 175.04,100.31 170.7,100.31 167,104 163.59,104 161.09,106.5 157.39,106.5 157.05,106.16 157.05,105.42 157.53,104.94 158.14,104.94 v2(158.38,104.7)
GPU_EDP_N1_C: length 5.5
  TOP w0.109: UV64.15 157.22,116.19 157.15,116.13 v3(157.15,115.34) 157.15,114.49 157.29,114.35 157.29,111.7 CV822.2
GPU_EDP_N2: length 92.2
  TOP w0.109: v2(236.78,92.05) 236.53,91.8 236.31,91.8 236.06,91.56 235.87,91.56 JDGFF1.C8 ; v2(158.93,109.88) 158.63,110.19 158.63,110.58 158.81,110.75 158.81,111.81 158.63,111.98 158.63,112.89 CV824.1
  IN4 w0.102: v2(158.93,109.88) 158.67,109.88 158.56,109.78 158.56,109.06 159.25,108.38 170.43,108.38 184.7,94.1 231.18,94.1 231.49,93.79 231.49,93.23 232.2,92.53 235.07,92.53 235.92,91.68 236.39,91.68 236.5,91.8 236.5,91.96 236.59,92.05 v2(236.78,92.05)
GPU_EDP_N2_C: length 3.5
  TOP w0.109: CV824.2 158.63,114.16 158.63,114.93 158.37,115.19 158.01,115.19 157.95,115.25 157.95,116.14 158.02,116.21 UV64.17
GPU_EDP_N3: length 92.6
  TOP w0.109: JDGFF1.C5 235.92,89.71 236.13,89.71 236.57,89.27 236.75,89.27 v2(236.9,89.42) ; CV826.1 160.12,110.65 160.12,109.62 164.46,105.28 164.98,105.28 165.07,105.37 165.07,105.65 165.16,105.74 v2(165.43,105.74)
  IN4 w0.102: v2(236.9,89.42) 236.67,89.18 236.07,89.18 234.24,87.35 232.97,87.35 231.51,88.81 231.51,92.17 231.2,92.48 230.49,92.48 230.15,92.14 224.84,92.14 224.42,92.56 183.93,92.56 171.65,104.84 168.93,104.84 168.34,105.44 165.73,105.44 v2(165.43,105.74)
GPU_EDP_N3_C: length 5.7
  TOP w0.109: UV64.20 159.22,116.19 159.15,116.12 159.15,115.67 160.12,114.7 v3(160.12,113.63) 160.12,111.83 CV826.2
GPU_EDP_P0: length 88.3
  TOP w0.109: v2(230.38,92.84) 230.22,92.84 230.12,92.74 230.12,92.21 229.82,91.92 229.31,91.92 JDGFF1.G8 ; CV819.1 155.48,112.8 155.48,112.07 155.25,111.84 155.25,110.35 v2(155.02,110.12)
  IN4 w0.102: v2(155.02,110.12) 155.11,109.94 155.11,109.48 157.25,107.33 170.05,107.33 184.25,93.13 227.78,93.13 228.26,92.65 229.98,92.65 230.17,92.84 v2(230.38,92.84)
GPU_EDP_P0_C: length 3.2
  TOP w0.109: UV64.11 155.62,116.19 155.69,116.12 v3(155.69,115.45) 155.69,114.9 155.51,114.73 155.51,114.04 CV819.2
GPU_EDP_P1: length 102.7
  TOP w0.109: v2(158.22,105.57) 158.46,105.57 158.55,105.47 158.55,105.23 158.73,105.05 158.84,105.05 158.99,105.19 158.99,106.62 157.1,108.5 157.1,110.41 CV821.1 ; JDGFF1.B2 237.92,88.29 237.7,88.29 237.54,88.12 237.54,87.75 237.26,87.48 237.07,87.48 v2(236.84,87.24)
  IN4 w0.102: v2(158.22,105.57) 158.37,105.57 158.45,105.49 158.45,105.32 158.29,105.16 157.62,105.16 157.26,105.51 157.26,106.07 157.48,106.29 161,106.29 163.5,103.79 166.91,103.79 170.61,100.09 174.95,100.09 183.32,91.72 223.79,91.72 224.47,91.04 228.2,91.04 229.09,90.15 229.09,87.58 230.1,86.58 231.78,86.58 232.55,85.8 234.08,85.8 235.86,87.58 236.5,87.58 v2(236.84,87.24)
GPU_EDP_P1_C: length 5.5
  TOP w0.109: CV821.2 157.03,111.74 v3(157.03,113.6) 157.03,114.24 156.89,114.38 156.89,116.12 156.82,116.19 UV64.14
GPU_EDP_P2: length 92.2
  TOP w0.109: v2(158.07,109.88) 158.37,110.19 158.37,110.69 158.54,110.86 v3(158.54,111.33) 158.54,111.7 158.37,111.87 158.37,112.89 CV823.1 ; JDGFF1.C7 235.89,91.3 236.17,91.3 236.41,91.54 236.61,91.54 v2(236.8,91.36)
  IN4 w0.102: v2(236.8,91.36) 236.69,91.46 235.83,91.46 234.98,92.31 232.11,92.31 231.28,93.14 231.28,93.7 231.1,93.89 184.61,93.89 170.34,108.16 159.16,108.16 158.35,108.97 158.35,109.6 v2(158.07,109.88)
GPU_EDP_P2_C: length 3.5
  TOP w0.109: UV64.16 157.62,116.21 157.69,116.14 157.69,115.14 157.9,114.93 158.26,114.93 158.37,114.82 158.37,114.16 CV823.2
GPU_EDP_P3: length 92.7
  TOP w0.109: JDGFF1.C4 235.84,89.45 236.02,89.45 236.47,89.01 236.63,89.01 v2(236.9,88.73) ; CV825.1 159.86,110.62 159.86,109.52 164.36,105.02 165.42,105.02 v2(165.43,105.02)
  IN4 w0.102: v2(236.9,88.73) 236.67,88.97 236.16,88.97 234.33,87.14 232.88,87.14 231.3,88.72 231.3,92.08 231.11,92.27 230.58,92.27 230.24,91.93 224.75,91.93 224.33,92.34 183.84,92.34 171.56,104.63 168.84,104.63 168.25,105.22 165.62,105.22 v2(165.43,105.02)
GPU_EDP_P3_C: length 5.7
  TOP w0.109: UV64.19 158.82,116.19 158.89,116.13 158.89,115.56 v3(159.26,115.19) 159.86,114.59 159.86,111.86 CV825.2
GPU_EVENT#: length 148.5
  TOP w0.109: UH1.BE9 123.8,44.29 123.29,44.29 123.08,44.07 121.99,44.07 121.98,44.06 121.65,44.06 v2(121.59,44.13)
  VCC w0.086: v2(162.61,65.16) 163.56,66.11 163.56,66.87 165.66,68.96 165.66,78.01 166.84,79.19 166.84,80.92 166.41,81.34 166.41,85.1 168.9,87.59 174.72,87.59 175.64,88.51 177.81,88.51 178.35,87.98 179.07,87.98 180.25,86.8 180.25,86.53 181.12,85.66 182.15,85.66 182.95,86.46 196.34,86.46 197.32,85.48 212.86,85.48 219.77,78.56 224.22,78.56 v2(224.83,79.17)
  IN3 w0.081: v2(162.61,65.16) 162.28,65.16 160.93,63.8 159.91,63.8 155.34,59.22 152.89,59.22 150.71,57.04 148.81,57.04 148.23,56.45 147.14,56.45 145.07,54.39 143.58,54.39 142.01,52.82 139.24,52.82 138.95,53.11 136.41,53.11 134.35,51.06 134.35,49.99 132.32,47.95 130.32,47.95 129.98,47.62 126.34,47.62 126.12,47.4 126.12,46.2 125.03,45.11 124.06,45.11 123.01,44.06 121.65,44.06 v2(121.59,44.13)
  BOTTOM w0.109: DV44.1 v1(229.64,83.07) 228.72,83.07 224.82,79.18 v2(224.83,79.17)
GPU_GC6_FB_EN: length 161.6
  TOP w0.102: UH1.BF9 123.15,44.52 122.96,44.32 122.38,44.32 122.11,44.59 v2(121.93,44.59)
  TOP w0.109: RV485.2 243.29,84.34 237.57,84.34 237.28,84.06 235.46,84.06 234.64,83.24 233.59,83.24 233.15,83.68 v2(233.15,83.91)
  VCC w0.086: v2(224.19,79.19) 223.9,78.9 219.78,78.9 212.96,85.72 197.49,85.72 196.5,86.71 182.85,86.71 182.05,85.91 181.22,85.91 180.49,86.63 180.49,86.9 179.17,88.22 178.46,88.22 177.92,88.76 175.52,88.76 174.61,87.85 168.79,87.85 166.16,85.22 166.16,81.24 166.59,80.81 166.59,79.29 165.4,78.1 165.4,69.07 163.04,66.71 163.04,66.01 162.82,65.8 v2(162.6,65.8)
  IN3 w0.081: v2(121.93,44.59) 121.94,44.58 123,44.58 123.88,45.47 125.12,45.47 125.87,46.22 125.87,47.66 126.11,47.9 129.99,47.9 130.3,48.21 132.33,48.21 134.18,50.06 134.18,51.2 136.29,53.3 139,53.3 139.31,52.99 141.86,52.99 143.49,54.62 144.98,54.62 147.04,56.68 148.16,56.68 148.75,57.27 150.61,57.27 152.8,59.45 155.24,59.45 159.8,64.01 160.8,64.01 v2(162.6,65.8)
  BOTTOM w0.109: v2(224.19,79.19) 224.37,79.36 224.37,79.54 v1(228.2,83.38) 228.74,83.91 v2(233.15,83.91)
GPU_GC6_FB_EN_R: length 12.4
  TOP w0.109: RV485.1 246.24,85.46 246.91,85.46 v2(247.62,86.17) ; JDGFF2.F10 246.49,93.52 v2(246.53,93.56)
  IN4 w0.102: v2(246.53,93.56) 246.53,92.36 246.94,91.96 246.94,89.54 247.45,89.02 247.45,86.34 v2(247.62,86.17)
GPU_PWR_LEVEL: length 251.1
  TOP w0.109: v2(125.63,61.1) 125.63,61.28 125.04,61.86 123.58,61.86 121.69,63.76 120.81,63.76 120.47,64.1 120.47,65.19 119.13,66.53 116.37,66.53 116.17,66.33 115.37,66.33 v1(114.88,66.82) 114.64,67.06 RE557.1 ; UE1.E12 v2(142.01,76.42)
  IN2 w0.081: v2(125.63,61.1) 125.63,60.46 124.78,59.61 124.78,58.55 125.54,57.79 132.4,57.79 132.81,58.21 132.81,59.58 132.56,59.83 132.56,60.37 133.76,61.56 137.2,61.56 138.29,60.47 141.89,60.47 142.99,59.37 148.73,59.37 150.33,57.77 150.61,57.77 152.73,55.66 153.86,55.66 v2(154.79,54.73)
  VCC w0.086: v2(154.79,54.73) 154.79,56.43 159.19,60.84 159.19,62.87 160.98,64.66 163.07,64.66 163.8,65.4 163.8,66.73 165.91,68.83 165.91,77.91 167.08,79.08 167.08,81.02 166.66,81.44 166.66,84.98 169.02,87.34 174.82,87.34 175.75,88.26 177.71,88.26 178.25,87.73 178.91,87.73 180,86.64 180,86.43 181.01,85.41 182.25,85.41 183.05,86.21 196.23,86.21 197.27,85.18 212.8,85.18 219.67,78.32 224.95,78.32 226.3,79.67 229.53,79.67 233.22,75.98 238.53,75.98 239.24,75.28 254.51,75.28 256.18,76.95 257.95,76.95 258.53,76.37 259.46,76.37 260.07,76.98 260.07,77.45 261.32,78.7 265.37,78.7 267.07,76.99 274.51,76.99 277.57,80.05 278.58,80.05 v2(279.06,80.53)
  IN3 w0.102: v2(142.01,76.42) 142.75,75.69 142.75,74.82 145.34,72.23 145.34,68.55 143.85,67.07 143.85,66.62 141.42,64.19 141.42,63.45 141.08,63.11 139.63,63.11 138.92,62.4 134.64,62.4 134.11,61.86 133.42,61.86 132.12,60.57 127.28,60.57 126.75,61.1 v2(125.63,61.1)
  BOTTOM w0.109: UV60.2 279.06,80.14 v2(279.06,80.53)
GPU_SMBCLK_R: length 31.8
  TOP w0.109: JDGFF2.C1 250.45,87.26 250.45,86.48 250.72,86.21 251.78,86.21 v2(252.27,85.71)
  IN3 w0.081: v2(273.89,86.2) 273.64,85.96 271.13,85.96 270.6,85.43 268.41,85.43 267.84,84.85 253.13,84.85 v2(252.27,85.71)
  BOTTOM w0.109: QV30.4 275.2,82.1 RV804.2 275.78,83.02 274.94,83.86 v1(274.94,84.27) 274.94,85.14 v2(273.89,86.2)
GPU_SMBDAT_R: length 44.1
  TOP w0.109: JDGFF2.C2 250.82,88.12 251.26,87.68 251.26,87.29 250.99,87.02 v2(250.99,86.73)
  VCC w0.086: v2(271.29,90.27) 271.13,90.44 269.63,90.44 268.81,89.61 268.81,86.57 268.07,85.83 253.97,85.83 253.73,86.08 253.73,86.85 253.22,87.35 251.61,87.35 v2(250.99,86.73)
  BOTTOM w0.109: v2(271.29,90.27) 270.98,89.97 270.98,84.15 v1(273.04,82.1) 274.8,80.33 276.82,80.33 277.24,79.92 277.24,79.03 RV805.2 276.5,78.97 QV30.1
GPU_SMCLK: length 173.5
  TOP w0.109: v2(136.04,82.93) 136.04,83.13 v1(136.51,83.61) 136.51,84.29 RE730.1 ; UE1.F7 v2(137.27,75.62)
  IN1 w0.102: v2(136.04,82.93) 136.04,82.76 136.42,82.37 136.42,79.67 136.05,79.3 136.05,76.16 136.2,76.02 136.72,76.02 137.11,75.62 v2(137.27,75.62)
  IN2 w0.081: v2(136.04,82.93) 136.04,82.75 136.33,82.46 136.33,81.76 137.02,81.07 144.66,81.07 146.92,78.81 150.72,78.81 153.14,76.38 155.89,76.38 156.21,76.7 162.56,76.7 v2(162.75,76.89)
  VCC w0.086: v2(162.75,76.89) 163.13,77.27 163.13,85.53 167.41,89.8 167.41,90.4 168.93,91.92 180.26,91.92 181.45,90.74 181.45,90.15 182.69,88.9 197.62,88.9 198.14,88.38 216.47,88.38 222.19,82.66 230.89,82.66 234.59,78.96 239.58,78.96 241.15,77.39 253.59,77.39 255.97,79.76 271.51,79.76 272.62,78.65 274.41,78.65 v2(274.62,78.86)
  BOTTOM w0.109: QV30.3 275.2,79.21 274.85,78.86 v2(274.62,78.86)
GPU_SMDAT: length 173.7
  TOP w0.109: RE731.1 137.04,83.5 136.6,83.06 136.6,82.83 ; UE1.B6 136.45,78.84 136.45,80.28 136.85,80.68 136.85,82.58 136.6,82.83 ; v2(136.61,82.83) 136.6,82.83
  IN2 w0.081: v2(136.61,82.83) 136.9,82.54 136.9,81.69 137.17,81.42 144.81,81.42 147.07,79.16 150.87,79.16 152.64,77.38 156,77.38 156.28,77.1 161.08,77.1 v2(161.32,77.34)
  VCC w0.086: v2(277.38,80.72) 276.84,80.18 272.62,80.18 271.6,81.2 264.15,81.2 263.55,80.59 255.68,80.59 253.15,78.07 241.36,78.07 239.57,79.86 235.3,79.86 231.8,83.36 222.95,83.36 216.08,90.24 195.98,90.24 195.33,89.59 185.14,89.59 184.87,89.86 182.64,89.86 182.05,90.46 182.05,90.96 180.39,92.62 177.43,92.62 176.98,93.07 169.29,93.07 168.71,93.64 167.69,93.64 166.42,92.37 166.42,89.91 162.29,85.78 162.29,79.78 161.11,78.6 161.11,77.55 v2(161.32,77.34)
  BOTTOM w0.109: QV30.6 276.5,80.94 276.63,80.81 277.29,80.81 v2(277.38,80.72)
GT_SW1: length 2
  BOTTOM w0.109: v2(284.17,13.98) v1(283.46,13.98)
  BOTTOM w0.508: PC1709.1 284.68,13.27 284.17,13.78 v2(284.17,13.98)
H_CATERR#: length 11.7
  TOP w0.109: RC79.2 258.42,23.03 v2(258.42,23.83) ; v2(253.16,29.63) 253.05,29.63 UC1.BM30
  BOTTOM w0.109: v2(253.16,29.63) 254.16,29.63 254.55,30.01 255.65,30.01 v1(256.77,28.89) 257.33,28.34 257.33,27.74 258.57,26.5 258.57,23.98 v2(258.42,23.83)
H_PECI: length 195.8
  TOP w0.109: RH73.2 131.71,58.22 v2(131.49,58.44) ; v1(148.28,60.17) 147.99,60.47 v2(147.77,60.47) ; RE60.2 146.9,70.94 v2(147.32,71.36) ; v2(255.21,26.55) 255.21,27.16 UC1.BT34
  IN1 w0.102: v2(147.77,60.47) 147.9,60.59 147.9,60.95 151.23,64.28 151.23,67.45 v2(147.32,71.36)
  IN2 w0.081: v2(255.21,26.55) 255.85,25.91 255.85,25.16 255.65,24.96 255.65,21.45 255.15,20.96 253.35,20.96 252.7,21.6 249.37,21.6 248.69,20.93 241.99,20.93 239.86,18.79 238.69,18.79 237.88,17.98 235.53,17.98 231.94,14.39 200.74,14.39 199.07,12.71 196.08,12.71 195.63,12.26 176.34,12.26 172.58,16.02 170.73,16.02 169.25,17.49 169.25,25.53 167.79,26.98 167.79,41.48 166.93,42.35 166.93,47.09 164.22,49.79 164.06,49.79 163.21,50.63 161.1,50.63 157.5,54.23 157.5,56.34 156.56,57.28 153.18,57.28 150,60.47 v2(147.77,60.47) 147.01,61.23 146.88,61.23 145.66,62.45 140.97,62.45 140.84,62.58 131.56,62.58 130.54,61.55 130.54,59.06 131.16,58.44 v2(131.49,58.44)
H_PM_DOWN: length 182.7
  TOP w0.109: v2(256.36,20.31) 256.06,20 256.06,19.75 255.8,19.5 RC168.1 ; UH1.AE2 133.94,48.1 133.94,48.65 134.08,48.79 134.08,49.23 134.59,49.74 134.59,51.57 134.1,52.07 134.1,52.54 133.27,53.37 133.27,55.27 132.97,55.58 132.97,58.34 v1(132.45,58.86) 132.15,59.16 v2(131.99,59.16)
  IN2 w0.081: v2(131.99,59.16) 131.99,60.45 133.6,62.07 137.67,62.07 138.55,61.19 144.9,61.19 146.29,59.79 148.91,59.79 149.88,58.82 150.47,58.82 152.48,56.81 156.45,56.81 157.09,56.17 157.09,54.06 162.01,49.13 164.22,49.13 165.77,47.59 165.77,42.78 167.23,41.32 167.23,26.82 168.8,25.26 168.8,17.36 170.55,15.6 172.32,15.6 176.23,11.69 212.6,11.69 214.49,13.58 232.17,13.58 236.15,17.56 238.05,17.56 238.87,18.38 240.03,18.38 240.34,18.69 241.91,18.69 242.68,19.45 248.32,19.45 249.83,20.97 252.27,20.97 252.93,20.31 v2(256.36,20.31)
H_PM_DOWN_R: length 9.9
  TOP w0.089: UC1.BP31 254.05,28.12 254.05,28.1 254.05,28.09 254.05,27.86 254.05,27.86 254.05,27.53 253.97,27.45 253.97,26.81 253.9,26.74 253.9,26.04 254.44,25.49
  TOP w0.109: RC168.2 256.13,21.05 256.13,22.97 v1(255.78,23.32) 255.14,23.96 254.84,23.96 254.44,24.36 254.44,25.49
H_PM_SYNC: length 183
  TOP w0.109: RH156.2 132.5,58.06 v2(132.12,58.44) ; v2(255.51,29.6) 255.36,29.76 255.29,29.76 UC1.BM34
  IN2 w0.081: v2(132.12,58.44) 131.57,58.99 131.57,59.6 131.1,60.07 131.1,61.79 131.66,62.35 137.79,62.35 138.72,61.41 146.27,61.41 147.61,60.07 150.1,60.07 153.11,57.06 156.49,57.06 157.29,56.26 157.29,54.14 161.96,49.48 164.21,49.48 166.7,46.99 166.7,42.26 167.57,41.39 167.57,26.78 169.03,25.32 169.03,17.43 170.64,15.81 172.41,15.81 176.19,12.03 212.37,12.03 214.34,14.01 232.28,14.01 236.04,17.77 237.96,17.77 238.78,18.59 239.94,18.59 241.02,19.66 248.17,19.66 249.73,21.22 252.45,21.22 253,20.67 255.31,20.67 256.01,21.37 256.01,24.81 256.83,25.64 256.83,28.28 v2(255.51,29.6)
  BOTTOM w0.109: v2(132.12,58.44) 132.35,58.66 v4(132.64,58.66)
H_PM_SYNC_R: length 10
  TOP w0.109: RH156.1 132.5,55.71 132.94,55.27 132.94,54.76 v1(132.94,54.75) 132.94,54.75 132.94,54.56 133.03,54.47 133.03,53.34 133.23,53.13 133.23,52.35 134.2,51.38 134.2,49.91 133.69,49.4 133.69,48.97 133.54,48.82 133.54,48.34 133.25,48.05 133.25,47.65 UH1.AF3
H_PROCHOT#_R: length 7.9
  TOP w0.089: UC1.BR30 253.05,27.68 253.05,27.09 252.87,26.9 252.87,26.87
  TOP w0.109: 252.87,26.87 252.87,25.4 253.5,24.77 253.5,24.58 v1(253.39,24.47) 253.12,24.47 253.01,24.36 253.01,24.14 253.12,24.03 253.39,24.03 253.5,23.93 253.5,23.69 253.08,23.27 253.08,22.66 253.4,22.34 253.62,22.34 253.74,22.21 RC84.2
H_PWRGD: length 255.1
  TOP w0.089: 253.93,25.08 253.49,25.52 253.49,27.3 UC1.BT31 ; 133.75,48.39 133.75,48.28 133.45,47.99 133.45,47.63 133.52,47.57 UH1.AE3
  TOP w0.109: v2(264.72,6.61) 264.72,7.17 266,8.44 266,12.06 263.19,14.87 259.79,14.87 259.31,15.35 257.02,15.35 254.96,17.41 254.96,20.39 CC300.1 254.68,21.33 254.81,21.33 255.1,21.62 255.1,22.94 254.78,23.26 254.73,23.26 253.93,24.06 253.93,25.08 ; v2(133.6,52.51) 133.6,52.26 134.4,51.47 134.4,49.82 133.89,49.32 133.89,48.87 133.75,48.73 133.75,48.39
  IN3 w0.081: v2(264.72,6.61) 265.28,6.05 265.28,5.22 264.09,4.03 255.82,4.03 253.27,6.58 247.93,6.58 243.4,2.06 167.14,2.06 166.1,3.1 157.3,3.1 153.61,6.78 148.62,6.78 147.06,8.34 138.06,8.34 137.2,9.2 135.52,9.2 133.96,7.63 131.21,7.63 130.25,8.6 126.58,8.6 125.4,9.78 120.63,9.78 118.87,11.54 118.87,12.94 116.66,15.15 116.66,16.26 116.98,16.58 116.98,18.22 115.32,19.88 115.32,21.27 114.93,21.66 114.93,25.79 113.71,27.01 113.71,27.68 113.2,28.18 113.2,28.78 114.71,30.28 114.71,30.83 115.39,31.51 116.41,31.51 116.63,31.74 116.63,36.11 117.17,36.64 117.17,46.79 123.12,52.74 123.73,52.74 124.12,53.13 124.12,53.98 125.43,55.29 128.92,55.29 129.17,55.04 129.17,54.52 129.33,54.36 131.32,54.36 131.74,53.93 132.18,53.93 v2(133.6,52.51)
H_SKTOCC#: length 10.9
  TOP w0.089: UC1.BR33 254.33,27.82 254.53,27.62 254.53,27.49 254.55,27.46 254.55,27.19 254.53,27.17 254.53,26.94 254.65,26.82 254.65,24.51 254.95,24.21 255.4,24.21 256.82,22.8 v1(256.82,22.27) 256.82,19.04 RC319.2
H_THERMTRIP#: length 183.2
  TOP w0.109: v2(134.01,56.63) 134.44,56.2 RH75.2
  IN2 w0.081: v2(150.33,54.51) 148.79,56.05 145.87,56.05 144.8,57.11 143.43,57.11 142.03,55.72 135.28,55.72 134.36,56.63 v2(134.01,56.63)
  IN3 w0.081: v2(156.69,55.72) 152.04,55.72 151.58,55.26 151.08,55.26 v2(150.33,54.51) ; v2(161.97,58.99) 161.99,58.97 163.07,58.97 163.23,59.13 163.23,59.9 167.74,64.4 170.66,64.4 170.99,64.73 173.3,64.73 174.93,66.36 174.93,78.45 175.69,79.21 182.95,79.21 183.49,78.67 190.14,78.67 190.69,78.12 197.91,78.12 198.68,78.89 202.99,78.89 217.73,64.15 229.94,64.15 231.06,63.03 234.05,63.03 235.47,61.61 239.16,61.61 240.34,62.79 249.78,62.79 250.14,62.44 250.14,61.61 250.39,61.36 250.89,61.36 251.35,60.9 251.65,60.9 252.04,61.29 252.04,61.86 252.36,62.18 256.74,62.18 257.2,62.64 259.77,62.64 260.26,62.15 262.75,62.15 263.09,61.82 264.11,61.82 266.33,64.04 266.33,66.47 267.23,67.38 v2(273.53,67.38)
  BOTTOM w0.109: v2(156.69,55.72) 157.69,54.72 158.79,54.72 159.79,55.72 RD45.2 RD29.2 162.13,56.45 RD21.2 RD7.2 162.05,58.91 v2(161.97,58.99) 161.39,59.56 QE4.3 ; v2(273.53,67.38) 273.52,67.38 RC169.1 274.28,68.18 CC323.1 274.31,67.28 274.65,66.95 RC80.2
H_THERMTRIP#_R: length 23.3
  TOP w0.109: v2(253.05,62.59) 253.42,62.95 UC1.J31
  BOTTOM w0.109: v2(253.05,62.59) 253.26,62.79 256.57,62.79 257.01,63.24 260.13,63.24 260.42,62.95 263.08,62.95 263.42,62.62 263.86,62.62 264.16,62.92 264.16,63.21 267.67,66.72 271.51,66.72 v1(271.84,67.05) 272.61,67.81 RC169.2
H_VCCST_PWRGD_XDP: length 16.6
  BOTTOM w0.109: RC124.2 235.46,13.55 235.51,13.6 CC307.1 v1(235.84,12.49) 235.84,12.4 236.54,11.7 237.44,11.7 238.58,12.84 240.55,12.84 241.01,12.38 241.01,11.07 241.33,10.75 241.96,10.75 244.88,13.67 JXDP1.39
HDA_BIT_CLK: length 8.4
  TOP w0.102: 121.21,43.38 123.83,43.38 123.95,43.26 124.23,43.26 124.37,43.4 UH1.BD11
  TOP w0.109: RH46.2 118.19,44.72 118.76,44.72 118.94,44.9 119.5,44.9 119.75,44.66 119.75,44.54 119.78,44.5 RH637.2 120.06,44.21 120.33,44.21 120.82,43.72 120.82,43.35 v1(120.87,43.3) 121.14,43.3 121.21,43.38
HDA_BIT_CLK_R: length 331.3
  TOP w0.109: RH46.1 v2(116.05,44.17) ; UA1.14 379.93,19.58 379.64,19.29 379.5,19.29 379.17,18.96 RA17.1 378.81,18.13 378.51,17.82 v2(378.51,17.26)
  IN1 w0.102: v2(116.19,27.73) 116.44,27.49 117.11,27.49 117.33,27.71 117.33,28.61 117.01,28.93 117.01,35.26 116.36,35.91 116.36,38.21 116.4,38.24 116.4,43.82 v2(116.05,44.17)
  IN2 w0.081: v2(378.51,17.26) 377.97,16.73 357.68,16.73 356.39,15.44 356.39,10.69 356.25,10.54 v2(356.25,7.77)
  IN4 w0.102: v2(116.19,27.73) 116.48,27.73 118.36,25.85 118.36,21.86 119.05,21.17 124.32,21.17 124.84,20.65 125.67,20.65 126.22,20.11 130.47,20.11 131,19.57 133.33,19.57 135.11,17.79 136.9,17.79 137.25,18.15 142.66,18.15 142.96,18.45 145.52,18.45 146.17,17.79 146.86,17.79 147.32,17.34 147.32,16.56 148.08,15.8 148.08,12.09 157.26,2.91 166.28,2.91 167.65,1.55 243.95,1.55 248.49,6.09 251.51,6.09 255.95,1.64 305.75,1.64 309.71,5.59 311.45,5.59 312.78,6.92 314.41,6.92 315.95,8.47 315.95,10.23 318.26,12.54 320.19,12.54 322.27,10.46 334.75,10.46 336.12,9.09 336.12,3.57 336.81,2.89 349.1,2.89 352.86,6.64 355.9,6.64 356.25,6.99 v2(356.25,7.77)
  BOTTOM w0.109: CH268.2 117.85,43.83 117.43,44.26 v1(117.4,44.26) 116.14,44.26 v2(116.05,44.17)
HDA_RST#: length 6.2
  TOP w0.102: UH1.BE10 124.07,44.09 123.37,44.09 123.04,43.76 121.38,43.76 121.04,44.1
  TOP w0.109: RH636.2 119.91,46.04 RH50.2 119.95,45.48 120.08,45.48 v1(120.86,44.69) 121.04,44.52 121.04,44.1
HDA_RST#_R: length 332.3
  TOP w0.109: v2(114.95,44.78) 115.35,45.19 115.35,45.58 115.72,45.95 115.98,45.95 116.18,46.14 117.28,46.14 118.07,45.36 118.07,45.32 118.27,45.12 118.57,45.12 118.97,45.52 RH50.1 ; v2(373.32,25.44) 373.43,25.54 RA50.1
  IN1 w0.102: v2(115.01,27.71) 114.94,27.78 114.94,28.88 115.19,29.13 115.19,31.82 114.89,32.12 114.89,35.14 115.44,35.69 115.44,37.4 114.91,37.93 114.91,38.41 114.61,38.72 114.61,40.75 114.33,41.03 114.33,44.16 v2(114.95,44.78) ; v2(373.32,25.44) 372.95,25.06 372.95,24.82 372.8,24.68 372.8,22.57 369.22,18.99 366.01,18.99 365.05,18.03 361.34,18.03 360.62,17.31 356.91,17.31 354.25,14.65 354.25,10.3 352.77,8.81 352.77,7.74 v2(352.74,7.71)
  IN4 w0.102: v2(115.01,27.71) 114.89,27.83 114.89,28.38 115.74,29.22 117.22,29.22 117.98,28.46 118.64,28.46 119.27,27.83 119.27,25.81 119.87,25.21 119.87,22.42 120.26,22.02 122.89,22.02 123.68,22.81 125.13,22.81 125.96,21.98 127.97,21.98 128.6,21.35 132.04,21.35 132.85,22.16 136.23,22.16 138.71,19.69 145.81,19.69 146.16,19.33 146.43,19.33 149.03,16.73 149.03,12.11 157.42,3.72 166.44,3.72 167.93,2.23 243.66,2.23 248.2,6.77 251.79,6.77 256.24,2.33 305.47,2.33 309.42,6.28 311.04,6.28 312.46,7.7 314.09,7.7 315.18,8.79 315.18,10.55 317.94,13.31 320.51,13.31 322.59,11.23 335.07,11.23 336.9,9.41 336.9,3.89 337.13,3.66 345.3,3.66 346.38,4.74 349.94,4.74 352.74,7.54 v2(352.74,7.71)
HDA_SDIN0: length 337.4
  TOP w0.102: 120.54,44.28 121.25,43.57 124.02,43.57 UH1.BE11
  TOP w0.109: v2(379.31,16.57) 379.47,16.57 379.86,16.96 RA9.1 ; 120.54,44.28 120.54,44.47 119.91,45.1 118.83,45.1 118.65,44.92 117.75,44.92 CA73.1 116.96,45.71 116.34,45.71 v2(116.33,45.72)
  IN1 w0.102: v2(116.33,45.72) 116.63,45.43 116.63,37.71 117.24,37.1 117.24,29.02 117.56,28.71 117.56,27.62 117.2,27.26 116.06,27.26 115.6,27.71 v2(115.6,27.73) ; v2(379.31,16.57) 379.28,16.57 379.08,16.37 376.7,16.37 376.35,16.02 376.35,15.55 376.77,15.13 376.77,13.96 376.08,13.27 373.9,13.27 372.77,14.4 370.74,14.4 370.06,13.73 370.06,11.79 369.01,10.74 363.96,10.74 362.92,9.7 358.75,9.7 v2(356.83,7.77)
  IN4 w0.102: v2(356.83,7.77) 356.83,7.17 356,6.34 352.88,6.34 349.19,2.66 336.71,2.66 335.89,3.47 335.89,8.99 334.65,10.23 322.17,10.23 320.09,12.31 318.35,12.31 316.18,10.14 316.18,8.37 314.5,6.7 312.87,6.7 311.54,5.36 309.8,5.36 305.85,1.41 255.86,1.41 251.47,5.8 248.61,5.8 244.13,1.32 167.55,1.32 166.19,2.68 157.16,2.68 147.85,12 147.85,15.71 147.18,16.38 145.79,16.38 144.24,17.92 137.35,17.92 136.99,17.57 135.02,17.57 133.24,19.34 130.91,19.34 130.37,19.88 126.12,19.88 125.54,20.46 124.76,20.46 124.3,20.92 118.99,20.92 118.13,21.77 118.13,25.76 116.83,27.06 116.26,27.06 115.6,27.71 v2(115.6,27.73)
  BOTTOM w0.109: v2(379.31,16.57) 379.31,17.2 v1(379.25,17.26)
HDA_SDIN0_R: length 2.5
  TOP w0.109: UA1.16 380.73,19.97 380.73,19.96 380.73,19.57 380.02,18.86 380.02,17.91 RA9.2
HDA_SDOUT: length 7.4
  TOP w0.102: 121.14,42.85 121.48,43.19 123.2,43.19 UH1.BF12
  TOP w0.109: 121.14,42.85 120.76,42.85 120.53,43.07 120.53,43.23 CA76.1 119.58,43.32 118.06,43.32 117.99,43.39 RH45.2 117.63,43.38 RH328.2
HDA_SDOUT_R: length 329.5
  TOP w0.109: UA1.17 381.13,19.89 381.13,19.56 380.44,18.86 v2(380.44,18.56) ; RH45.1 116.16,43.39 v2(115.99,43.56)
  IN1 w0.102: v2(115.65,28.55) 116.56,29.46 116.56,35.07 115.91,35.72 115.91,39.46 115.06,40.31 115.06,40.94 114.78,41.22 114.78,42.69 114.96,42.86 115.29,42.86 v2(115.99,43.56)
  IN2 w0.081: v2(380.44,18.56) 380.44,18.24 379.89,17.69 378.21,17.69 377.48,16.96 357.56,16.96 356.16,15.55 356.16,14.55 355.51,13.9 355.51,10.17 355.72,9.96 v2(355.72,7.33)
  IN4 w0.102: v2(355.72,7.33) 355.38,6.99 352.86,6.99 350.11,4.23 346.63,4.23 345.51,3.11 336.9,3.11 336.35,3.66 336.35,9.18 334.84,10.69 322.36,10.69 320.28,12.77 318.16,12.77 315.72,10.33 315.72,8.56 314.31,7.15 312.69,7.15 311.35,5.82 309.61,5.82 305.66,1.87 256.05,1.87 251.6,6.31 248.39,6.31 243.85,1.77 167.74,1.77 166.33,3.19 157.3,3.19 148.58,11.92 148.58,16.54 147.02,18.1 146.19,18.1 145.61,18.68 142.87,18.68 142.57,18.38 137.16,18.38 136.8,18.02 135.21,18.02 133.25,19.98 130.92,19.98 130.56,20.33 126.38,20.33 124.97,21.74 123.8,21.74 123.65,21.59 119.02,21.59 118.57,22.05 118.57,25.97 117.78,26.76 117.78,26.9 116.52,28.16 116.05,28.16 v2(115.65,28.55)
  BOTTOM w0.109: v2(380.44,18.56) v1(380.44,17.95)
HDA_SYNC: length 4.1
  TOP w0.109: RH48.2 CA74.1 120.37,42.86 120.63,42.61 121.18,42.61 121.56,42.99 122.71,42.99 UH1.BG13
HDA_SYNC_R: length 329.4
  TOP w0.109: v2(379.61,18.72) 379.61,18.87 380.33,19.6 380.33,19.96 380.33,19.97 UA1.15 ; RH48.1 118.66,42.04 118.55,41.92 118.31,41.92 118.11,42.13 116.31,42.13 v2(115.99,42.45)
  IN1 w0.102: v2(116.24,28.56) 116.79,29.11 116.79,35.16 116.14,35.81 116.14,39.56 115.29,40.4 115.29,41.74 v2(115.99,42.45)
  IN2 w0.081: v2(379.61,18.72) 379.61,18.25 379.38,18.02 377.57,18.02 376.73,17.18 357.42,17.18 355.93,15.69 355.93,14.68 355.21,13.96 355.21,10.89 354.65,10.33 v2(354.65,7.47)
  IN4 w0.102: v2(116.24,28.56) 116.52,28.84 117.28,28.84 117.97,28.15 117.97,26.84 119.67,25.13 119.67,22.03 119.92,21.78 123.57,21.78 124.28,22.49 125.09,22.49 125.63,21.95 125.63,21.35 126.29,20.7 127.64,20.7 128.11,21.16 130.01,21.16 130.26,20.91 134.27,20.91 136.09,19.09 136.54,19.09 136.91,19.45 145.16,19.45 146.26,18.35 147.09,18.35 148.8,16.64 148.8,12.01 157.37,3.44 166.4,3.44 167.84,2 243.76,2 248.3,6.54 251.7,6.54 256.14,2.1 305.57,2.1 309.52,6.05 311.26,6.05 312.59,7.38 314.22,7.38 315.49,8.66 315.49,10.42 318.07,13 320.38,13 322.46,10.92 334.94,10.92 336.58,9.28 336.58,3.76 337,3.34 345.39,3.34 346.55,4.51 350.04,4.51 352.81,7.28 354.45,7.28 v2(354.65,7.47)
  BOTTOM w0.109: v2(379.61,18.72) 379.61,19.32 v1(379.68,19.4)
HDD_DET#: length 286.7
  TOP w0.076: JNGFF4.34 376,9 375.73,9.27
  TOP w0.102: 131.75,24.98 131.24,25.49 131.24,25.9 131.33,25.99 UH1.AK47
  TOP w0.109: 131.75,24.98 131.75,24.31 132.23,23.82 v2(132.7,23.82) ; RH324.2 370.26,12.29 371.54,12.29 372.27,11.56 v1(372.27,11.39) 372.27,10.81 372.64,10.44 373.9,10.44 374.75,9.59 375.41,9.59 375.73,9.27
  IN2 w0.081: v2(357.83,12.56) 358.34,13.07 359.08,13.07 359.79,12.36 363.12,12.36 364.18,13.43 365.09,13.43 366.31,14.65 373.77,14.65 376.93,11.48 376.93,10.23 376,9.29 JNGFF4.34
  IN3 w0.081: v2(132.7,23.82) 132.61,23.82 132.36,23.57 132.36,21.32 132.76,20.93 133.82,20.93 134.17,21.28 134.17,21.69 135.08,22.61 139.14,22.61 141.11,20.64 142.53,20.64 142.96,21.07 146.68,21.07 149.07,18.68 151.04,18.68 151.46,18.26 157.11,18.26 161.05,14.33 163.43,14.33 169.63,8.13 230.9,8.13 234.6,11.82 237.15,11.82 238.03,12.71 243.48,12.71 243.72,12.95 256.37,12.95 257.28,12.03 265.63,12.03 266.24,11.42 266.89,11.42 269.92,8.38 276.16,8.38 277.16,7.38 305.68,7.38 306.97,8.67 317.27,8.67 320.39,11.8 320.39,13.64 321.11,14.36 325.35,14.36 326.68,13.02 332.87,13.02 333.28,12.6 334.71,12.6 335.52,11.79 336.81,11.79 338.07,13.05 340.63,13.05 341.56,12.12 344.75,12.12 347.31,14.68 349.35,14.68 349.56,14.48 355.46,14.48 357.38,12.56 v2(357.83,12.56)
HDD_FALL_INT: length 249.6
  TOP w0.102: UH1.AW26 127,36.15 127.43,36.58 v2(127.43,36.63)
  IN3 w0.081: v2(127.43,36.63) 126.38,35.57 126.38,35.12 125.61,34.35 123.3,34.35 121.66,32.71 121.66,30.29 122.72,29.23 122.72,27.94 122.39,27.61 122.39,25.78 121.08,24.47 121.08,23.03 120.72,22.67 120.72,21.17 120.22,20.67 120.22,19.77 121.33,18.66 121.33,17.55 123.72,15.15 129.68,15.15 131.89,12.94 133.55,12.94 134.14,12.36 140.96,12.36 141.82,11.49 148.45,11.49 149.63,10.31 163.35,10.31 168.45,5.21 241.57,5.21 246.24,9.88 254.9,9.88 256.42,8.36 265.59,8.36 268.72,5.23 274.32,5.23 277.31,2.24 301.36,2.24 303.07,3.95 v2(305.51,3.95)
  BOTTOM w0.109: v2(127.43,36.63) 127.43,37.34 127.87,37.78 127.87,38.05 128.05,38.23 RH355.2
  BOTTOM w0.203: v2(305.51,3.95) 305.17,4.3 305.17,7.18 303.41,8.95 302.38,8.95 299.88,11.45 299.88,13.92 301.71,15.75 301.71,22.37 301.97,22.63 v1(302.43,22.63) 305.48,22.63 305.63,22.78 LGA1.12
HDD_IFDET: length 8.7
  TOP w0.109: UZ60.1 360.48,13.49 v2(361.01,12.97)
  BOTTOM w0.109: v2(361.01,12.97) 361.78,12.19 361.78,11.33 v1(361.91,11.2) 362.35,10.76 363.3,10.76 363.41,10.87 RZ541.1 365.37,11.17 365.75,10.79 JNGFF4.75
HOST_DEBUG_TX: length 49.8
  TOP w0.109: UE1.G11 v2(141.21,74.08)
  IN3 w0.081: v2(116.43,56.92) 116.56,56.92 123.17,63.54 126.35,63.54 128.13,61.76 129.98,61.76 130.31,62.09 130.31,62.85 130.49,63.04 133.67,63.04 134.37,63.74 135.47,63.74 136.05,64.33 138.54,64.33 139.39,65.18 140.46,65.18 140.88,65.6 140.88,65.88 142.53,67.53 143.02,67.53 143.57,68.08 143.57,68.9 143.71,69.04 144.05,69.04 144.24,69.23 144.24,70.92 142.24,72.92 141.86,72.92 141.65,73.13 141.65,73.51 141.21,73.95 v2(141.21,74.08)
  BOTTOM w0.109: v1(141.7,74.56) 141.22,74.08 v2(141.21,74.08) ; JDEG1.8 116.51,54.81 RE73.2 RE306.2 117.08,56.28 v2(116.43,56.92)
