# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RV893  4.7K_0402_5%  [R_0402]  70.12 57.58 180 bottom
RV894  4.7K_0402_5%  [R_0402]  70.85 57.58 0 bottom
RV895  1M_0402_5%  [R_0402]  52.58 52.34 0 top
RV896  1M_0402_5%  [R_0402]  71.12 56.15 0 bottom
RV897  100K_0402_5%  [R_0402]  77.82 42.64 0 top
RV898  100K_0402_5%  [R_0402]  60.09 48.07 270 top
RV900  10K_0402_5%  [R_0402]  144.88 130.26 270 top
RV901  8.2K_0402_5%  [R_0402]  145.4 131.7 90 top
RV902  100K_0402_5%  [R_0402]  59.13 46.19 270 top
RV903  100K_0402_5%  [R_0402]  79.5 43.19 0 top
RV904  100K_0402_5%  [R_0402]  164.11 75.07 180 bottom
RV905  100K_0402_5%  [R_0402]  142.06 78.68 90 bottom
RV907  4.3M_0402_1%  [R_0402]  138.01 135.14 180 bottom
RV908  3M_0402_1%  [R_0402]  137.09 135.9 0 bottom
RV909  100K_0402_5%  [R_0402]  138.69 137.99 90 bottom
RV910  100K_0402_5%  [R_0402]  134.36 136.73 0 bottom
RV911  1M_0402_1%  [R_0402]  134.49 139.19 0 bottom
RZ3  0_0201_5%  [R_0201]  137.3 95.49 270 top
RZ4  0_0201_5%  [R_0201]  134.38 100.7 270 top
RZ8  4.7K_0402_5%  [R_0402]  338.15 53.02 90 top
RZ9  4.7K_0402_5%  [R_0402]  336.17 52.61 180 bottom
RZ10  100K_0402_5%  [R_0402]  339.01 47.02 180 top
RZ18  4.7K_0402_5%  [R_0402]  29.2 10.63 180 bottom
RZ19  4.7K_0402_5%  [R_0402]  29.18 9.86 180 bottom
RZ20  2.2K_0402_5%  [R_0402]  32.42 9.76 0 bottom
RZ21  2.2K_0402_5%  [R_0402]  32.42 10.56 0 bottom
RZ22  0_0402_5%  [R_0402]  28.28 11.39 0 bottom
RZ23  0_0402_5%  [R_0402]  28.27 9.08 0 bottom
RZ25  150_0402_5%  [R_0402]  388.17 12.21 180 bottom
RZ26  0_0402_5%  [R0402_0OHM]  32.38 8.93 270 bottom
RZ28  200_0402_5%  [R_0402]  399.81 14.14 0 bottom
RZ29  0_0402_5%  [R0402_0OHM]  32.49 11.42 180 bottom
RZ32  270_0402_5%  [R_0402]  394.46 8.14 0 top
RZ43  10K_0402_5%  [R_0402]  144.98 117.69 270 bottom
RZ56  0_0402_5%  [R_0402]  121.8 115.64 90 bottom
RZ58  33_0402_5%  [R_0402]  134.78 19.99 0 bottom
RZ59  33_0402_5%  [R_0402]  134.78 19.21 0 bottom
RZ60  33_0402_5%  [R_0402]  134.34 17.4 0 bottom
RZ61  0_0402_5%  [R0402_0OHM]  134.1 18.24 0 bottom
RZ62  10K_0402_5%  [R_0402]  138.76 21.66 90 bottom
RZ63  33_0402_5%  [R_0402]  134.34 16.51 0 bottom
RZ69  10K_0402_5%  [R_0402]  134.67 14.19 0 bottom
RZ70  0_0402_5%  [R_0402]  146.94 100.47 0 top
RZ71  0_0402_5%  [R_0402]  146.71 96.97 0 top
RZ78  0_0402_5%  [R_0402]  119 39.48 0 top
RZ79  0_0402_5%  [R_0402]  119 38.72 0 top
RZ80  0_0402_5%  [R_0402]  119.16 41.18 0 top
RZ81  0_0402_5%  [R_0402]  122.39 43.73 0 bottom
RZ85  0_0402_5%  [R_0402]  338.37 59.84 180 top
RZ89  0_0402_5%  [R0402_0OHM]  144.9 16.18 180 bottom
RZ112  0_0402_5%  [R0402_0OHM]  139.77 22.57 270 bottom
RZ114  0_0402_5%  [R_0402]  339.07 47.96 180 top
RZ116  10K_0402_5%  [R_0402]  31.59 8.93 270 bottom
RZ117  10K_0402_5%  [R_0402]  31.63 9.71 90 bottom
RZ119  0_0402_5%  [R_0402]  165.22 34.16 90 bottom
RZ120  0_0402_5%  [R0402_0OHM]  161.39 30.85 0 bottom
RZ128  0_0402_5%  [R_0402]  159.23 116.42 90 bottom
RZ129  0_0402_5%  [R_0402]  161.49 119.57 90 bottom
RZ130  0_0402_5%  [R_0402]  162.38 119.45 90 bottom
RZ151  0_0402_5%  [R_0402]  270.46 74.64 270 top
RZ346  0_0402_5%  [R0402_0OHM]  29.92 9.14 0 bottom
RZ347  0_0402_5%  [R0402_0OHM]  29.91 11.38 0 bottom
RZ361  240_0402_5%  [R_0402]  394.45 13.1 270 bottom
RZ362  10K_0402_5%  [R_0402]  138.81 23.64 0 bottom
RZ363  0_0402_5%  [R_0402]  144.55 19.83 180 bottom
RZ364  100_0402_5%  [R_0402]  338.37 58.32 180 top
RZ365  0_0402_5%  [R0402_0OHM]  137.84 19.52 90 top
RZ366  0_0402_5%  [R_0402]  148.62 18.09 180 bottom
RZ367  0_0402_5%  [R_0402]  144.9 17.96 180 bottom
RZ368  0_0402_5%  [R0402_0OHM]  148.62 20.74 180 bottom
RZ369  0_0402_5%  [R_0402]  148.62 21.53 180 bottom
RZ371  0_0402_5%  [R_0402]  126.57 115.42 90 bottom
RZ372  0_0201_5%  [R_0201]  161.43 118.78 0 bottom
RZ373  0_0201_5%  [R_0201]  162.29 117.49 180 bottom
RZ374  0_0201_5%  [R_0201]  159.97 116.69 90 bottom
RZ375  10K_0402_5%  [R_0402]  143.46 100.42 270 top
RZ376  10K_0402_5%  [R_0402]  135.01 97.35 90 top
RZ377  100K_0402_5%  [R_0402]  136.6 94.81 90 top
RZ378  100K_0402_5%  [R_0402]  134.17 94.88 0 top
RZ379  20K_0402_5%  [R_0402]  144.52 101.4 0 top
RZ381  100K_0402_5%  [R_0402]  135.76 102.44 0 top
RZ504  10K_0402_5%  [R_0402]  303.58 67.35 0 top
RZ505  10K_0402_5%  [R_0402]  120.17 73.8 180 top
RZ507  10K_0402_5%  [R_0402]  130.73 77.18 0 bottom
RZ508  10K_0402_5%  [R_0402]  120.55 76.24 180 top
RZ509  0_0402_5%  [R0402_0OHM]  136.1 14.51 270 top
RZ510  0_0402_5%  [R0402_0OHM]  365.45 31.69 90 top
RZ512  100K_0402_5%  [R_0402]  128.29 87.75 0 top
RZ513  100K_0402_5%  [R_0402]  133.41 99.33 0 top
RZ514  20K_0402_5%  [R_0402]  129.61 85.81 0 top
RZ518  20_0603_5%  [R_0603]  353.69 50.83 90 top
RZ522  0_0402_5%  [R0402_0OHM]  130.29 160.76 0 bottom
RZ523  0_0201_5%  [R_0201]  127.96 101.83 90 bottom
RZ524  0_0201_5%  [R_0201]  127.33 101.83 90 bottom
RZ525  0_0201_5%  [R_0201]  118.06 101.83 90 bottom
RZ526  0_0201_5%  [R_0201]  117.42 101.83 90 bottom
RZ527  0_0201_5%  [R_0201]  116.02 101.83 90 bottom
RZ528  0_0201_5%  [R_0201]  116.66 101.83 90 bottom
RZ529  0_0201_5%  [R_0201]  114.75 101.96 90 bottom
RZ530  0_0201_5%  [R_0201]  115.39 101.96 90 bottom
RZ531  22_0402_5%  [R_0402]  116.66 115.64 90 bottom
RZ532  22_0402_5%  [R_0402]  115.83 115.64 90 bottom
RZ533  22_0402_5%  [R_0402]  124.29 52.53 270 top
RZ534  22_0402_5%  [R_0402]  118.25 115.64 90 bottom
RZ535  22_0402_5%  [R_0402]  119.07 115.64 90 bottom
RZ536  22_0402_5%  [R_0402]  119.9 115.64 90 bottom
RZ537  100K_0402_5%  [R_0402]  130.16 73.53 180 bottom
RZ538  100K_0402_5%  [R_0402]  334.87 21.27 90 bottom
RZ539  100K_0402_5%  [R_0402]  334.08 21.26 90 bottom
RZ540  100K_0402_5%  [R_0402]  160.86 78.3 90 bottom
RZ541  1M_0201_5%  [R_0201]  363.41 11.17 180 bottom
RZ542  10K_0402_5%  [R_0402]  274.48 74.41 180 top
RZ543  10K_0402_5%  [R_0402]  279.5 73.99 270 top
RZ545  0_0201_5%  [R0201_0OHM]  133.08 133.47 0 bottom
RZ547  100K_0402_5%  [R_0402]  132.43 87.82 90 top
RZ548  0_0402_5%  [R_0402]  299.44 67.83 270 bottom
RZ549  0_0402_5%  [R0402_0OHM]  299.44 65.25 90 bottom
RZ550  0_0603_5%  [R_0603]  133.94 132.5 180 bottom
RZ551  0_0603_5%  [R_0603]  132.55 126.37 0 bottom
RZ1385  10K_0402_5%  [R_0402]  144.97 96.97 0 top
RZ1413  330K_0402_5%  [R_0402]  102.99 62.51 180 top
RZ1415  0_0402_5%  [R0402_0OHM]  102.08 63.34 0 top
RZ1482  1M_0402_5%  [R_0402]  98.31 61.34 90 top
RZ1483  0_0402_5%  [R_0402]  338.37 56.97 180 top
RZ1484  0_0402_5%  [R_0402]  28.19 2.38 90 top
SW1  SS3-CMFTQR9_3P  [SW_SS3-CMFTQR9_3P]  166 98.25 0 bottom
SW3  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  363.07 50.01 180 top
T1  PAD~D  [TPC12]  230.34 71.77 0 top
T2  PAD~D  [TPC12]  227.26 68.94 0 top
T3  PAD~D  [TPC12]  233.17 73.23 0 top
T4  PAD~D  [TPC12]  231.66 73.09 0 top
T5  PAD~D  [TPC12]  219.81 25.69 180 bottom
T6  PAD~D  [TPC12]  221.09 25.69 180 bottom
T7  PAD~D  [TPC12]  258.46 18.77 0 top
T8  PAD~D  [TPC12]  258.53 20.07 0 top
T9  PAD~D  [TPC12]  250.71 69.48 180 bottom
T10  PAD~D  [TPC12]  251.99 69.2 180 bottom
T11  PAD~D  [TPC12]  264.18 14.47 180 bottom
T12  PAD~D  [TPC12]  239.98 53.53 180 bottom
T13  PAD~D  [TPC12]  221.44 69.44 180 bottom
T14  PAD~D  [TPC12]  250.39 62.5 180 bottom
T15  PAD~D  [TPC12]  251.3 49.75 180 bottom
T18  PAD~D  [TPC12]  253.44 69.99 0 top
T19  PAD~D  [TPC12]  253.17 71.72 0 top
T20  PAD~D  [TPC12]  224.47 65.37 0 top
T21  PAD~D  [TPC12]  229.17 72.43 0 top
T22  PAD~D  [TPC12]  252.51 32.77 180 bottom
T23  PAD~D  [TPC12]  257.16 20.89 0 top
T24  PAD~D  [TPC12]  255.56 21.43 0 top
T25  PAD~D  [TPC12]  238.55 38.78 180 bottom
T26  PAD~D  [TPC12]  238.96 41.87 180 bottom
T27  PAD~D  [TPC12]  239.99 43.44 180 bottom
T28  PAD~D  [TPC12]  251.91 43.45 180 bottom
T29  PAD~D  [TPC12]  262.89 14.56 180 bottom
T30  PAD~D  [TPC12]  264.28 13.17 180 bottom
T31  PAD~D  [TPC12]  239.6 40.72 180 bottom
T32  PAD~D  [TPC12]  239.82 38.75 180 bottom
T33  PAD~D  [TPC12]  137.39 30.09 180 bottom
T34  PAD~D  [TPC12]  137.25 31.37 180 bottom
T35  PAD~D  [TPC12]  130.01 31.4 180 bottom
T36  PAD~D  [TPC12]  119.45 53.23 0 top
T40  PAD~D  [TPC12]  137.41 43.11 180 bottom
T46  PAD~D  [TPC12]  184 57.54 180 bottom
T47  PAD~D  [TPC12]  171.37 59.3 180 bottom
T48  PAD~D  [TPC12]  171.26 58 180 bottom
T49  PAD~D  [TPC12]  183.97 58.83 0 top
T50  PAD~D  [TPC12]  200.66 57.48 180 bottom
T51  PAD~D  [TPC12]  185.26 58.66 180 bottom
T52  PAD~D  [TPC12]  185.3 58.16 0 top
T53  PAD~D  [TPC12]  198.32 58.94 0 top
T60  PAD~D  [TPC12]  138.49 42.26 180 bottom
T61  PAD~D  [TPC12]  139.76 42.56 180 bottom
T62  PAD~D  [TPC12]  128.83 31.93 180 bottom
T63  PAD~D  [TPC12]  131.11 30.6 180 bottom
T73  PAD~D  [TPC12]  150.45 139.42 0 bottom
T74  PAD~D  [TPC12]  150.33 140.86 0 bottom
T75  PAD~D  [TPC12]  119.9 49.35 0 top
T76  PAD~D  [TPC12]  138.88 22.87 0 top
T77  PAD~D  [TPC12]  140.15 22.96 0 top
T178  PAD~D  [TPC12]  120.89 30.41 0 top
T179  PAD~D  [TPC12]  254.98 20.65 180 bottom
T180  PAD~D  [TPC12]  248.92 24.53 180 bottom
T181  PAD~D  [TPC12]  251.13 23.89 180 bottom
T184  PAD~D  [TPC12]  249.87 23.6 180 bottom
T185  PAD~D  [TPC12]  238.67 23.38 180 bottom
T189  PAD~D  [TPC12]  248.77 21.5 0 top
T190  PAD~D  [TPC12]  252.41 25.35 0 top
T194  PAD~D  [TPC12]  255.65 71.06 0 top
T199  PAD~D  [TPC12]  238.58 25.16 0 top
T258  PAD~D  [TPC12]  121.09 31.26 90 top
T268  PAD~D  [TPC12]  127.54 31.69 180 bottom
T269  PAD~D  [TPC12]  121.17 41.86 0 top
T281  PAD~D  [TPC12]  252.02 70.53 180 bottom
T284  PAD~D  [TPC12]  139.39 13.06 180 bottom
T285  PAD~D  [TPC12]  253.41 70.16 180 bottom
T287  PAD~D  [TPC12]  131.02 37.48 270 bottom
T288  PAD~D  [TPC12]  135.95 42.67 180 bottom
T289  PAD~D  [TPC12]  137.16 41.85 180 bottom
T290  PAD~D  [TPC12]  138.68 30.18 180 bottom
T291  PAD~D  [TPC12]  138.54 31.45 180 bottom
T294  PAD~D  [TPC12]  132.13 41.7 180 bottom
T295  PAD~D  [TPC12]  131.71 42.93 180 bottom
T297  PAD~D  [TPC12]  257.21 19.57 0 top
T298  PAD~D  [TPC12]  225.37 46.42 0 top
T299  PAD~D  [TPC12]  221.46 70.75 180 bottom
T300  PAD~D  [TPC12]  259.93 71.62 0 top
T301  PAD~D  [TPC12]  231.76 71.66 0 top
T302  PAD~D  [TPC12]  219.81 24.4 180 bottom
T303  PAD~D  [TPC12]  221.1 24.4 180 bottom
T304  PAD~D  [TPC12]  258.48 71.74 0 top
T305  PAD~D  [TPC12]  233.27 71.8 0 top
T306  PAD~D  [TPC12]  119.58 37.61 0 top
T307  PAD~D  [TPC12]  121.23 38.69 0 top
T309  PAD~D  [TPC12]  145.77 71.87 0 top
T313  PAD~D  [TPC12]  141.4 44.62 180 bottom
T314  PAD~D  [TPC12]  141.08 46.4 180 bottom
T315  PAD~D  [TPC12]  52.42 43.45 180 bottom
T316  PAD~D  [TPC12]  84.48 58.43 0 top
T317  PAD~D  [TPC12]  119.19 29.12 0 top
T318  PAD~D  [TPC12]  124.69 34.48 180 bottom
T319  PAD~D  [TPC12]  112.91 29.78 0 top
TL1  MHPC_NS692417  [MHPC_NS692417_24P]  168.35 172.73 270 bottom
UA1  -  [ALC3281-CG_MQFN48_6X6]  378.78 25.21 0 top
UC1  CFL-H_BGA1440  [CFL-H_BGA_1440P-T]  231.35 67.95 180 top
UC3  -  [TC7SH09FU_SSOP5]  122.11 57.5 180 top
UC5  -  [W25Q256JVEIQ_WSON8_8X6]  124.15 13.6 180 bottom
UC6  -  [MX25L25645GM2I-10G_SO8]  110.19 28.39 270 bottom
UD1  -  [74AUP1G07GW_TSSOP5]  151.73 14.49 180 bottom
UE1  MEC5105_WFBGA169_11X11  [MEC5105_WFBGA_169P]  132.84 79.25 0 top
UE3  -  [MC74VHC1G08DFT2G_SC70-5]  156.3 61.99 270 bottom
UE4  -  [74AUP1G07GW_TSSOP5]  152.82 61.99 270 bottom
UE5  -  [MC74VHC1G08DFT2G_SC70-5]  154.51 64.49 180 bottom
UE11  -  [74AUP1G07GW_TSSOP5]  108.42 64.3 270 top
UE12  -  [IT8306FN-CX-R_QFN28_4X4]  161.38 75.48 180 bottom
UH1  CNP-H_BGA874  [CNP-H_BGA_874P-T]  145.52 48.54 270 top
UH7  -  [MC74VHC1G08DFT2G_SC70-5]  108.61 30.84 90 bottom
UI1  -  [SLGC55544CVTR_TQFN16_3X3]  382.89 58.55 0 top
UI2  -  [SLGC55544CVTR_TQFN16_3X3]  380.69 36.97 270 top
UI3  -  [SLGC55544CVTR_TQFN16_3X3]  115.55 149.23 0 top
UI4  -  [PS8713BTQFN24GTR2-A_TQFN24_4X4]  379.72 56.69 270 bottom
UI5  -  [PS8713BTQFN24GTR2-A_TQFN24_4X4]  383.28 46.02 270 bottom
UL1  WGI219LM-SLKJ2-A0_QFN48_6X6~D  [WGI219LM-SLKJ2-A0_QFN48_6X6]  156.13 137.63 180 top
UL2  -  [SN74AHC1G08DCKR_SC70-5]  131.65 143.89 90 top
UR1  -  [RTS5243-GR_QFN48_6X6]  20.55 18.23 180 bottom
UR3  -  [W25X40CLSSIG_SO8]  21.97 5.98 270 bottom
UR4  -  [EM5201V_DFN3X3-8-X]  27.78 17.51 0 bottom
UT1  THUNDERBOLT_BGA337  [THUNDERBOLT_BGA_337P]  32.35 52.57 90 bottom
UT2  -  [W25Q80DVSSIG_SO8]  47.44 51.27 180 top
UT5  CYPD5225-96BZXI_BGA96_6X6  [CYPD5256-96BZXI_BGA_96P]  17.54 30.67 0 bottom
UT7  -  [RT9069-33GB_SOT23-5]  49.6 16.51 90 top
UT9  -  [DPS1113FIA-13_QFN18_4X4]  37.72 23.03 90 top
UT10  -  [74AUP1G02GW_TSSOP5]  33.94 24.61 0 bottom
UT11  -  [DPS1113FIA-13_QFN18_4X4]  43.02 23.03 90 top
UT12  -  [74AUP1G02GW_TSSOP5]  42.49 24.38 90 bottom
UT32  -  [TS5A3159ADCKR_SC70-6]  115.15 65.05 270 top
UT34  -  [MC74VHC1G08DFT2G_SC70-5]  115.58 61.69 270 top
UV8  -  [PS8338BQFN60GTR-A1_QFN60_5X9]  295.37 77.39 90 top
UV24  -  [G524B1T11U_SOT23-5]  109.64 146.95 270 top
UV60  -  [MC74VHC1G09DFT2G_SC70-5]  279.39 79.83 180 bottom
UV61  -  [SN74AHC1G08DCKR_SC70-5]  288.4 75.22 90 bottom
UV62  -  [SN74AHC1G08DCKR_SC70-5]  288.4 77.82 90 bottom
UV63  -  [SN74AHC1G08DCKR_SC70-5]  286.71 83.35 270 bottom
UV64  PS8331BQFN60GTR-A0_QFN60_5X9  [PS8331BQFN60GTR-A0_QFN60_5X9-S]  151.62 116.67 0 top
UV65  M74VHC1GT125DF2G_SC70-5  [P_M74VHC1GT125DF2G_SC70_5P]  165.71 124.53 0 top
UV66  -  [PS8461QFN66GTR-A0_QFN66_5X10]  58.35 54.12 180 bottom
UV67  -  [PS8461QFN66GTR-A0_QFN66_5X10]  71.87 48.14 90 top
UV68  M74VHC1GT125DF2G_SC70-5  [P_M74VHC1GT125DF2G_SC70_5P]  279.36 78.12 90 bottom
UV69  -  [74AUP1G07GW_TSSOP5]  281.12 73.4 180 bottom
UZ6  -  [MC74VHC1G08DFT2G_SC70-5]  104.09 13.17 90 bottom
UZ7  -  [AOZ1336DI_DFN8_2X2]  167.13 139.06 0 bottom
UZ9  -  [EM5209VF_DFN14_3X2]  334.09 18.63 90 top
UZ10  -  [MC74VHC1G08DFT2G_SC70-5]  389.47 9.14 180 top
UZ12  -  [NPCT750JABYX_QFN32_5X5]  142.1 19.04 180 bottom
UZ19  -  [EM5201V_DFN3X3-8-X]  270.75 78.29 0 top
UZ21  -  [EM5201V_DFN3X3-8-X]  277.37 73.95 270 bottom
UZ23  -  [AOZ1336DI_DFN8_2X2]  363.41 13.31 270 top
UZ26  -  [EM5201V_DFN3X3-8-X]  163.82 32.58 180 bottom
UZ34  -  [MC74VHC1G08DFT2G_SC70-5]  151.31 17.8 180 bottom
UZ35  -  [MC74VHC1G08DFT2G_SC70-5]  275.34 75.68 90 top
UZ40  -  [EM5209VF_DFN14_3X2]  366.61 35.76 270 top
UZ41  -  [EM5209VF_DFN14_3X2]  299.4 66.25 90 top
UZ42  -  [AOZ1336DI_DFN8_2X2]  138.1 15.11 270 top
UZ43  -  [AOZ1336DI_DFN8_2X2]  94.26 56.67 90 top
UZ44  -  [EM5209VF_DFN14_3X2]  146.83 102.52 0 top
UZ45  -  [AOZ1336DI_DFN8_2X2]  333.32 14.19 270 top
UZ58  -  [AOZ1336DI_DFN8_2X2]  351.61 11.83 90 bottom
UZ59  -  [AOZ1336DI_DFN8_2X2]  128.33 81.08 180 bottom
UZ60  -  [SN74AHC1G08DCKR_SC70-5]  359.76 13.49 270 top
UZ61  -  [74AUP1G07GW_TSSOP5]  277.65 73.11 90 top
Y1  25MHZ_18PF_7V25000015  [Y_X3G025000DI1H-H_4P]  160.35 143.46 270 top
YE1  32.768KHZ_9PF_X1A000141000200  [Y_X1A000141000200_2P]  131.72 84.2 0 top
YH1  32.768KHZ_12.5PF_9H03200042  [Y_9H03200042_2P]  128.35 17.76 180 top
YH2  24MHZ_12PF_8Y24000034  [Y_8Y24000034_4P]  138.27 57.31 0 top
YT1  25MHZ_20PF_FL2500123Z  [Y_FL2500123Z_4P]  30.01 37.34 0 bottom

## Library data of the parts
C190 CA29 CA31 CA49 CA232 CA233 CC161 CC163-CC168 CC170-CC172 CC185 CH63 CH65-CH67 CH349 CH350 CT356 CT358 CT372-CT374 CV13 CV14 CV954 CZ17 CZ18 CZ218 PC1113 PC1117 = CAP NP
C191 C195 C206 C207 C209 CZ10 CZ11 CZ19 CZ21 CZ28 CZ29 CZ521 = CAP NP: room: WWAN
C192 C193 CZ12 CZ13 CZ536-CZ539 = CAP NP: room: WLAN
C194 = CAP NP: room: +3.3V_LAN_Source
C199 C201-C203 CZ522 = CAP NP: room: +3.3V_M source
C200 CZ121 = CAP NP: room: +3.3V_MXM_Source
CA1 CA4 PC200 PC202 PC206 PC209-PC213 PC302 PC1206 PC1207 PC1217 PC1218 PC1227 PC1228 PC1237 PC1238 PC1700 PC1701 PC1800 PC1801 = P_CAP NP: room: P_1.35V0.675V
CA2 CA3 CA9 CA12 CA13 CA19 CA22-CA25 CA27 CA28 CA33 CA35 CA41 CA43 CA44 CA46 CA48 CA51-CA53 CA56 CA58 CA59 CA61 CA69 CA73 CA74 CA76 CA224-CA226 CZ38-CZ40 = CAP NP: room: CODEC
CA8 = CAP NP: signal model: C_0201_0.1U_0201_10V6K
CA10 CA45 CA47 CA55 CA57 CA60 = CAP NP: room: CODEC; signal model: C_0201_0.1U_0201_10V6K
CA54 CA63-CA68 CE59 CE60 CH45 CT2-CT9 CT68 CT69 CT91 CT95-CT98 CT101 CT102 CT109 CT123-CT130 CT189 CT190 CT300-CT303 CT305-CT311 CT314-CT341 CT343 CT346 CT349 CT359-CT368 CV839 CV840 CV852 CV955-CV957 CZ57-CZ60 CZ62 CZ63 CZ528 CZ529 CZ545 = CAP NP: room: TBT
CA227 CA228 = CAP NP: room: CAMERA
CC28 CC29 CC32 CC33 CC269 CC306-CC308 CC334 CC336-CC338 = CAP NP: room: CPU XDP
CC34-CC65 CC186 CC191-CC195 CC209 CC210 CC300-CC305 CC322-CC324 CC327 CC328 CC333 CC335 CC568 CC569 CE61 CH47 CH324 CH560 CR220 CR229 CR238 CR241 CR250 CR253 PC1302-PC1323 PC1395-PC1400 PC1502-PC1514 PC1600-PC1609 = CAP NP: room: CPU
CC81-CC84 CC187-CC189 CC272 = P_CAP NP: room: CPU
CC310 CC311 CC329-CC332 = CAP NP: room: CPU; signal model: C_0201_0.1U_0201_10V6K
CC318-CC320 CC325 CE57 CH270 CH321 CH322 CT237 CT389 = CAP NP: room: SPI ROM
CD1-CD13 CD15-CD46 CD48-CD75 CD77-CD111 CD113-CD128 CZ544 = CAP NP: room: MEMORY
CD14 CD47 CD76 CD112 = CAP WP: room: MEMORY
CE3 CE4 CE10 CE12 CE14 CE16 CE17 CE24 CE26-CE31 CE36 CE38 CE40 CE47 CE54 CE62 CE66 CE270 CE343 CV851 CZ80 CZ81 CZ512 CZ525 = CAP NP: room: KBC
CE8 = CAP NP: room: SIO
CE11 CE13 CE15 CE18-CE23 CE25 = CAP NP: room: KBC; signal model: C_0201_0.1U_0201_10V6K
CE35 CE39 CE46 CE272 CE339 CR219 CR237 CR240 CR249 CR252 CV842 CV843 CZ507 CZ508 = CAP NP: room: Thermal
CE52 CE53 CE340-CE342 CH4 CH5 CH10 CH13 CH14 CH20 CH21 CH29 CH31 CH33-CH38 CH40 CH41 CH46 CH266-CH268 CH323 CH341-CH348 CH555 CV841 CV853 = CAP NP: room: PCH
CE63-CE65 = CAP NP: room: RTC_2
CH9 = CAP NP: room: SPI ROM; signal model: C_0201_0.1U_0201_10V6K
CH22 CH30 CH32 CH559 CR200 CR214 CR215 CR218 CR223-CR225 CR227 CR228 CR235 CR236 CR244-CR246 CR248 CR256 CV813 = CAP NP: room: RTS5242
CH44 CH62 CH64 CH68 = CAP NP: signal model: C_0201_0.1U_0201_10V6K; room: PCH
CH340 = P_CAP NP: room: CAMERA
CI1 CI32 CI77 CN179 CN193 CN207 CN217 PC1300 PC1301 PC1393 PC1394 = CAP WP
CI3 CI68 CI70-CI75 = CAP NP: room: JUSB3
CI13 CI16 CI76 = CAP NP: room: JUSB1
CI14 CI60-CI67 CI69 = CAP NP: room: JUSB2
CL1-CL15 CL280 CT370 CT371 CT377 CT379 CZ120 CZ513 CZ514 CZ518-CZ520 CZ524 CZ540 = CAP NP: room: LAN
CL16-CL22 CL199 = CAP NP: room: LOM
CL28 = CAP NP: room: +3.3V_LAN Source
CLIP1 CLIP2 = YDM_DH792_1P-T
CMOS1 = OPEN: User Part Number: PART#; room: PCH
CN1 CN2 = CAP NP: room: FFS
CN65-CN72 CN180-CN187 CN194-CN201 CN208-CN215 CR203-CR206 = CAP NP: room: SATA EXPRESS; signal model: C_0402_0.22U_0402_10V6K
CN174 CN177 CN178 CN188 CN189 CN192 CN202 CN205 CN206 CN216 CN218 CN221 CN276 CN280 CN281 CN283 CN287 CN289 CN295 CN299 CN300 CN306 CN311 CN313 CZ50 CZ52 CZ55 CZ56 CZ75 CZ198 CZ530 CZ531 CZ534 CZ535 = CAP NP: room: TPM
CN175 CN176 CN190 CN191 CN203 CN204 CN219 CN220 CN277 CN279 CN282 CN285 CN286 CN288 CN297 CN298 CN301 CN309 CN310 CN312 CV60-CV64 CV75 CV857 CV858 CV881 CV882 CV901 CV911 CV912 CV916 CV917 CV920 CV921 CV925 CV926 CV930 CV931 CV935 CV938 CV940 CV942 CV947 CV949 CV952 CZ532 CZ533 CZ542 CZ543 = CAP NP: room: DP12412
CR217 CR221 CR222 CR230 CR234 CR239 CR242 CR247 CR251 CR254 = CAP NP: room: RTS5243
CR255 = CAP NP: room: HDMI
CT1 = P_CAP NP: room: TBT; signal model: C_0201_0.1U_0201_10V6K
CT10-CT19 CT178-CT187 = CAP NP: room: TBT; signal model: C_0201_0.1U_0201_10V6K
CT20 CT21 CT67 = P_CAP NP: room: TBT
CT342 CT344 CT345 CT347 CT348 CT350-CT354 CT383 CT384 = CAP NP: room: TBT_CCG5
CT355 CT357 = CAP NP: room: TBT_PD
CT375 CT376 = P_CAP NP: room: 3V_LDO
CT378 CT380 CZ20 CZ526 PC24 PC30 PC101-PC106 PC109 PC112 PC120-PC126 PC128 PC129 PC138 PC205 PC300 PC303-PC305 PC307-PC310 PC312-PC314 PC400 PC403 PC404 PC406 PC506-PC512 PC514 PC515 PC520-PC523 PC525-PC527 PC529 PC703 PC708 PC709 PC713-PC716 PC725 PC802 PC803 PC900 PC901 PC905 PC906 PC1100-PC1112 PC1114-PC1116 PC1118-PC1129 PC1131-PC1133 PC1135-PC1137 PC1140 PC1208-PC1211 PC1213-PC1216 PC1219-PC1226 PC1229-PC1236 PC1239-PC1246 PC1324-PC1392 PC1401-PC1421 PC1515-PC1536 PC1610-PC1617 PC1702-PC1713 PC1802-PC1809 PC2019 PC2020 PC2022-PC2024 PC2026 PC2104 PC2106 = P_CAP NP
CV1-CV6 CV845-CV848 = CAP NP: room: eDP
CV15 CV16 CV20 CV844 CV849 = CAP NP: room: LVDS
CV65-CV74 CV814-CV838 CV854-CV856 CV860-CV880 CV883-CV898 CV908-CV910 CV913-CV915 CV918 CV919 CV922-CV924 CV927-CV929 CV932-CV934 CV936 CV937 CV939 CV941 CV943-CV946 CV948 CV950 CV951 = CAP NP: room: DP/HDMI DEMUX
CV427-CV458 = CAP NP: room: GPU
CV805 CV809-CV811 CV902 CV903 CZ505 CZ510 = CAP NP: room: MXM
CV806 CZ506 CZ515-CZ517 = CAP NP: room: +3.3V_RUN_Source
CV812 CZ130 = CAP NP: room: HDD
CZ37 = CAP NP: room: SIM
CZ51 CZ53 CZ54 = CAP NP: room: TPM; signal model: C_0201_0.1U_0201_10V6K
CZ61 CZ69 CZ71-CZ73 = CAP NP: room: USH
CZ64 CZ66-CZ68 = CAP NP: room: USH; signal model: C_0201_0.1U_0201_10V6K
CZ82 = CAP NP: room: RSMRST; signal model: C_0201_0.1U_0201_10V6K
CZ90-CZ92 = CAP NP: room: KB/TP
CZ93 = CAP NP: room: LED; signal model: C_0201_0.1U_0201_10V6K
CZ100 CZ101 = CAP NP: room: +1.0V_VCCST
CZ102 CZ200 = CAP NP: room: +VCCPLL_OC
CZ105 CZ106 = CAP NP: room: +1.0V_VCCSTG
CZ129 = CAP NP: room: HDD; signal model: C_0201_0.1U_0201_10V6K
CZ157 CZ164 = CAP WP: room: WWAN
CZ199 = CAP NP: room: +VCCPLL_OC; signal model: C_0201_0.1U_0201_10V6K
CZ509 CZ511 = CAP NP: room: CAM
CZ523 = CAP NP: room: +5V_RUN source
CZ527 = CAP NP: room: LED
CZ541 = CAP NP: room: PWR SW
DA1 DA2 DA6 DA7 = AZ5125-02S.R7G_SOT23-3: room: CODEC
DA3 = AZ5123-02S.R7G_SOT23-3
DA8 DE2 DH1 DH2 DZ1 DZ2 DZ5 DZ6 DZ8 = RB751S-40_SOD523-2
DI1 DI4 DI6 DT7 DT8 DT11 DT12 = AZ1045-04F_DFN2510P10E-10-9: room: JUSB1
DI2 DI3 DI5 DV41 = PESD5V0U2BT_SOT23-3
DT1-DT3 DT16 = SDMP0340LAT-7-F_SOT-523-3
DT4 DT59 = P_PESD24VS2UT_SOT23-3: room: DCIN
DT5 DT6 DT9 DT10 DT13 DT14 DT17 DT18 DT43-DT45 DT48 DT51-DT54 = AZ5B75-01B.R7G_CSP0603P2Y2
DT60 DT62-DT64 = RB520SM-30T2R_EMD2-2: room: 3V_LDO
DT2001-DT2008 = SBR1A20T5-7_SOD523-2-2
DV3 = BAT54CW_SOT323-3~D: room: LVDS
DV4 = AZ5125-02S.R7G_SOT23-3
DV32-DV34 DV43 DV44 = RB751VM-40TE-17_SOD323-2~D: room: MXM
DV35-DV40 DV42 = RB751VM-40TE-17_SOD323-2~D: room: LVDS
DZ9 = BAT54CW_SOT323-3~D: room: LCD
DZ12 = RB751S40T1G_SOD523-2
DZ20 DZ21 = P_BZV55-B5V1_SOD80C2
FD1-FD6 = FIDUCIAL MARK: room: LED
FV1 = 1.5A_65V_T0603FF1500TM
FZ1 FZ2 = 1A_65V_T0603FF1000TM
H1 H3-H9 H11-H19 H21-H23 = HOLE: room: LED
H20 = HOLE: room: HS
JAPS1 = ACES_3: room: CPU
JCCG1 = ACES_50521-01041-P01
JDEG1 JESPI = JXT_FP241AH-010GAAM_0
JDG1 = P_BELLW_0
JDGFF1-JDGFF4 = UNIMI_FBGCAX011_0
JDIMM1 = LOTES_ADDR0107-P005A_0: room: RAM
JDIMM2 JDIMM3 = BELLW_2
JDIMM4 = LOTES_ADDR0107-P005A_0
JEDP1 = ACES_50398-04041-001
JFAN1 = ACES_50271-0040N-001: room: FAN
JFAN2 = ACES_50271-0040N-001
JHP1 = SINGA_2
JIR1 = ACES_4
JKBTP1 = CVILU_CF2020FV0RK-NH
JLED1 = CVILU_CF2006FV0RK-NH
JLOM1 = SANTA_0
JNGFF1 = BELLW_4
JNGFF2 = LOTES_APCI0071-P001A_1
JNGFF3 JNGFF5 JNGFF6 = BELLW_SD-80159-4221_1
JNGFF4 = LOTES_AP-APCI0356-P001A~D_0
JPB1 = HRS_TF31-6S-0P5SH_0
JRTC1 = ACES_2: room: P_DCIN
JSD1 = T-SOL_1
JSIM1 = T-SOL_0
JSPI1 = ACES_50559-02001-001
JSPK1 = ACES_50271-0060N-001
JTAG1 = OPEN: User Part Number: PART#; room: KBC
JUSB1 JUSB2 = SINGA_0
JUSB3 = ACON_TCR2C-9U1U91_1: room: USB3.0
JUSBC1 = FOX_UT12113-1160D-7H~D_0
JUSH1 = HRS_TF31C-26S-0P5SH-800
JXDP1 = JXT_FP270H-061G1AM
L1 LV2 = MCM1012B900F06BP_4P
LA6-LA12 LA14-LA16 LA21 LA27 = L: room: CODEC
LC1-LC3 = L: room: PCH
LC562 LH421 LH423 = L: room: SOC
LGA1 = LNG2DMTR_LGA12_0
LI3 LI4 LI7 = MCM1012B900F06BP_4P: room: USB3.0
LI16 LI17 = DLW21HN900HQ2L_4P: room: JUSB1
LL1 = L: room: LAN
LR1 PL1 PL2 PL5-PL9 PL100 PL300 PL400 PL501 PL701 PL801 PL900 = P_L
LT2 LT10 = L: room: TBT
LV1 = L: room: LCD
LV4-LV13 = L: room: DP/HDMI DEMUX
PBATT1 = P_DEREN_0
PC1 PC5 PC8 PC9 PC11 PC15 PC16 PC18 PC2007-PC2018 PC2100 PC2102 = P_CAP NP: room: DCIN
PC2 PC4 PC21 PC25 = P_CAP NP_1: room: P_DCIN
PC3 PC12 PC19 = P_CAP NP_10: room: DCIN
PC6 PC13 PC20 = P_CAP NP: room: P_USBA
PC7 PC10 PC14 PC17 PC2105 = CAP NP: room: DCIN
PC22 PC2003 = P_CAP NP: room: P_DCIN
PC23 PC207 PC806 PC1204 PC1205 PC1500 = P_CAP WP
PC100 PC107 PC108 PC110 PC111 PC113-PC119 PC127 PC500-PC505 PC513 PC524 PC528 PC530-PC533 PC2103 = P_CAP NP: room: 3_5V
PC201 PC203 PC204 = P_CAP NP_1: room: P_1.35V0.675V
PC208 = CAP NP: room: P_1.35V0.675V
PC301 = P_CAP NP: room: CHARGER
PC401 PC402 PC405 PC902-PC904 = P_CAP NP: room: 1.8V
PC700 PC702 PC706 PC707 PC710-PC712 PC717 = P_CAP NP_1: room: P_Charger
PC701 PC704 PC705 PC718-PC720 = P_CAP NP: room: P_Charger
PC800 PC801 PC804 = P_CAP NP_1: room: P_1.05V
PC805 PC807 PC808 = P_CAP NP: room: P_1.05V
PC1130 = P_CAP NP: room: CPU_CORE
PC2021 PC2025 = P_CAP NP: room: Charger
PD1 = P_SBR3A40SA-13_SMA2: room: P_Charger
PD2 = SF10402ML080C_0402: room: P_DCIN
PD3 = P_L03ESDL5V0CC3-2_SOT23-3
PD4 PD6 = P_SS5P10-M3-86A_TO277A3
PD8 = P_RB715FGT106_UMD3: room: P_DCIN
PD9 PD10 = TVNST52302AB0_SOT523-3: room: P_DCIN
PD11-PD15 PD700 PD701 = BAT54CW_SOT323~D: room: P_Charger
PD200 PD2004 PD2005 = P_SDMK0340L-7-F_SOD323-2~D: room: P_selector
PD702 = P_MM3Z22VST1G_SOD323-2: room: P_Charger
PH1100 = P_100K_0402_1%_TSM0B104F4251RZ
PH1101-PH1104 = P_220K_0402_5%_ERTJ0EV224J
PJP1 PJP2 PJP6 PJP12 = PAD-OPEN: room: TBT
PJP3 PJP39 = P_JUMP_43X118: room: +3.3V_RUN_Source
PJP5 = P_JUMP_43X118: room: TBT
PJP17 = PAD-OPEN: room: UZ4
PJP18 = PAD-OPEN: room: CODEC
PJP19 = PAD-OPEN: room: UZ2
PJP20 PJP22 = PAD-OPEN: room: KBC
PJP27 = PAD-OPEN: room: JUSB2
PJP28 = PAD-OPEN: room: JUSB3
PJP30 PJP62 = P_JUMP_43X118: room: +3.3V_SSD1_Source
PJP32 = PAD-OPEN: room: HDD
PJP35 = PAD-OPEN: room: TP
PJP36 = P_JUMP_43X118: room: +3.3V_ALW_PCH_Source
PJP37 = P_JUMP_43X118: room: +3.3V_LAN_Source
PJP38 = P_JUMP_43X118: room: +3.3V_SUS source
PJP40 = PAD-OPEN: room: +5V_RUN source
PJP42 = P_JUMP_43X118: room: +1.8V_RUN_source
PJP43 = P_JUMP_43X118: room: +3.3V_MXM_Source
PJP63 PJP64 = P_JUMP_43X118: room: +3.3V_SSD2 source
PJP65 = P_JUMP_43X118: room: +5V_MXM_Source
PJP66 = P_JUMP_43X118: room: +1.2V_RUN_Source
PJP67 PJP301 = P_JUMP_43X118
PJP69 = PAD-OPEN: room: RTS5242
PJP100 PJP102 PJP500 PJP503 = VCCPAD: room: DDR_VTT_0.75V
PJP101 PJP103 PJP300 PJP400 PJP401 PJP501 PJP502 = P_JUMP_43X118: room: 1.5V
PJP200 = VCCPAD: room: P_1.35V0.675V
PJP202 PJP203 = P_JUMP_43X118: room: P_1.35V0.675V
PJP204 = PAD-OPEN: room: P_1.35V0.675V
PJP391 = PAD-OPEN: room: TPM
PJP700 PJP701 = PAD-OPEN: room: Charger
PJP800 = VCCPAD: room: P_1.05V
PJP801 = PAD-OPEN: room: P_3V5V
PJP900 PJP901 = PAD-OPEN: room: VGA_CORE
PJPDC1 = ACES_50493-0110N-001: room: P_DCIN
PL4 PL11 PL12 = P_L: room: P_DCIN
PL101 PL500 = P_L: room: VDDCI
PL201 = P_L: room: 1.35V_0.675V
PL700 = P_L: room: P_Charger
PL1200 PL1201 = P_L: room: PWR_SUPPORT
PL1202-PL1205 PL1700 = P_0.15UH_PCME064T-R15MS_36A_20%
PL1800 = P_0.47UH_MMD05CZR47M_12A_20%
PQ1 PQ4 PQ7 PQ2008 PQ2009 PQ2109-PQ2112 = P_DMN65D8LDW-7_SOT363-6
PQ2 PQ3 PQ5 PQ6 PQ8 PQ9 PQ2007 PQ2102 PQ2106 = P_DMN65D8LDW-7_SOT363-6: room: DCIN
PQ10 PQ11 PQ700 = P_AON6405L_DFN8-5_0
PQ12 PQ13 PQ19 PQ20 PQ24 PQ25 PQ705 = P_NTR4502PT1G_SOT23-3~D: room: DCIN
PQ14 PQ2108 = P_FDV301N_NL_SOT23-3~D: room: P_DCIN
PQ16 = MMST3904-7-F_SOT323~D: room: P_DCIN
PQ17 PQ18 PQ22 PQ23 QZ19 = P_SI4483ADY-T1-GE3_SO8_0
PQ26 = P_2N7002KW_SOT323-3
PQ200 PQ702 = P_PK616BA_PDFN8-5_0
PQ201 PQ703 = P_PK632BA_PDFN8-5_0
PQ701 = P_AON6426_DFN5X6-8-5_0
PQ704 = 2N7002DW-T-R7_SOT363-6: room: P_Charger
PQ800 = P_AON7408L_DFN8-5_0
PQ801 = P_AON7752_DFN3X3EP8-5_0
PQ2001-PQ2006 PQ2012 = DMN65D8LDW-7_SOT363-6
PQ2010 = DMN65D8LW-7_SOT323-3
PQ2100 PQ2104 = P_AON7401_DFN8-5_0
PQ2101 PQ2105 = P_DMP3099L-7_SOT23-3
PR1-PR4 PR6-PR9 PR25-PR29 PR31-PR34 PR43-PR48 PR50-PR52 PR731-PR734 PR2022-PR2035 PR2037-PR2042 PR2053 PR2056 PR2063 PR2064 PR2100 PR2101 PR2104 PR2105 PR2108 PR2109 PR2134 PR2142 PR2158 PR2159 = P_R: room: DCIN
PR10-PR12 PR14 PR19 PR21 PR24 PR61 PR62 PR2054 PR2055 PR2143-PR2149 = P_R: room: P_DCIN
PR13 PR15-PR17 PR23 PR35 PR36 PR38 PR41 PR53-PR55 PR60 PR101 PR102 PR104 PR105 PR111 PR113 PR304 PR306 PR309 PR310 PR401 PR501 PR505 PR514 PR703 PR704 PR710 PR711 PR713 PR714 PR717-PR719 PR724 PR810 PR811 PR901 PR906 PR1106 PR1108 PR1115 PR1121 PR1122 PR1126 PR1128 PR1165 PR1166 PR1198 PR2009 PR2019 PR2020 PR2036 PR2065 PR2066 PR2106 PR2150 PR2152-PR2157 PR2161 PR2162 = P_R-SHORT
PR18 PR20 PR22 PR39 PR40 PR42 PR57-PR59 PR70-PR72 PR74-PR76 PR2003 PR2005 PR2007 PR2008 PR2010 PR2016 PR2018 PR2021 PR2151 PR2163 = P_R: room: P_Selector
PR64 PR207 PR809 PR1107 RE343 RE362 RH330 RH360 RH361 RH376 RH604 RH605 RH617 RH733 RI49 RI50 RR227 RT440 RT447 RT535-RT537 RT571 RT575 RT585-RT588 RT611 RV907 RV908 RV911 RZ3 RZ4 RZ22 RZ23 RZ28 RZ32 RZ70 RZ361 RZ363 RZ366 RZ369 RZ1484 = R
PR65-PR67 PR103 PR106 PR109 PR114 PR115 PR206 PR209 PR300 PR307 PR308 PR311 PR312 PR404 PR506-PR510 PR513 PR720 PR721 PR729 PR807 PR808 PR904 PR1100-PR1105 PR1109-PR1114 PR1116-PR1120 PR1123-PR1125 PR1127 PR1129-PR1146 PR1148-PR1158 PR1160 PR1161 PR1163 PR1164 PR1167-PR1171 PR1199-PR1223 PR1700-PR1703 PR1800-PR1802 PR2047 PR2048 PR2050 PR2051 PR2059-PR2062 RT39 RT565 RT566 RT573 RT577 RV901 RZ518 RZ541 RZ1413 RZ1482 = P_R
PR100 PR112 PR502 PR511 = P_R: room: 1.5V
PR107 PR110 PR500 PR515 = P_R: room: 1P5V
PR108 PR512 = P_R: room: 3_5V
PR200-PR203 PR205 PR208 PR210 = P_R: room: P_1.35V0.675V
PR204 = P_R: room: CPU_CORE
PR301 = P_R: room: CHARGER
PR302 = P_R: room: P_3V5V
PR303 RC1 RC2 RC5-RC7 RC66 RC71 RC74 RC78-RC80 RC83 RC84 RC114 RC152 RC153 RC157 RC166 RC168 RC171 RC177 RC181 RC221 RC239 RC240 RC321-RC325 RC436-RC444 RC560 RC561 RE95 RE349 RE736-RE738 RH1 RH156 RH250 RH267 RH268 RH295 RH311 RH355 RH379 RH435 RH439 RH718-RH721 RH731 RI94 RI95 RT526 RT527 RV741 RZ20 RZ21 RZ151 = R: room: CPU
PR313 PR314 PR702 = P_R: room: Charger
PR400 PR402 PR403 PR405 PR900 PR902 PR903 PR905 = P_R: room: 1.8V
PR700 PR715 = P_R~D: room: P_Charger
PR701 PR705 PR706 PR708 PR712 PR716 PR722 PR723 PR725-PR728 PR730 PR735 PR803 PR812 = P_R: room: P_Charger
PR707 = P_R_0: room: P_Charger
PR709 = R: room: P_Charger
PR800-PR802 PR804 PR805 = P_R: room: P_1.05V
PR2014 = P_R: room: P_USBB
PU1 = TC7SH08FU_SSOP5~D: room: DCIN
PU100 PU501 = P_SY8288BRAC_QFN20_0
PU101 PU500 = P_SY8288CRAC_QFN20_0
PU200 = P_RT8207PGQW_WQFN20_3X3
PU300 = P_NB681GD-Z_QFN13_2X3
PU400 PU900 = P_G5719CRC1U_TDFN8_0
PU700 = BQ24780_1: room: P_Charger
PU800 = P_TPS51212DSCR_SON10_3X3: room: P_1.05V
PU1100 = P_NCP81215DMNTXG_QFN52_0
PU1200-PU1203 PU1700 PU1800 = P_NCP302035MNTXG_PQFN33_0
PU2001 PU2003 PU2004 = P_LM393DGKR_VSSOP8
PWRSW1 = OPEN_0: User Part Number: PART#; room: PWR SW
QA10 = L2N7002WT1G_SC-70-3: room: CODEC
QE2 QH4 QV23 QV44 QZ17 QZ18 = P_L2N7002DW1T1G_SC88-6
QE3 QE4 QE6 QE7 QE26 QE104 QZ22 = LMBT3904WT1G_SC70-3
QE11 QE12 QL7 QR1 QT1 QT5-QT9 QV2 QV40-QV43 QZ7 QZ15 QZ21 = L2N7002WT1G_SC-70-3
QE15 QH7 QZ1 = PJ2301_SOT23-3
QE17 = L2N7002WT1G_SC-70-3: room: RTC_2
QH6 = L2N7002WT1G_SC-70-3: room: DSW_2
QL1 QN1 QT4 QV30 = 2N7002KDW_SOT363-6
QT2 QT3 = SI1303DL-T1-E3_SOT323-3~D: room: 3V_LDO
QT10 = P_EMB80P03JS_SOT-23-3
QV1 = AO6405_TSOP6
QZ3 = LMUN5111T1G_SC70-3
QZ20 = P_DMN3150LW-7_SOT323-3
R127 R129 RZ78-RZ81 = R: room: WLAN
R128 RZ537-RZ540 = R: room: WWAN
RA5-RA9 RA12-RA14 RA17 RA18 RA44 RA52 RA209 RA214 RA219 RA220 RA224 RA225 RV900 = R: room: CODEC
RA48 RA201 RA221-RA223 RA226-RA228 RC127 RC143 RC144 RC169 RC178 RC179 RC216 RC228-RC230 RC304 RC314 RC315 RC319 RC326 RD16 RD76-RD90 RD92-RD94 RE30 RE32 RE59 RE90 RE275 RE290 RE318 RE506 RE548 RE552 RE747 RE749 RH6 RH37 RH43 RH66 RH100 RH154 RH155 RH161 RH166-RH170 RH215 RH237 RH240 RH242 RH246 RH247 RH254 RH256-RH260 RH279 RH286-RH288 RH290 RH292-RH294 RH297-RH300 RH302-RH306 RH365 RH440 RH442 RH445 RH616 RH619 RH622 RH626 RH732 RL3 RL7 RL8 RL10 RL71-RL78 RN99 RN205 RN207 RN213 RN219 RN220 RN475 RN476 RR200 RR228-RR231 RR233 RR234 RT120-RT123 RT385-RT388 RT392 RT441 RT448 RT456 RT499-RT501 RT538-RT542 RT547 RT549 RT550 RT570 RT574 RT606-RT609 RT619 RT620 RV485 RV800 RV808 RV809 RZ26 RZ29 RZ61 RZ89 RZ112 RZ120 RZ346 RZ347 RZ365 RZ368 RZ509 RZ510 RZ522 RZ545 RZ549 RZ1415 = R-SHORT
RA50 RA213 = R: room: UZ8
RC75 = R: room: RSMRST
RC115 RC121 RC122 RC124 RC126 RC128 RC129 RC132 RC133 RC135-RC139 RC217-RC219 RC241 RH180 = R: room: CPU XDP
RC366-RC369 RH38 RH39 RH42 RH44-RH46 RH48 RH50 RH56 RH57 RH61 RH65 RH67 RH70 RH73-RH78 RH80 RH81 RH83 RH86 RH90 RH94 RH95 RH97 RH99 RH101 RH110 RH171 RH192 RH193 RH198-RH201 RH203 RH204 RH214 RH221-RH225 RH239 RH241 RH243 RH255 RH291 RH296 RH308-RH310 RH324 RH327-RH329 RH331 RH339 RH340 RH349 RH350 RH364 RH373 RH378 RH380 RH402 RH424 RH441 RH443 RH600-RH602 RH609-RH615 RH628 RH630 RH730 RH734-RH736 RR232 RR235 RT503 RT510 RT511 RT514 RT515 RT569 RV819 RZ550 RZ551 = R: room: PCH
RC370 = P_R: room: CPU
RC562 RH446 RT525 RT534 RT623 RT624 = R: room: TBT_CCG5
RD4 RD7-RD12 RD14 RD15 RD17 RD18 RD21-RD24 RD29-RD34 RD36 RD37 RD40 RD42 RD43 RD45 RD46 RD48 RD51 = R: room: MEMORY
RE8 RE10-RE12 RE20 RE21 RE25 RE26 RE35 RE38 RE83 RE84 RE91 RE93 RE94 RE274 RE365 RE505 RE507 RE508 RE526 RE532 RE549 RE550 RE561 RE563 RE565-RE568 RE700 RE701 RE732-RE735 RE748 RE750 RH606-RH608 RT516 RT518 RT523 RT524 RT567 RT568 RT583 RT584 RT617 RT618 RZ364 = R: room: SIO
RE31 RE33 RE37 RE43 RE55-RE58 RE60 RE63-RE65 RE67-RE75 RE77 RE86 RE280 RE288 RE292 RE300 RE302-RE304 RE306 RE312-RE314 RE342 RE536 RE551 RE557 RE564 RE569 RE570 RE702 RE703 RE730 RE731 RE739-RE743 RE745 RE746 RH371 RH372 RH400 RH401 RH553-RH556 RH710-RH717 RV739 RV740 RZ542 RZ543 = R: room: KBC
RE79 RI13 RI14 RI60-RI66 RI69 RI72-RI77 = R: room: JUSB2
RE350 RE539 RH28-RH30 RH334 RH335 RH351-RH353 RH722-RH729 RV737 RV738 RV742 = R: room: SPI ROM
RE541 RE543 RE546 = R: room: RTC_2
RH92 RH123 RH124 RH126-RH128 RH130-RH134 RH153 RH325 RH326 RH603 = P_R: room: PCH
RH93 RH319 RT16 RT17 RT517 RT519 RT521 RT522 RT528 RT591 RT592 RT610 RT613 RT643 = P_R: room: TBT
RH152 RH436 RT557 RT558 RT561 RT562 RZ523-RZ530 = R: room: TBT_CCG5; signal model: R_0201_0_0201_5%
RH177 RH623 = R: room: SPI ROM; signal model: R_0201_0_0201_5%
RH178 RH179 RH181 RH183 RH184 RZ372-RZ374 = R: signal model: R_0201_0_0201_5%
RH182 RH624 RH625 RT551 RT552 RT555 RT556 RT559 RT560 RT579-RT582 RT589 RT590 RT594-RT601 = R-SHORT: signal model: R_0201_0_0201_5%
RH185 RZ119 = R: room: +VCCPLL_OC
RH312-RH315 RH333 RH374 RH629 RH631-RH641 = R: room: PCH XDP
RH431-RH433 = R: room: DSW_2
RI27-RI30 RR236-RR239 RT1-RT8 RT11 RT20 RT23 RT26 RT27 RT33 RT34 RT36 RT184 RT372 RT391 RT502 RT505-RT509 RT529 RT553 RT554 RT593 RT614-RT616 RT644 RZ128-RZ130 = R: room: TBT
RI67 RI68 RI70 RI71 RI78 RI80 RI81 RI83 RI85 RI86 RI88-RI93 = R: room: JUSB3
RI79 RI82 RI84 RI87 = R: room: JUSB1
RL1 RL2 RL5 RL6 RL9 RL12 RL13 RL29 RL30 RL50 = R: room: LAN
RL14-RL20 = R: room: LOM
RL34 RN216-RN218 RN474 RT9 RT37 RT40 RT394 RT578 RZ56 RZ548 = R: room: Flash ROM
RN1 RN2 RT564 = R: room: FFS
RN37 RN200 RN202 RN203 RN208 RN210 RN211 = R: room: SSD
RR201 RR205 RR211 RR213 = R: room: RTS5242
RT41 RT42 = R: room: GPU
RT445 RT612 RT621 RT622 = R: room: AR
RT512 = P_R: room: TBT_CCG5
RT543-RT546 RT548 = P_R: room: 3V_LDO
RV3-RV5 RV843 = R: room: LVDS
RV7 RV822-RV831 RV833-RV836 RV839 RV848-RV853 RV856-RV858 RV861-RV868 RV870-RV888 RV891-RV896 = R: room: DP/HDMI DEMUX
RV50 RV55-RV66 RV125-RV127 RV130 RV131 = R: room: DP12412
RV803-RV807 RV812 RV813 RV815-RV818 RV820 RV821 RV904 RV905 = R: room: MXM
RV832 RV855 RV869 RV889 RV890 RV897 RV898 RV902 RV903 = R: room: DP_SW
RV840 RV842 RV909 RV910 = R: room: eDP
RZ8-RZ10 RZ85 RZ114 RZ1483 = R: room: USH
RZ18 RZ19 RZ116 RZ117 = R: room: KBTP
RZ25 = R: room: LED
RZ43 RZ58-RZ60 RZ62 RZ63 RZ69 RZ362 RZ367 RZ375-RZ379 RZ381 RZ1385 = R: room: TPM
RZ71 = R: room: UZ2
RZ371 = R: room: Flash ROM; signal model: R_0201_0_0201_5%
RZ504 RZ505 RZ507 RZ508 = R: room: Thermal
RZ512-RZ514 RZ547 = R: room: MXM_PWR_SRC Source
RZ531-RZ536 = R: room: WLAN; signal model: R_0201_0_0201_5%
SW1 = SS3-CMFTQR9_3P: room: PCH
SW3 = SKRBAAE010_4P~D: room: SWITCH
T1-T15 T18-T32 T46-T53 T75-T77 T258 T268 T269 T281 T284 T285 T287-T291 T294 T295 T297-T307 T315-T319 = PAD_1: room: CPU
T33-T36 T40 T179-T181 T184 T185 T189 T190 T194 T199 T309 T313 T314 = PAD_0: room: CPU
T60-T63 T178 = PAD_0: room: PCH
T73 T74 = PAD_0: room: LAN
TL1 = MHPC_NS692417
UA1 = ALC3281-CG_MQFN48_6X6
UC1 = CFL-H_BGA1440: room: CPU
UC3 = TC7SH09FU_SSOP5
UC5 = W25Q256JVEIQ_WSON8_8X6
UC6 = MX25L25645GM2I-10G_SO8
UD1 UE4 UE11 UV69 UZ61 = 74AUP1G07GW_TSSOP5
UE1 = MEC5105_WFBGA169_11X11
UE3 UE5 UH7 UT34 UZ6 UZ10 UZ34 UZ35 = MC74VHC1G08DFT2G_SC70-5
UE12 = IT8306FN-CX-R_QFN28_4X4
UH1 = CNP-H_BGA874_1
UI1-UI3 = SLGC55544CVTR_TQFN16_3X3
UI4 UI5 = PS8713BTQFN24GTR2-A_TQFN24_0
UL1 = WGI219LM-SLKJ2-A0_QFN48_6X6~D
UL2 UZ60 = SN74AHC1G08DCKR_SC70-5
UR1 = RTS5243-GR_QFN48_0
UR3 = W25X40CLSSIG_SO8
UR4 UZ19 UZ21 UZ26 = EM5201V_DFN3X3-8-X
UT1 = THUNDERBOLT_BGA337_0
UT2 = W25Q80DVSSIG_SO8: room: TBT
UT5 = CCG5_5: room: TBT_CCG5
UT7 = P_RT9069-33GB_SOT23-5: room: 3V_LDO
UT9 UT11 = DPS1113FIA-13_QFN18_4X4: room: TBT_CCG5
UT10 UT12 = 74AUP1G02GW_TSSOP5: room: TBT_CCG5
UT32 = TS5A3159ADCKR_SC70-6
UV8 = PS8338BQFN60GTR-A1_QFN60_0
UV24 = G524B1T11U_SOT23-5
UV60 = MC74VHC1G09DFT2G_SC70-5
UV61-UV63 = SN74AHC1G08DCKR_SC70-5: room: MXM
UV64 = PS8331BQFN60GTR-A0_QFN60_0
UV65 UV68 = M74VHC1GT125DF2G_SC70-5
UV66 UV67 = PS8461QFN66GTR-A0_QFN66_0
UZ7 UZ23 UZ42 UZ43 UZ45 UZ58 UZ59 = AOZ1336DI_DFN8_0
UZ9 UZ40 UZ41 UZ44 = EM5209VF_DFN14_0
UZ12 = NPCT750JABYX_QFN32_5X5
Y1 = 25MHZ_18PF_X3G025000DI1H-H~D_0: room: LAN
YE1 = 32.768KHZ_9PF_X1A000141000200
YH1 = 32.768KHZ_12.5PF_9H03200042: room: PCH
YH2 = 24MHZ_12PF_8Y24000034
YT1 = 25MHZ_20PF_FL2500123Z

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002KDW_SOT363-6
  oval 0.356x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.6) 5(0.65,1.6) 6(0,1.6)
5A_Z80_0805_2P
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
9A_Z80_1812_2P
  rect 1.803x3.404 smd: 1(0,0) 2(3.8,0)
74AUP1G02GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50228-0067N-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0)
  rect 1.194x1.803 smd: 7(1.3,2.525) 8(-6.3,2.525)
ACES_50271-0020N-001_2P
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(3.8,-2.9) 4(-2.55,-2.9)
ACES_50271-0040N-001_4P
  oval 0.787x1.6 smd: 1(0,0) 2(-1.25,0) 3(-2.5,0) 4(-3.75,0)
  rect 2.108x2.997 smd: 5(2.55,-2.9) 6(-6.3,-2.9)
ACES_50271-0060N-001_6P-T
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0) 5(5,0) 6(6.25,0)
  rect 2.108x2.997 smd: 7(-2.55,-2.9) 8(8.8,-2.9)
ACES_50398-04041-001_40P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.194x3.2 smd: 41(-2.4,1.95) 45(21.9,1.95)
  rect 2.311x1.295 smd: 42(0.85,3.9) 43(9.75,3.9) 44(18.65,3.9)
ACES_50493-0110N-001_11P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50521-01041-P01_10P
  oval 0.305x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.5) 12(5.5,-2.5)
ACES_50559-02001-001_20P
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3) 7(3,0) 8(3.5,3) 9(4,0) 10(4.5,3) 11(5,0) 12(5.5,3) 13(6,0) 14(6.5,3) 15(7,0) 16(7.5,3) 17(8,0) 18(8.5,3) 19(9,0) 20(9.5,3)
  rect 0.787x1.499 smd: 21(-1,0) 22(-1,3) 23(10.5,0) 24(10.5,3)
ACON_TCR2C-9U1U91_9P-T
  round 1.397 hole 0.787: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0) 5(7.5,1.5) 6(5.5,1.5) 7(3.5,1.5) 8(1.5,1.5) 9(-0.5,1.5)
  oval 1.295x2.21 hole 0.711x1.6: 10(-2.9,0) 11(9.9,0)
  oval 1.295x2.997 hole 0.711x2.388: 12(-4.35,-10.8) 13(11.35,-10.8)
ALC3281-CG_MQFN48_6X6
  oval 0.762x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(5.9,-4.4) 26(5.9,-4) 27(5.9,-3.6) 28(5.9,-3.2) 29(5.9,-2.8) 30(5.9,-2.4) 31(5.9,-2) 32(5.9,-1.6) 33(5.9,-1.2) 34(5.9,-0.8) 35(5.9,-0.4) 36(5.9,0)
  oval 0.254x0.762 smd: 13(0.75,-5.15) 14(1.15,-5.15) 15(1.55,-5.15) 16(1.95,-5.15) 17(2.35,-5.15) 18(2.75,-5.15) 19(3.15,-5.15) 20(3.55,-5.15) 21(3.95,-5.15) 22(4.35,-5.15) 23(4.75,-5.15) 24(5.15,-5.15) 37(5.15,0.75) 38(4.75,0.75) 39(4.35,0.75) 40(3.95,0.75) 41(3.55,0.75) 42(3.15,0.75) 43(2.75,0.75) 44(2.35,0.75) 45(1.95,0.75) 46(1.55,0.75) 47(1.15,0.75) 48(0.75,0.75)
  rect 4.394x4.394 smd: 49(2.95,-2.2)
AO6405_TSOP6
  oval 0.508x1.473 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
AOZ1336DI_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.499x0.889 smd: 9(0.75,1.1)
AZ5B75-01BPR7G_CSP0603P2Y2
  rect 0.279x0.381 smd: 1(0,0) 2(0.4,0)
AZ1045-04F_DFN2510P10E-10-9
  oval 0.254x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.381x1.549 smd: 3(1,0.437)
AZ5123-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAS40CW_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BELLW_80148-4221_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(3.75,-7.55) 9(4,0) 10(4.25,-7.55) 11(4.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
BELLW_80252-0521_5P-T
  oval 0.711x1.194 smd: 1(0,0) 2(-1.5,0) 3(-3,0) 4(-4.5,0) 5(-6,0)
  oval 1.041x1.6 hole 0.66x1.194: 6(-8.7,-1.35) 7(-8.7,-5.45) 8(2.7,-1.35) 9(2.7,-5.45)
BELLW_80888-2021_260P-T
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,16.1) 262(67.175,16.1)
BELLW_SD-80159-4221_67P-T
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
BQ24780RUYR_WQFN28_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.584 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1808
  rect 1.041x2.311 smd: 1(0,0) 2(4.35,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_D2E
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_T521D107M025ATE060
  rect 2.362x2.438 smd: 1(0,0) 2(6.24,0)
C_X
  rect 1.803x2.896 smd: 1(0,0) 2(6,0)
CFL-H_BGA_1440P-T
  round 0.406 smd: A3(-1.254,0) A37(-26.054,0) B2(-0.66,0.66) B38(-26.628,0.553) BR1(0,40.062) BR38(-26.628,40.036) BT2(-0.571,40.628) BT37(-26.037,40.628) C1(0,1.267)
  round 0.381 smd: A4(-1.971,0) A34(-24.46,0) A36(-25.272,0) B3(-1.382,0.699) B37(-25.909,0.703) BN1(0,38.614) BN38(-26.628,38.599) BP1(0,39.338) BP38(-26.628,39.31) BR2(-0.719,39.934) BR37(-25.904,39.927) BT3(-1.295,40.628) BT4(-2.019,40.628) BT35(-24.498,40.628) BT36(-25.311,40.628) C2(-0.699,1.361) C38(-26.628,1.334) D1(0,1.991) D38(-26.628,2.097)
  round 0.356 smd: A5(-2.771,0) A33(-23.66,0) B4(-2.031,0.971) B36(-25.198,0.701) BM1(0,37.814) BM38(-26.628,37.888) BN2(-0.65,38.642) BN37(-25.965,38.665) BP2(-0.828,39.28) BP37(-25.689,39.257) BR3(-1.387,39.978) BR36(-25.193,39.971) BT5(-2.819,40.628) BT34(-23.698,40.628) C37(-25.908,1.402) D3(-1.233,1.822) E1(0,2.779) E2(-0.65,2.474) E38(-26.628,2.897)
  round 0.33 smd: A6(-3.546,0) A32(-22.872,0) B5(-2.743,0.65) B34(-24.443,0.67) BK1(0,37.037) BL2(-0.65,37.438) BL38(-26.628,37.176) BM2(-0.963,38.053) BM37(-25.978,37.986) BN3(-1.3,38.701) BN36(-25.314,38.638) BP3(-1.483,39.334) BP35(-24.561,39.328) BR5(-2.166,39.984) BR34(-23.774,39.978) BR35(-24.536,39.978) BT6(-3.594,40.628) BT32(-22.923,40.628) C36(-25.145,1.388) D4(-1.894,1.655) D37(-25.603,1.985) E3(-1.3,2.474) E37(-25.978,2.604) F2(-0.65,3.16) G1(0,3.581) G38(-26.628,3.671)
  round 0.305 smd: A8(-4.318,0) A9(-5.105,0) A10(-5.893,0) A11(-6.68,0) A12(-7.468,0) A13(-8.255,0) A14(-9.042,0) A15(-9.83,0) A16(-10.617,0) A17(-11.405,0) A18(-12.192,0) A19(-12.979,0) A20(-13.767,0) A21(-14.554,0) A22(-15.342,0) A23(-16.129,0) A24(-16.916,0) A25(-17.704,0) A26(-18.491,0) A27(-19.279,0) A28(-20.066,0) A29(-20.853,0) A30(-21.844,0) AA1(0,14.019) AA2(-0.65,14.019) AA3(-1.3,14.019) AA4(-1.951,14.019) AA5(-2.601,14.019) AA6(-3.251,13.968) AA7(-3.911,14.548) AA8(-4.561,14.548) AA9(-5.212,14.548) AA10(-5.862,14.548) AA11(-6.512,14.548) AA12(-7.162,14.548) AA13(-7.813,14.548) AA14(-8.463,14.548) AA29(-20.725,14.415) AA30(-21.376,14.415) AA31(-22.077,14.415) AA32(-22.727,14.415) AA33(-23.377,14.415) AA34(-24.027,14.415) AA35(-24.678,14.415) AA36(-25.328,14.415) AA37(-25.978,14.415) AA38(-26.628,14.415) AB1(0,14.756) AB2(-0.65,14.756) AB3(-1.3,14.756) AB4(-1.951,14.756) AB5(-2.601,14.756) AB6(-3.251,14.806) AB29(-20.725,15.203) AB30(-21.376,15.203) AB31(-22.077,15.203) AB32(-22.727,15.203) AB33(-23.377,15.203) AB34(-24.027,15.203) AB35(-24.678,15.203) AB36(-25.328,15.203) AB37(-25.978,15.203) AB38(-26.628,15.203) AC1(0,15.645) AC2(-0.65,15.645) AC3(-1.3,15.645) AC4(-1.951,15.645) AC5(-2.601,15.645) AC6(-3.251,15.645) AC7(-3.911,15.463) AC8(-4.561,15.463) AC9(-5.212,15.463) AC10(-5.862,15.463) AC11(-6.512,15.463) AC12(-7.162,15.463) AC13(-7.813,15.463) AC14(-8.463,15.463) AC29(-20.725,15.99) AC30(-21.376,15.99) AC31(-22.077,15.99) AC32(-22.727,15.99) AC33(-23.377,15.99) AC34(-24.027,15.99) AC35(-24.678,15.99) AC36(-25.328,15.99) AC37(-25.978,15.99) AC38(-26.628,15.99) AD1(0,16.534) AD2(-0.65,16.534) AD3(-1.3,16.534) AD4(-1.951,16.534) AD5(-2.601,16.534) AD6(-3.251,16.483) AD7(-3.911,16.377) AD8(-4.561,16.377) AD9(-5.212,16.377) AD10(-5.862,16.377) AD11(-6.512,16.377) AD12(-7.162,16.377) AD13(-7.813,16.377) AD14(-8.463,16.377) AD29(-20.725,16.777) AD30(-21.376,16.777) AD31(-22.077,16.777) AD32(-22.727,16.777) AD33(-23.377,16.777) AD34(-24.027,16.777) AD35(-24.678,16.777) AD36(-25.328,16.777) AD37(-25.978,16.777) AD38(-26.628,16.777) AE1(0,17.27) AE2(-0.65,17.27) AE3(-1.3,17.27) AE4(-1.951,17.27) AE5(-2.601,17.27) AE6(-3.251,17.321) AE7(-3.911,17.291) AE8(-4.561,17.291) AE9(-5.212,17.291) AE10(-5.862,17.291) AE11(-6.512,17.291) AE12(-7.162,17.291) AE13(-7.813,17.291) AE14(-8.463,17.291) AE29(-20.725,17.565) AE30(-21.376,17.565) AE31(-22.077,17.565) AE32(-22.727,17.565) AE33(-23.377,17.565) AE34(-24.027,17.565) AE35(-24.678,17.565) AE36(-25.328,17.565) AE37(-25.978,17.565) AE38(-26.628,17.565) AF1(0,18.159) AF2(-0.65,18.159) AF3(-1.3,18.159) AF4(-1.951,18.159) AF5(-2.601,18.159) AF6(-3.251,18.159) AF7(-3.911,18.206) AF8(-4.561,18.206) AF9(-5.212,18.206) AF10(-5.862,18.206) AF11(-6.512,18.206) AF12(-7.162,18.206) AF13(-7.813,18.206) AF14(-8.463,18.206) AF29(-20.725,18.352) AF30(-21.376,18.352) AF31(-22.077,18.352) AF32(-22.727,18.352) AF33(-23.377,18.352) AF34(-24.027,18.352) AF35(-24.678,18.352) AF36(-25.328,18.352) AF37(-25.978,18.352) AF38(-26.628,18.352) AG1(0,19.048) AG2(-0.65,19.048) AG3(-1.3,19.048) AG4(-1.951,19.048) AG5(-2.601,19.048) AG6(-3.251,18.997) AG7(-3.911,19.12) AG8(-4.561,19.12) AG9(-5.212,19.12) AG10(-5.862,19.12) AG11(-6.512,19.12) AG12(-7.162,19.12) AG13(-7.813,19.12) AG14(-8.463,19.12) AG29(-20.725,19.14) AG30(-21.376,19.14) AG31(-22.077,19.14) AG32(-22.727,19.14) AG33(-23.377,19.14) AG34(-24.027,19.14) AG35(-24.678,19.14) AG36(-25.328,19.14) AG37(-25.978,19.14) AG38(-26.628,19.14) AH1(0,19.785) AH2(-0.65,19.785) AH3(-1.3,19.785) AH4(-1.951,19.785) AH5(-2.601,19.785) AH6(-3.251,19.836) AH7(-3.911,20.035) AH8(-4.561,20.035) AH9(-5.212,20.035) AH10(-5.862,20.035) AH11(-6.512,20.035) AH12(-7.162,20.035) AH13(-7.813,20.035) AH14(-8.463,20.035) AH29(-20.725,19.927) AH30(-21.376,19.927) AH31(-22.077,19.927) AH32(-22.727,19.927) AH33(-23.377,19.927) AH34(-24.027,19.927) AH35(-24.678,19.927) AH36(-25.328,19.927) AH37(-25.978,19.927) AH38(-26.628,19.927) AJ1(0,20.674) AJ2(-0.65,20.674) AJ3(-1.3,20.674) AJ4(-1.951,20.674) AJ5(-2.601,20.674) AJ6(-3.251,20.674) AJ7(-3.911,20.949) AJ8(-4.561,20.949) AJ9(-5.212,20.949) AJ10(-5.862,20.949) AJ11(-6.512,20.949) AJ12(-7.162,20.949) AJ13(-7.813,20.949) AJ14(-8.463,20.949) AJ29(-20.725,20.714) AJ30(-21.376,20.714) AJ31(-22.077,20.714) AJ32(-22.727,20.714) AJ33(-23.377,20.714) AJ34(-24.027,20.714) AJ35(-24.678,20.714) AJ36(-25.328,20.714) AJ37(-25.978,20.714) AJ38(-26.628,20.714) AK1(0,21.563) AK2(-0.65,21.563) AK3(-1.3,21.563) AK4(-1.951,21.563) AK5(-2.601,21.563) AK6(-3.251,21.512) AK29(-20.725,21.502) AK30(-21.376,21.502) AK31(-22.077,21.502) AK32(-22.727,21.502) AK33(-23.377,21.502) AK34(-24.027,21.502) AK35(-24.678,21.502) AK36(-25.328,21.502) AK37(-25.978,21.502) AK38(-26.628,21.502) AL1(0,22.299) AL2(-0.65,22.299) AL3(-1.3,22.299) AL4(-1.951,22.299) AL5(-2.601,22.299) AL6(-3.251,22.35) AL7(-3.911,21.863) AL8(-4.561,21.863) AL9(-5.212,21.863) AL10(-5.862,21.863) AL11(-6.512,21.863) AL12(-7.162,21.863) AL13(-7.813,21.863) AL14(-8.463,21.863) AL29(-20.725,22.289) AL30(-21.376,22.289) AL31(-22.077,22.289) AL32(-22.727,22.289) AL33(-23.377,22.289) AL34(-24.027,22.289) AL35(-24.678,22.289) AL36(-25.328,22.289) AL37(-25.978,22.289) AL38(-26.628,22.289) AM1(0,23.188) AM2(-0.65,23.188) AM3(-1.3,23.188) AM4(-1.951,23.188) AM5(-2.601,23.188) AM6(-3.251,23.188) AM7(-3.911,22.778) AM8(-4.561,22.778) AM9(-5.212,22.778) AM10(-5.862,22.778) AM11(-6.512,22.778) AM12(-7.162,22.778) AM13(-7.813,22.778) AM14(-8.463,22.778) AM29(-20.725,23.077) AM30(-21.376,23.077) AM31(-22.077,23.077) AM32(-22.727,23.077) AM33(-23.377,23.077) AM34(-24.027,23.077) AM35(-24.678,23.077) AM36(-25.328,23.077) AM37(-25.978,23.077) AM38(-26.628,23.077) AN1(0,24.077) AN2(-0.65,24.077) AN3(-1.3,24.077) AN4(-1.951,24.077) AN5(-2.601,24.077) AN6(-3.251,24.027) AN7(-3.911,23.692) AN8(-4.561,23.692) AN9(-5.212,23.692) AN10(-5.862,23.692) AN11(-6.512,23.692) AN12(-7.162,23.692) AN13(-7.813,23.692) AN14(-8.463,23.692) AN29(-20.725,23.864) AN30(-21.376,23.864) AN31(-22.077,23.864) AN32(-22.727,23.864) AN33(-23.377,23.864) AN34(-24.027,23.864) AN35(-24.678,23.864) AN36(-25.328,23.864) AN37(-25.978,23.864) AN38(-26.628,23.864) AP1(0,24.814) AP2(-0.65,24.814) AP3(-1.3,24.814) AP4(-1.951,24.814) AP5(-2.601,24.814) AP6(-3.251,24.865) AP7(-3.911,24.607) AP8(-4.561,24.607) AP9(-5.212,24.607) AP10(-5.862,24.607) AP11(-6.512,24.607) AP12(-7.162,24.607) AP13(-7.813,24.607) AP14(-8.463,24.607) AP29(-20.725,24.651) AP30(-21.376,24.651) AP31(-22.077,24.651) AP32(-22.727,24.651) AP33(-23.377,24.651) AP34(-24.027,24.651) AP35(-24.678,24.651) AP36(-25.328,24.651) AP37(-25.978,24.651) AP38(-26.628,24.651) AR1(0,25.703) AR2(-0.65,25.703) AR3(-1.3,25.703) AR4(-1.951,25.703) AR5(-2.601,25.703) AR6(-3.251,25.703) AR7(-3.911,25.521) AR8(-4.561,25.521) AR9(-5.212,25.521) AR10(-5.862,25.521) AR11(-6.512,25.521) AR12(-7.162,25.521) AR13(-7.813,25.521) AR14(-8.463,25.521) AR29(-20.725,25.439) AR30(-21.376,25.439) AR31(-22.077,25.439) AR32(-22.727,25.439) AR33(-23.377,25.439) AR34(-24.027,25.439) AR35(-24.678,25.439) AR36(-25.328,25.439) AR37(-25.978,25.439) AR38(-26.628,25.439) AT1(0,26.592) AT2(-0.65,26.592) AT3(-1.3,26.592) AT4(-1.951,26.592) AT5(-2.601,26.592) AT6(-3.251,26.541) AT7(-3.911,26.435) AT8(-4.561,26.435) AT9(-5.212,26.435) AT10(-5.862,26.435) AT11(-6.512,26.435) AT12(-7.162,26.435) AT13(-7.813,26.435) AT14(-8.463,26.435) AT29(-20.725,26.226) AT30(-21.376,26.226) AT31(-22.077,26.226) AT32(-22.727,26.226) AT33(-23.377,26.226) AT34(-24.027,26.226) AT35(-24.678,26.226) AT36(-25.328,26.226) AT37(-25.978,26.226) AT38(-26.628,26.226) AU1(0,27.329) AU2(-0.65,27.329) AU3(-1.3,27.329) AU4(-1.951,27.329) AU5(-2.601,27.329) AU6(-3.251,27.379) AU7(-3.911,27.35) AU8(-4.561,27.35) AU9(-5.212,27.35) AU10(-5.862,27.35) AU11(-6.512,27.35) AU12(-7.162,27.35) AU13(-7.813,27.35) AU14(-8.463,27.35) AU29(-20.725,27.014) AU30(-21.376,27.014) AU31(-22.077,27.014) AU32(-22.727,27.014) AU33(-23.377,27.014) AU34(-24.027,27.014) AU35(-24.678,27.014) AU36(-25.328,27.014) AU37(-25.978,27.014) AU38(-26.628,27.014) AV29(-20.725,27.801) AV30(-21.376,27.801) AV31(-22.077,27.801) AV32(-22.727,27.801) AV33(-23.377,27.801) AV34(-24.027,27.801) AV35(-24.678,27.801) AV36(-25.328,27.801) AV37(-25.978,27.801) AV38(-26.628,27.801) AW1(0,28.218) AW2(-0.65,28.218) AW3(-1.3,28.218) AW4(-1.951,28.218) AW5(-2.601,28.218) AW6(-3.251,28.218) AW7(-3.911,28.264) AW8(-4.561,28.264) AW9(-5.212,28.264) AW10(-5.862,28.264) AW11(-6.512,28.264) AW12(-7.162,28.264) AW13(-7.813,28.264) AW14(-8.463,28.264) AW29(-20.725,28.588) AW30(-21.376,28.588) AW31(-22.077,28.588) AW32(-22.727,28.588) AW33(-23.377,28.588) AW34(-24.027,28.588) AW35(-24.678,28.588) AW36(-25.328,28.588) AW37(-25.978,28.588) AW38(-26.628,28.588) AY1(0,29.107) AY2(-0.65,29.107) AY3(-1.3,29.107) AY4(-1.951,29.107) AY5(-2.601,29.107) AY6(-3.251,29.056) AY7(-3.911,29.179) AY8(-4.561,29.179) AY9(-5.212,29.179) AY10(-5.862,29.179) AY11(-6.512,29.179) AY12(-7.162,29.179) AY13(-7.813,29.179) AY14(-8.463,29.179) AY29(-20.725,29.376) AY30(-21.376,29.376) AY31(-22.077,29.376) AY32(-22.727,29.376) AY33(-23.377,29.376) AY34(-24.027,29.376) AY35(-24.678,29.376) AY36(-25.328,29.376) AY37(-25.978,29.376) AY38(-26.628,29.376) B6(-3.531,0.65) B8(-4.318,0.65) B9(-5.105,0.65) B10(-5.893,0.65) B11(-6.68,0.65) B12(-7.468,0.65) B13(-8.255,0.65) B14(-9.042,0.65) B15(-9.83,0.65) B16(-10.617,0.65) B17(-11.405,0.65) B18(-12.192,0.65) B19(-12.979,0.65) B20(-13.767,0.65) B21(-14.554,0.65) B22(-15.342,0.65) B23(-16.129,0.65) B24(-16.916,0.65) B25(-17.704,0.65) B26(-18.491,0.65) B27(-19.279,0.65) B28(-20.066,0.65) B29(-20.853,0.65) B30(-21.641,0.65) B31(-22.428,0.65) B33(-23.216,0.65) BA1(0,29.843) BA2(-0.65,29.843) BA3(-1.3,29.843) BA4(-1.951,29.843) BA5(-2.601,29.843) BA6(-3.251,29.894) BA7(-3.911,30.093) BA8(-4.561,30.093) BA9(-5.212,30.093) BA10(-5.862,30.093) BA11(-6.512,30.093) BA12(-7.162,30.093) BA13(-7.813,30.093) BA14(-8.463,30.093) BA29(-20.725,30.163) BA30(-21.376,30.163) BA31(-22.077,30.163) BA32(-22.727,30.163) BA33(-23.377,30.163) BA34(-24.027,30.163) BA35(-24.678,30.163) BA36(-25.328,30.163) BA37(-25.978,30.163) BA38(-26.628,30.163) BB1(0,30.732) BB2(-0.65,30.732) BB3(-1.3,30.732) BB4(-1.951,30.732) BB5(-2.601,30.732) BB6(-3.251,30.732) BB7(-3.911,31.007) BB8(-4.561,31.007) BB9(-5.212,31.007) BB10(-5.862,31.007) BB11(-6.512,31.007) BB12(-7.162,31.007) BB13(-7.813,31.007) BB14(-8.463,31.007) BB29(-20.725,30.951) BB30(-21.376,30.951) BB31(-22.077,30.951) BB32(-22.727,30.951) BB33(-23.377,30.951) BB34(-24.027,30.951) BB35(-24.678,30.951) BB36(-25.328,30.951) BB37(-25.978,30.951) BB38(-26.628,30.951) BC1(0,31.621) BC2(-0.65,31.621) BC3(-1.3,31.621) BC4(-1.951,31.621) BC5(-2.601,31.621) BC6(-3.251,31.57) BC7(-3.911,31.922) BC8(-4.561,31.922) BC9(-5.212,31.922) BC10(-5.862,31.922) BC11(-6.512,31.922) BC12(-7.162,31.922) BC13(-7.813,31.922) BC14(-8.463,31.922) BC29(-20.725,31.738) BC30(-21.376,31.738) BC31(-22.077,31.738) BC32(-22.727,31.738) BC33(-23.377,31.738) BC34(-24.027,31.738) BC35(-24.678,31.738) BC36(-25.328,31.738) BC37(-25.978,31.738) BC38(-26.628,31.738) BD1(0,32.358) BD2(-0.65,32.358) BD3(-1.3,32.358) BD4(-1.951,32.358) BD5(-2.601,32.358) BD6(-3.251,32.409) BD7(-3.911,32.836) BD8(-4.561,32.836) BD9(-5.212,32.836) BD10(-5.862,32.836) BD11(-6.512,32.836) BD12(-7.162,32.836) BD13(-7.813,32.836) BD14(-8.463,32.836) BD29(-20.725,32.525) BD30(-21.376,32.525) BD31(-22.077,32.525) BD32(-22.727,32.525) BD33(-23.377,32.525) BD34(-24.027,32.525) BD35(-24.678,32.525) BD36(-25.328,32.525) BD37(-25.978,32.525) BD38(-26.628,32.525) BE1(0,33.247) BE2(-0.65,33.247) BE3(-1.3,33.247) BE4(-1.951,33.247) BE5(-2.601,33.247) BE6(-3.251,33.247) BE29(-20.725,33.313) BE30(-21.376,33.313) BE31(-22.077,33.313) BE32(-22.727,33.313) BE33(-23.377,33.313) BE34(-24.027,33.313) BE35(-24.678,33.313) BE36(-25.328,33.313) BE37(-25.978,33.313) BE38(-26.628,33.313) BF1(0,34.136) BF2(-0.65,34.136) BF3(-1.3,34.136) BF4(-1.951,34.136) BF5(-2.601,34.136) BF6(-3.251,34.085) BF7(-3.911,33.751) BF8(-4.561,33.751) BF9(-5.212,33.751) BF10(-5.862,33.751) BF11(-6.512,33.751) BF12(-7.162,33.751) BF13(-7.813,33.751) BF14(-8.463,33.751) BF29(-20.725,34.1) BF30(-21.376,34.1) BF31(-22.077,34.1) BF32(-22.727,34.1) BF33(-23.377,34.1) BF34(-24.027,34.1) BF35(-24.678,34.1) BF36(-25.328,34.1) BF37(-25.978,34.1) BF38(-26.628,34.1) BG1(0,34.872) BG2(-0.65,34.872) BG3(-1.3,34.872) BG4(-1.951,34.872) BG5(-2.601,34.872) BG6(-3.251,34.923) BG7(-3.911,34.665) BG8(-4.561,34.665) BG9(-5.212,34.665) BG10(-5.862,34.665) BG11(-6.512,34.665) BG12(-7.162,34.665) BG13(-7.813,34.665) BG14(-8.463,34.665) BG29(-20.725,34.888) BG30(-21.376,34.888) BG31(-22.077,34.888) BG32(-22.727,34.888) BG33(-23.377,34.888) BG34(-24.027,34.888) BG35(-24.678,34.888) BG36(-25.328,34.888) BG37(-25.978,34.888) BG38(-26.628,34.888) BH1(0,36.015) BH2(-0.65,35.761) BH3(-1.3,35.761) BH4(-1.951,35.761) BH5(-2.601,35.761) BH6(-3.251,35.761) BH7(-3.911,35.579) BH8(-4.561,35.579) BH9(-5.212,35.579) BH10(-5.862,35.579) BH11(-6.512,35.579) BH12(-7.162,35.579) BH13(-7.813,35.579) BH14(-8.463,35.541) BH29(-20.725,35.548) BH30(-21.376,35.675) BH31(-22.077,35.675) BH32(-22.727,35.675) BH33(-23.377,35.675) BH34(-24.027,35.675) BH35(-24.678,35.675) BH36(-25.328,35.675) BH37(-25.978,35.675) BH38(-26.628,35.675) BJ7(-3.911,36.494) BJ8(-4.561,36.494) BJ9(-5.212,36.494) BJ10(-5.862,36.494) BJ11(-6.512,36.494) BJ12(-7.282,36.405) BJ13(-8.171,36.126) BJ14(-8.851,36.077) BJ15(-9.601,36.077) BJ16(-10.388,36.077) BJ17(-11.175,36.077) BJ18(-11.963,36.077) BJ19(-12.75,36.077) BJ20(-13.538,36.077) BJ21(-14.325,36.077) BJ22(-15.112,36.077) BJ23(-15.9,36.077) BJ24(-16.687,36.077) BJ25(-17.475,36.077) BJ26(-18.262,36.077) BJ27(-19.049,36.077) BJ28(-19.837,36.077) BJ29(-20.497,36.158) BJ30(-21.353,36.329) BJ31(-22.077,36.462) BJ32(-22.727,36.462) BJ33(-23.377,36.462) BJ34(-24.027,36.462) BJ35(-24.678,36.462) BJ36(-25.328,36.462) BJ37(-25.978,36.462) BJ38(-26.628,36.412) BK2(-0.65,36.6) BK3(-1.3,36.6) BK4(-1.951,36.6) BK5(-2.601,36.6) BK6(-3.251,36.6) BK13(-7.899,36.727) BK14(-8.813,36.727) BK15(-9.601,36.727) BK16(-10.388,36.727) BK17(-11.175,36.727) BK18(-11.963,36.727) BK19(-12.75,36.727) BK20(-13.538,36.727) BK21(-14.325,36.727) BK22(-15.112,36.727) BK23(-15.9,36.727) BK24(-16.687,36.727) BK25(-17.475,36.727) BK26(-18.262,36.727) BK27(-19.049,36.727) BK28(-19.837,36.727) BK29(-20.833,36.735) BL3(-1.3,37.387) BL4(-1.951,37.387) BL5(-2.601,37.387) BL6(-3.251,37.438) BL7(-3.987,37.383) BL8(-4.876,37.377) BL9(-5.664,37.377) BL11(-6.451,37.377) BL12(-7.238,37.377) BL13(-8.026,37.377) BL14(-8.813,37.377) BL15(-9.601,37.377) BL16(-10.388,37.377) BL17(-11.175,37.377) BL18(-11.963,37.377) BL19(-12.75,37.377) BL20(-13.538,37.377) BL21(-14.325,37.377) BL22(-15.112,37.377) BL23(-15.9,37.377) BL24(-16.687,37.377) BL25(-17.475,37.377) BL26(-18.262,37.377) BL27(-19.049,37.377) BL28(-19.837,37.377) BL29(-20.624,37.377) BL30(-21.426,37.25) BL31(-22.077,37.25) BL32(-22.727,37.25) BL33(-23.377,37.25) BL34(-24.027,37.25) BL35(-24.678,37.25) BL36(-25.328,37.25) BL37(-25.978,37.25) BM3(-1.613,38.129) BM5(-2.525,38.129) BM6(-3.169,38.231) BM7(-4.089,38.027) BM8(-4.876,38.027) BM9(-5.664,38.027) BM11(-6.451,38.027) BM12(-7.238,38.027) BM13(-8.026,38.027) BM14(-8.813,38.027) BM15(-9.601,38.027) BM16(-10.388,38.027) BM17(-11.175,38.027) BM18(-11.963,38.027) BM19(-12.75,38.027) BM20(-13.538,38.027) BM21(-14.325,38.027) BM22(-15.112,38.027) BM23(-15.9,38.027) BM24(-16.687,38.027) BM25(-17.475,38.027) BM26(-18.262,38.027) BM27(-19.049,38.027) BM28(-19.837,38.027) BM29(-20.624,38.027) BM30(-21.412,38.027) BM31(-22.199,38.027) BM33(-22.986,38.027) BM34(-23.774,38.027) BM35(-24.561,38.027) BM36(-25.328,37.986) BN4(-2.106,38.629) BN5(-2.748,38.793) BN7(-4.089,38.678) BN8(-4.876,38.678) BN9(-5.664,38.678) BN11(-6.451,38.678) BN12(-7.238,38.678) BN13(-8.026,38.678) BN14(-8.813,38.678) BN15(-9.601,38.678) BN16(-10.388,38.678) BN17(-11.175,38.678) BN18(-11.963,38.678) BN19(-12.75,38.678) BN20(-13.538,38.678) BN21(-14.325,38.678) BN22(-15.112,38.678) BN23(-15.9,38.678) BN24(-16.687,38.678) BN25(-17.475,38.678) BN26(-18.262,38.678) BN27(-19.049,38.678) BN28(-19.837,38.678) BN29(-20.624,38.678) BN30(-21.412,38.678) BN31(-22.199,38.678) BN33(-22.986,38.678) BN34(-23.774,38.678) BN35(-24.562,38.678) BP5(-2.374,39.351) BP6(-3.294,39.288) BP7(-4.089,39.328) BP8(-4.876,39.328) BP9(-5.664,39.328) BP11(-6.451,39.328) BP12(-7.238,39.328) BP13(-8.026,39.328) BP14(-8.813,39.328) BP15(-9.601,39.328) BP16(-10.388,39.328) BP17(-11.175,39.328) BP18(-11.963,39.328) BP19(-12.75,39.328) BP20(-13.538,39.328) BP21(-14.325,39.328) BP22(-15.112,39.328) BP23(-15.9,39.328) BP24(-16.687,39.328) BP25(-17.475,39.328) BP26(-18.262,39.328) BP27(-19.049,39.328) BP28(-19.837,39.328) BP29(-20.624,39.328) BP30(-21.412,39.328) BP31(-22.199,39.328) BP33(-22.986,39.328) BP34(-23.774,39.328) BR6(-3.192,39.961) BR7(-4.089,39.978) BR8(-4.876,39.978) BR9(-5.664,39.978) BR11(-6.451,39.978) BR12(-7.238,39.978) BR13(-8.026,39.978) BR14(-8.813,39.978) BR15(-9.601,39.978) BR16(-10.388,39.978) BR17(-11.175,39.978) BR18(-11.963,39.978) BR19(-12.75,39.978) BR20(-13.538,39.978) BR21(-14.325,39.978) BR22(-15.112,39.978) BR23(-15.9,39.978) BR24(-16.687,39.978) BR25(-17.475,39.978) BR26(-18.262,39.978) BR27(-19.049,39.978) BR28(-19.837,39.978) BR29(-20.624,39.978) BR30(-21.412,39.978) BR31(-22.199,39.978) BR33(-22.986,39.978) BT8(-4.648,40.628) BT9(-5.664,40.628) BT11(-6.451,40.628) BT12(-7.238,40.628) BT13(-8.026,40.628) BT14(-8.813,40.628) BT15(-9.601,40.628) BT16(-10.388,40.628) BT17(-11.175,40.628) BT18(-11.963,40.628) BT19(-12.75,40.628) BT20(-13.538,40.628) BT21(-14.325,40.628) BT22(-15.112,40.628) BT23(-15.9,40.628) BT24(-16.687,40.628) BT25(-17.475,40.628) BT26(-18.262,40.628) BT27(-19.049,40.628) BT28(-19.837,40.628) BT29(-20.624,40.628) BT30(-21.412,40.628) BT31(-22.174,40.628) C5(-2.743,1.3) C6(-3.531,1.3) C8(-4.318,1.3) C9(-5.105,1.3) C10(-5.893,1.3) C11(-6.68,1.3) C12(-7.468,1.3) C13(-8.255,1.3) C14(-9.042,1.3) C15(-9.83,1.3) C16(-10.617,1.3) C17(-11.405,1.3) C18(-12.192,1.3) C19(-12.979,1.3) C20(-13.767,1.3) C21(-14.554,1.3) C22(-15.342,1.3) C23(-16.129,1.3) C24(-16.916,1.3) C25(-17.704,1.3) C26(-18.491,1.3) C27(-19.279,1.3) C28(-20.066,1.3) C29(-20.853,1.3) C30(-21.641,1.3) C31(-22.428,1.3) C33(-23.216,1.3) C34(-24.011,1.29) D5(-2.743,1.951) D6(-3.531,1.951) D8(-4.318,1.951) D9(-5.105,1.951) D10(-5.893,1.951) D11(-6.68,1.951) D12(-7.468,1.951) D13(-8.255,1.951) D14(-9.042,1.951) D15(-9.83,1.951) D16(-10.617,1.951) D17(-11.405,1.951) D18(-12.192,1.951) D19(-12.979,1.951) D20(-13.767,1.951) D21(-14.554,1.951) D22(-15.342,1.951) D23(-16.129,1.951) D24(-16.916,1.951) D25(-17.704,1.951) D26(-18.491,1.951) D27(-19.279,1.951) D28(-20.066,1.951) D29(-20.853,1.951) D30(-21.641,1.951) D31(-22.428,1.951) D33(-23.216,1.951) D34(-24.003,1.951) D35(-24.655,1.861) E4(-1.951,2.575) E5(-2.743,2.601) E6(-3.531,2.601) E8(-4.318,2.601) E9(-5.105,2.601) E10(-5.893,2.601) E11(-6.68,2.601) E12(-7.468,2.601) E13(-8.255,2.601) E14(-9.042,2.601) E15(-9.83,2.601) E16(-10.617,2.601) E17(-11.405,2.601) E18(-12.192,2.601) E19(-12.979,2.601) E20(-13.767,2.601) E21(-14.554,2.601) E22(-15.342,2.601) E23(-16.129,2.601) E24(-16.916,2.601) E25(-17.704,2.601) E26(-18.491,2.601) E27(-19.279,2.601) E28(-20.066,2.601) E29(-20.853,2.601) E30(-21.641,2.601) E31(-22.428,2.601) E33(-23.216,2.601) E34(-24.003,2.601) E35(-24.678,2.604) E36(-25.328,2.604) F3(-1.3,3.16) F4(-1.951,3.261) F5(-2.743,3.273) F6(-3.531,3.273) F8(-4.318,3.251) F9(-5.105,3.251) F10(-5.893,3.251) F11(-6.68,3.251) F12(-7.468,3.251) F13(-8.255,3.251) F14(-9.042,3.251) F15(-9.83,3.251) F16(-10.617,3.251) F17(-11.405,3.251) F18(-12.192,3.251) F19(-12.979,3.251) F20(-13.767,3.251) F21(-14.554,3.251) F22(-15.342,3.251) F23(-16.129,3.251) F24(-16.916,3.251) F25(-17.704,3.251) F26(-18.491,3.251) F27(-19.279,3.251) F28(-20.066,3.251) F29(-20.853,3.251) F30(-21.641,3.251) F31(-22.428,3.251) F33(-23.216,3.251) F34(-24.027,3.392) F35(-24.678,3.392) F36(-25.328,3.392) F37(-25.978,3.392) G2(-0.65,3.947) G3(-1.3,3.947) G4(-1.951,3.947) G5(-2.601,3.947) G6(-3.251,3.947) G8(-4.318,3.901) G9(-5.105,3.901) G10(-5.893,3.901) G11(-6.68,3.901) G12(-7.468,3.901) G13(-8.255,3.901) G14(-9.042,3.901) G15(-9.83,3.901) G16(-10.617,3.901) G17(-11.405,3.901) G18(-12.192,3.901) G19(-12.979,3.901) G20(-13.767,3.901) G21(-14.554,3.901) G22(-15.342,3.901) G23(-16.129,3.901) G24(-16.916,3.901) G25(-17.704,3.901) G26(-18.491,3.901) G27(-19.279,3.901) G28(-20.066,3.901) G29(-20.853,3.901) G30(-21.641,3.901) H1(0,4.443) H11(-6.68,4.552) H12(-7.468,4.552) H13(-8.255,4.602) H14(-9.042,4.602) H15(-9.83,4.602) H16(-10.617,4.602) H17(-11.405,4.602) H18(-12.192,4.602) H19(-12.979,4.602) H20(-13.767,4.602) H21(-14.554,4.602) H22(-15.342,4.602) H23(-16.129,4.602) H24(-16.916,4.602) H25(-17.704,4.602) H26(-18.491,4.602) H27(-19.279,4.602) H28(-20.066,4.602) H29(-20.853,4.552) H30(-21.603,4.552) H32(-22.727,4.179) H33(-23.377,4.179) H34(-24.027,4.179) H35(-24.678,4.179) H36(-25.328,4.179) H37(-25.978,4.179) J2(-0.65,4.748) J3(-1.3,4.748) J4(-1.951,4.748) J5(-2.601,4.748) J6(-3.251,4.748) J7(-3.893,4.619) J8(-4.541,4.716) J9(-5.212,4.693) J10(-5.893,4.628) J14(-9.042,5.253) J15(-9.83,5.253) J16(-10.617,5.253) J17(-11.405,5.253) J18(-12.192,5.253) J19(-12.979,5.253) J20(-13.767,5.253) J21(-14.554,5.253) J22(-15.342,5.253) J23(-16.129,5.253) J24(-16.916,5.253) J25(-17.704,5.253) J26(-18.491,5.253) J27(-19.279,5.253) J28(-20.066,5.253) J30(-21.061,5.168) J31(-22.077,5.005) J32(-22.727,4.966) J33(-23.377,4.966) J34(-24.027,4.966) J35(-24.678,4.966) J36(-25.328,4.966) J37(-25.978,4.966) J38(-26.628,4.712) K1(0,5.586) K2(-0.65,5.586) K3(-1.3,5.586) K4(-1.951,5.586) K5(-2.601,5.586) K6(-3.251,5.586) K7(-3.911,5.557) K8(-4.561,5.48) K9(-5.212,5.48) K10(-5.862,5.48) K11(-6.512,5.48) K12(-7.162,5.48) K13(-7.879,5.176) K14(-8.463,5.658) K29(-20.725,5.754) K30(-21.376,5.754) K31(-22.077,5.754) K32(-22.727,5.754) K33(-23.377,5.754) K34(-24.027,5.754) K35(-24.678,5.754) K36(-25.328,5.754) K37(-25.978,5.754) K38(-26.628,5.754) L1(0,6.475) L2(-0.65,6.475) L3(-1.3,6.475) L4(-1.951,6.475) L5(-2.601,6.475) L6(-3.251,6.424) L7(-3.911,6.395) L8(-4.561,6.344) L9(-5.212,6.319) L10(-5.862,6.319) L11(-6.512,6.319) L12(-7.162,6.319) L13(-7.813,6.319) L14(-8.463,6.319) L29(-20.725,6.541) L30(-21.376,6.541) L31(-22.077,6.541) L32(-22.727,6.541) L33(-23.377,6.541) L34(-24.027,6.541) L35(-24.678,6.541) L36(-25.328,6.541) L37(-25.978,6.541) L38(-26.628,6.541) M1(0,7.212) M2(-0.65,7.212) M3(-1.3,7.212) M4(-1.951,7.212) M5(-2.601,7.212) M6(-3.251,7.263) M7(-3.911,7.233) M8(-4.561,7.233) M9(-5.212,7.233) M10(-5.862,7.233) M11(-6.512,7.233) M12(-7.162,7.233) M13(-7.813,7.233) M14(-8.463,7.233) M29(-20.725,7.329) M30(-21.376,7.329) M31(-22.077,7.329) M32(-22.727,7.329) M33(-23.377,7.329) M34(-24.027,7.329) M35(-24.678,7.329) M36(-25.328,7.329) M37(-25.978,7.329) M38(-26.628,7.329) N1(0,8.101) N2(-0.65,8.101) N3(-1.3,8.101) N4(-1.951,8.101) N5(-2.601,8.101) N6(-3.251,8.101) N7(-3.911,8.147) N8(-4.561,8.147) N9(-5.212,8.147) N10(-5.862,8.147) N11(-6.512,8.147) N12(-7.162,8.147) N13(-7.813,8.147) N14(-8.463,8.147) N29(-20.725,8.116) N30(-21.376,8.116) N31(-22.077,8.116) N32(-22.727,8.116) N33(-23.377,8.116) N34(-24.027,8.116) N35(-24.678,8.116) N36(-25.328,8.116) N37(-25.978,8.116) N38(-26.628,8.116) P1(0,8.99) P2(-0.65,8.99) P3(-1.3,8.99) P4(-1.951,8.99) P5(-2.601,8.99) P6(-3.251,8.939) P7(-3.911,9.062) P8(-4.561,9.062) P9(-5.212,9.062) P10(-5.862,9.062) P11(-6.512,9.062) P12(-7.162,9.062) P13(-7.813,9.062) P14(-8.463,9.062) P29(-20.725,8.903) P30(-21.376,8.903) P31(-22.077,8.903) P32(-22.727,8.903) P33(-23.377,8.903) P34(-24.027,8.903) P35(-24.678,8.903) P36(-25.328,8.903) P37(-25.978,8.903) P38(-26.628,8.903) R1(0,9.726) R2(-0.65,9.726) R3(-1.3,9.726) R4(-1.951,9.726) R5(-2.601,9.726) R6(-3.251,9.777) R7(-3.911,9.976) R8(-4.561,9.976) R9(-5.212,9.976) R10(-5.862,9.976) R11(-6.512,9.976) R12(-7.162,9.976) R13(-7.813,9.976) R14(-8.463,9.976) R29(-20.725,9.691) R30(-21.376,9.691) R31(-22.077,9.691) R32(-22.727,9.691) R33(-23.377,9.691) R34(-24.027,9.691) R35(-24.678,9.691) R36(-25.328,9.691) R37(-25.978,9.691) R38(-26.628,9.691) T1(0,10.615) T2(-0.65,10.615) T3(-1.3,10.615) T4(-1.951,10.615) T5(-2.601,10.615) T6(-3.251,10.615) T7(-3.911,10.891) T8(-4.561,10.891) T9(-5.212,10.891) T10(-5.862,10.891) T11(-6.512,10.891) T12(-7.162,10.891) T13(-7.813,10.891) T14(-8.463,10.891) T29(-20.725,10.478) T30(-21.376,10.478) T31(-22.077,10.478) T32(-22.727,10.478) T33(-23.377,10.478) T34(-24.027,10.478) T35(-24.678,10.478) T36(-25.328,10.478) T37(-25.978,10.478) T38(-26.628,10.478) U1(0,11.504) U2(-0.65,11.504) U3(-1.3,11.504) U4(-1.951,11.504) U5(-2.601,11.504) U6(-3.251,11.454) U29(-20.725,11.266) U30(-21.376,11.266) U31(-22.077,11.266) U32(-22.727,11.266) U33(-23.377,11.266) U34(-24.027,11.266) U35(-24.678,11.266) U36(-25.328,11.266) U37(-25.978,11.266) U38(-26.628,11.266) V1(0,12.241) V2(-0.65,12.241) V3(-1.3,12.241) V4(-1.951,12.241) V5(-2.601,12.241) V6(-3.251,12.292) V7(-3.911,11.805) V8(-4.561,11.805) V9(-5.212,11.805) V10(-5.862,11.805) V11(-6.512,11.805) V12(-7.162,11.805) V13(-7.813,11.805) V14(-8.463,11.805) V29(-20.725,12.053) V30(-21.376,12.053) V31(-22.077,12.053) V32(-22.727,12.053) V33(-23.377,12.053) V34(-24.027,12.053) V35(-24.678,12.053) V36(-25.328,12.053) V37(-25.978,12.053) V38(-26.628,12.053) W1(0,13.13) W2(-0.65,13.13) W3(-1.3,13.13) W4(-1.951,13.13) W5(-2.601,13.13) W6(-3.251,13.13) W7(-3.911,12.719) W8(-4.561,12.719) W9(-5.212,12.719) W10(-5.862,12.719) W11(-6.512,12.719) W12(-7.162,12.719) W13(-7.813,12.719) W14(-8.463,12.719) W29(-20.725,12.84) W30(-21.376,12.84) W31(-22.077,12.84) W32(-22.727,12.84) W33(-23.377,12.84) W34(-24.027,12.84) W35(-24.678,12.84) W36(-25.328,12.84) W37(-25.978,12.84) W38(-26.628,12.84) Y7(-3.911,13.634) Y8(-4.561,13.634) Y9(-5.212,13.634) Y10(-5.862,13.634) Y11(-6.512,13.634) Y12(-7.162,13.634) Y13(-7.813,13.634) Y14(-8.463,13.634) Y29(-20.725,13.628) Y30(-21.376,13.628) Y31(-22.077,13.628) Y32(-22.727,13.628) Y33(-23.377,13.628) Y34(-24.027,13.628) Y35(-24.678,13.628) Y36(-25.328,13.628) Y37(-25.978,13.628) Y38(-26.628,13.628)
