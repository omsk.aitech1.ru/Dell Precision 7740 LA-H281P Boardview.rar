# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
CHILI_MPB201210T-4R7M-NA2_2P
  rect 0.787x1.194 smd: 1(0,0) 2(1.8,0)
CNP-H_BGA_874P-T
  round 0.305 smd: A2(0.354,0) A3(0.855,0) A4(1.355,0) A46(22.273,0) A47(22.773,0) A48(23.274,0) AA19(8.715,-9.765) AA20(9.49,-9.765) AA22(10.265,-9.765) AA23(11.039,-9.765) AA25(11.814,-9.765) AA27(12.589,-9.765) AA28(13.363,-9.765) AA30(14.138,-9.765) AA31(14.913,-9.765) AB19(8.715,-10.539) AB20(9.49,-10.539) AB22(10.265,-10.539) AB23(11.039,-10.539) AB25(11.814,-10.539) AB27(12.589,-10.539) AB28(13.363,-10.539) AB30(14.138,-10.539) AB31(14.913,-10.539) AC6(2.44,-10.735) AC7(3.202,-10.735) AC9(3.964,-10.735) AC11(4.726,-10.735) AC12(5.488,-10.735) AC14(6.25,-10.735) AC15(7.012,-10.735) AC17(7.774,-10.735) AC33(15.854,-10.735) AC35(16.616,-10.735) AC36(17.378,-10.735) AC38(18.14,-10.735) AC39(18.902,-10.735) AC41(19.664,-10.735) AC43(20.426,-10.735) AC44(21.188,-10.735) AD19(8.715,-11.314) AD20(9.49,-11.314) AD22(10.265,-11.314) AD23(11.039,-11.314) AD25(11.814,-11.314) AD27(12.589,-11.314) AD28(13.363,-11.314) AD30(14.138,-11.314) AD31(14.913,-11.314) AE6(2.44,-11.893) AE7(3.202,-11.893) AE9(3.964,-11.893) AE11(4.726,-11.893) AE12(5.488,-11.893) AE14(6.25,-11.893) AE15(7.012,-11.893) AE17(7.774,-11.893) AE33(15.854,-11.893) AE35(16.616,-11.893) AE36(17.378,-11.893) AE38(18.14,-11.893) AE39(18.902,-11.893) AE41(19.664,-11.893) AE43(20.426,-11.893) AE44(21.188,-11.893) AF19(8.715,-12.089) AF20(9.49,-12.089) AF22(10.265,-12.089) AF23(11.039,-12.089) AF25(11.814,-12.089) AF27(12.589,-12.089) AF28(13.363,-12.089) AF30(14.138,-12.089) AF31(14.913,-12.089) AG19(8.715,-12.863) AG20(9.49,-12.863) AG22(10.265,-12.863) AG23(11.039,-12.863) AG25(11.814,-12.863) AG27(12.589,-12.863) AG28(13.363,-12.863) AG30(14.138,-12.863) AG31(14.913,-12.863) AH9(3.895,-13.519) AH10(4.634,-13.328) AH12(5.412,-13.328) AH14(6.25,-13.328) AH15(7.025,-13.328) AH17(7.787,-13.328) AH33(15.841,-13.328) AH35(16.603,-13.328) AH36(17.378,-13.328) AH38(18.216,-13.328) AH40(18.994,-13.328) AH41(19.733,-13.519) AJ6(2.417,-13.9) AJ7(3.156,-13.709) AJ19(8.715,-13.638) AJ20(9.49,-13.638) AJ22(10.265,-13.638) AJ23(11.039,-13.638) AJ25(11.814,-13.638) AJ27(12.589,-13.638) AJ28(13.363,-13.638) AJ30(14.138,-13.638) AJ31(14.913,-13.638) AJ43(20.472,-13.709) AJ44(21.211,-13.9) AK19(8.715,-14.413) AK20(9.49,-14.413) AK22(10.265,-14.413) AK23(11.039,-14.413) AK25(11.814,-14.413) AK27(12.589,-14.413) AK28(13.363,-14.413) AK30(14.138,-14.413) AK31(14.913,-14.413) AL9(3.9,-14.809) AL10(4.633,-14.573) AL12(5.395,-14.573) AL13(6.157,-14.573) AL15(6.919,-14.573) AL17(7.681,-14.573) AL21(9.8,-14.892) AL24(11.235,-14.905) AL26(12.393,-14.905) AL29(13.828,-14.892) AL33(15.947,-14.573) AL35(16.709,-14.573) AL37(17.471,-14.573) AL38(18.233,-14.573) AL40(18.995,-14.573) AL41(19.728,-14.809) AM7(3.179,-15.157) AM18(8.555,-14.997) AM32(15.073,-14.997) AM43(20.449,-15.157) AN6(2.519,-15.538) AN10(4.633,-15.97) AN12(5.37,-15.665) AN13(6.132,-15.665) AN15(6.894,-15.665) AN16(7.463,-15.708) AN18(8.555,-15.708) AN21(9.8,-15.603) AN24(11.235,-15.616) AN26(12.393,-15.616) AN29(13.828,-15.603) AN32(15.073,-15.708) AN34(16.165,-15.708) AN35(16.734,-15.665) AN37(17.496,-15.665) AN38(18.258,-15.665) AN40(18.995,-15.97) AN44(21.109,-15.538) AP9(3.9,-16.282) AP21(9.8,-16.378) AP24(11.235,-16.378) AP26(12.393,-16.378) AP29(13.828,-16.378) AP41(19.728,-16.282) AR8(3.306,-16.783) AR12(5.37,-16.757) AR13(6.132,-16.757) AR15(6.894,-16.757) AR16(7.463,-16.496) AR18(8.555,-16.47) AR32(15.073,-16.47) AR34(16.165,-16.496) AR35(16.734,-16.757) AR37(17.496,-16.757) AR38(18.258,-16.757) AR42(20.322,-16.783) AT6(2.519,-16.973) AT10(4.633,-17.087) AT16(7.463,-17.258) AT18(8.555,-17.232) AT21(9.8,-17.216) AT24(11.235,-17.14) AT26(12.393,-17.14) AT29(13.828,-17.216) AT32(15.073,-17.232) AT34(16.165,-17.258) AT40(18.995,-17.087) AT44(21.109,-16.973) AU9(3.9,-17.73) AU24(11.235,-17.902) AU26(12.393,-17.902) AU41(19.728,-17.73) AV6(2.519,-18.408) AV7(3.217,-18.078) AV11(4.735,-18.289) AV13(6.066,-18.071) AV16(7.158,-18.032) AV18(8.555,-17.994) AV21(9.8,-17.993) AV29(13.828,-17.993) AV32(15.073,-17.994) AV34(16.47,-18.032) AV37(17.562,-18.071) AV39(18.893,-18.289) AV43(20.411,-18.078) AV44(21.109,-18.408) AW9(3.99,-18.891) AW10(4.552,-18.823) AW13(5.804,-18.804) AW15(6.922,-18.766) AW18(8.319,-18.727) AW21(9.609,-18.733) AW24(11.235,-18.664) AW26(12.393,-18.664) AW29(14.019,-18.733) AW32(15.309,-18.727) AW35(16.706,-18.766) AW37(17.824,-18.804) AW40(19.076,-18.823) AW41(19.638,-18.891) AY8(3.281,-19.212) AY42(20.347,-19.212) B1(0,-0.354) B2(0.484,-0.484) B3(1.105,-0.436) B47(22.523,-0.436) B48(23.144,-0.484) B49(23.628,-0.354) BA6(2.684,-19.517) BA12(5.329,-19.449) BA14(6.574,-19.449) BA17(7.971,-19.449) BA20(9.419,-19.472) BA24(11.235,-19.426) BA26(12.393,-19.426) BA30(14.209,-19.472) BA33(15.657,-19.449) BA36(17.054,-19.449) BA38(18.299,-19.449) BA44(20.944,-19.517) BB6(2.726,-20.02) BB7(3.225,-20.314) BB9(3.79,-20.088) BB11(4.948,-20.109) BB14(6.193,-20.109) BB16(7.59,-20.109) BB20(9.228,-20.211) BB24(11.235,-20.188) BB26(12.393,-20.188) BB30(14.4,-20.211) BB34(16.038,-20.109) BB36(17.435,-20.109) BB39(18.68,-20.109) BB41(19.838,-20.088) BB43(20.403,-20.314) BB44(20.902,-20.02) BC5(2.18,-20.568) BC45(21.448,-20.568) BD1(0,-21.273) BD4(1.34,-21.297) BD46(22.288,-21.297) BD49(23.628,-21.273) BE1(0,-21.773) BE2(0.441,-21.51) BE3(0.954,-21.625) BE4(1.423,-21.801) BE5(1.849,-21.526) BE45(21.779,-21.526) BE46(22.205,-21.801) BE47(22.674,-21.625) BE48(23.187,-21.51) BE49(23.628,-21.773) BF1(0,-22.274) BF2(0.484,-22.144) BF3(1.105,-22.192) BF47(22.523,-22.192) BF48(23.144,-22.144) BF49(23.628,-22.274) BG2(0.354,-22.628) BG3(0.855,-22.628) BG4(1.355,-22.628) BG46(22.273,-22.628) BG47(22.773,-22.628) BG48(23.274,-22.628) C1(0,-0.855) C2(0.441,-1.118) C3(0.954,-1.003) C4(1.423,-0.827) C5(1.849,-1.102) C45(21.779,-1.102) C46(22.205,-0.827) C47(22.674,-1.003) C48(23.187,-1.118) C49(23.628,-0.855) D1(0,-1.355) D4(1.34,-1.331) D46(22.288,-1.331) D49(23.628,-1.355) E5(2.18,-2.06) E45(21.448,-2.06) F6(2.726,-2.608) F7(3.225,-2.314) F9(3.79,-2.539) F11(4.948,-2.519) F14(6.193,-2.519) F16(7.59,-2.519) F20(9.228,-2.417) F24(11.235,-2.44) F26(12.393,-2.44) F30(14.4,-2.417) F34(16.038,-2.519) F36(17.435,-2.519) F39(18.68,-2.519) F41(19.838,-2.539) F43(20.403,-2.314) F44(20.902,-2.608) G6(2.684,-3.111) G12(5.329,-3.179) G14(6.574,-3.179) G17(7.971,-3.179) G20(9.419,-3.156) G24(11.235,-3.202) G26(12.393,-3.202) G30(14.209,-3.156) G33(15.657,-3.179) G36(17.054,-3.179) G38(18.299,-3.179) G44(20.944,-3.111) H8(3.281,-3.416) H42(20.347,-3.416) J9(3.99,-3.737) J10(4.552,-3.805) J13(5.804,-3.824) J15(6.922,-3.862) J18(8.319,-3.9) J21(9.609,-3.895) J24(11.235,-3.964) J26(12.393,-3.964) J29(14.019,-3.895) J32(15.309,-3.9) J35(16.706,-3.862) J37(17.824,-3.824) J40(19.076,-3.805) J41(19.638,-3.737) K6(2.519,-4.22) K7(3.217,-4.55) K11(4.735,-4.339) K13(6.066,-4.557) K16(7.158,-4.595) K18(8.555,-4.633) K21(9.8,-4.634) K29(13.828,-4.634) K32(15.073,-4.633) K34(16.47,-4.595) K37(17.562,-4.557) K39(18.893,-4.339) K43(20.411,-4.55) K44(21.109,-4.22) L9(3.9,-4.898) L24(11.235,-4.726) L26(12.393,-4.726) L41(19.728,-4.898) M6(2.519,-5.655) M10(4.633,-5.541) M16(7.463,-5.37) M18(8.555,-5.395) M21(9.8,-5.412) M24(11.235,-5.488) M26(12.393,-5.488) M29(13.828,-5.412) M32(15.073,-5.395) M34(16.165,-5.37) M40(18.995,-5.541) M44(21.109,-5.655) N8(3.306,-5.845) N12(5.37,-5.871) N13(6.132,-5.871) N15(6.894,-5.871) N16(7.463,-6.132) N18(8.555,-6.157) N32(15.073,-6.157) N34(16.165,-6.132) N35(16.734,-5.871) N37(17.496,-5.871) N38(18.258,-5.871) N42(20.322,-5.845) P9(3.9,-6.346) P21(9.8,-6.25) P24(11.235,-6.25) P26(12.393,-6.25) P29(13.828,-6.25) P41(19.728,-6.346) R6(2.519,-7.09) R10(4.633,-6.658) R12(5.37,-6.963) R13(6.132,-6.963) R15(6.894,-6.963) R16(7.463,-6.919) R18(8.555,-6.919) R21(9.8,-7.025) R24(11.235,-7.012) R26(12.393,-7.012) R29(13.828,-7.025) R32(15.073,-6.919) R34(16.165,-6.919) R35(16.734,-6.963) R37(17.496,-6.963) R38(18.258,-6.963) R40(18.995,-6.658) R44(21.109,-7.09) T7(3.179,-7.471) T17(8.003,-7.631) T18(8.555,-7.631) T32(15.073,-7.631) T43(20.449,-7.471) U9(3.9,-7.819) U10(4.633,-8.055) U12(5.395,-8.055) U13(6.157,-8.055) U15(6.919,-8.055) U17(7.681,-8.055) U21(9.8,-7.736) U24(11.235,-7.723) U26(12.393,-7.723) U29(13.828,-7.736) U33(15.947,-8.055) U35(16.709,-8.055) U37(17.471,-8.055) U38(18.233,-8.055) U40(18.995,-8.055) U41(19.728,-7.819) V19(8.715,-8.215) V20(9.49,-8.215) V22(10.265,-8.215) V23(11.039,-8.215) V25(11.814,-8.215) V27(12.589,-8.215) V28(13.363,-8.215) V30(14.138,-8.215) V31(14.913,-8.215) W6(2.417,-8.728) W7(3.156,-8.919) W19(8.715,-8.99) W20(9.49,-8.99) W22(10.265,-8.99) W23(11.039,-8.99) W25(11.814,-8.99) W27(12.589,-8.99) W28(13.363,-8.99) W30(14.138,-8.99) W31(14.913,-8.99) W43(20.472,-8.919) W44(21.211,-8.728) Y9(3.895,-9.109) Y10(4.634,-9.3) Y12(5.412,-9.3) Y14(6.25,-9.3) Y15(7.025,-9.3) Y17(7.787,-9.3) Y33(15.841,-9.3) Y35(16.603,-9.3) Y36(17.378,-9.3) Y38(18.216,-9.3) Y40(18.994,-9.3) Y41(19.733,-9.109)
  round 0.279 smd: A5(1.856,0) A45(21.772,0) BC1(0,-20.772) BC49(23.628,-20.772) BG5(1.856,-22.628) BG45(21.772,-22.628) E1(0,-1.856) E49(23.628,-1.856)
  oval 0.203x0.254 smd: A6(2.415,0) A8(3.52,0) A42(20.108,0) A44(21.213,0) BD8(3.403,-21.127) BD12(5.6,-21.127) BD17(7.797,-21.127) BD21(9.994,-21.127) BD29(13.634,-21.127) BD33(15.831,-21.127) BD38(18.028,-21.127) BD42(20.225,-21.127) BE9(4.03,-21.5) BE10(4.531,-21.373) BE14(6.227,-21.5) BE15(6.728,-21.373) BE18(8.424,-21.5) BE19(8.925,-21.373) BE23(10.621,-21.5) BE24(11.122,-21.373) BE26(12.506,-21.373) BE27(13.007,-21.5) BE31(14.703,-21.373) BE32(15.204,-21.5) BE35(16.9,-21.373) BE36(17.401,-21.5) BE40(19.097,-21.373) BE41(19.598,-21.5) BG6(2.415,-22.628) BG8(3.52,-22.628) BG42(20.108,-22.628) BG44(21.213,-22.628) C9(4.03,-1.128) C10(4.531,-1.255) C14(6.227,-1.128) C15(6.728,-1.255) C18(8.424,-1.128) C19(8.925,-1.255) C23(10.621,-1.128) C24(11.122,-1.255) C26(12.506,-1.255) C27(13.007,-1.128) C31(14.703,-1.255) C32(15.204,-1.128) C35(16.9,-1.255) C36(17.401,-1.128) C40(19.097,-1.255) C41(19.598,-1.128) D8(3.403,-1.501) D12(5.6,-1.501) D17(7.797,-1.501) D21(9.994,-1.501) D29(13.634,-1.501) D33(15.831,-1.501) D38(18.028,-1.501) D42(20.225,-1.501)
  oval 0.178x0.254 smd: A13(5.742,0) A17(7.939,0) A22(10.136,0) A25(11.814,0) A28(13.492,0) A33(15.689,0) A37(17.886,0) B10(4.691,-0.711) B12(5.549,-0.498) B14(6.227,-0.627) B15(6.888,-0.711) B17(7.746,-0.498) B18(8.424,-0.627) B19(9.085,-0.711) B21(9.943,-0.498) B23(10.621,-0.627) B24(11.282,-0.711) B25(11.814,-0.508) B26(12.346,-0.711) B27(13.007,-0.627) B29(13.685,-0.498) B31(14.543,-0.711) B32(15.204,-0.627) B33(15.882,-0.498) B35(16.74,-0.711) B36(17.401,-0.627) B38(18.079,-0.498) B40(18.937,-0.711) BE11(5.054,-21.432) BE12(5.519,-21.627) BE16(7.251,-21.432) BE17(7.716,-21.627) BE20(9.448,-21.432) BE21(9.913,-21.627) BE25(11.814,-21.612) BE29(13.715,-21.627) BE30(14.18,-21.432) BE33(15.912,-21.627) BE34(16.377,-21.432) BE38(18.109,-21.627) BE39(18.575,-21.432) BF10(4.691,-21.917) BF12(5.549,-22.129) BF14(6.227,-22) BF15(6.888,-21.917) BF17(7.746,-22.129) BF18(8.424,-22) BF19(9.085,-21.917) BF21(9.943,-22.129) BF23(10.621,-22) BF24(11.282,-21.917) BF25(11.814,-22.12) BF26(12.346,-21.917) BF27(13.007,-22) BF29(13.685,-22.129) BF31(14.543,-21.917) BF32(15.204,-22) BF33(15.882,-22.129) BF35(16.74,-21.917) BF36(17.401,-22) BF38(18.079,-22.129) BF40(18.937,-21.917) BG13(5.742,-22.628) BG17(7.939,-22.628) BG22(10.136,-22.628) BG25(11.814,-22.628) BG28(13.492,-22.628) BG33(15.689,-22.628) BG37(17.886,-22.628) C11(5.054,-1.196) C12(5.519,-1.001) C16(7.251,-1.196) C17(7.716,-1.001) C20(9.448,-1.196) C21(9.913,-1.001) C25(11.814,-1.016) C29(13.715,-1.001) C30(14.18,-1.196) C33(15.912,-1.001) C34(16.377,-1.196) C38(18.109,-1.001) C39(18.575,-1.196)
  oval 0.254x0.178 smd: AA1(0,-9.636) AA49(23.628,-9.636) AB2(0.627,-10.121) AB48(23.001,-10.121) AC2(0.711,-10.782) AC48(22.917,-10.782) AD1(0,-11.314) AD2(0.508,-11.314) AD3(1.016,-11.314) AD47(22.612,-11.314) AD48(23.12,-11.314) AD49(23.628,-11.314) AE2(0.711,-11.846) AE48(22.917,-11.846) AF2(0.627,-12.507) AF48(23.001,-12.507) AG1(0,-12.992) AG49(23.628,-12.992) AH2(0.498,-13.185) AH3(1.001,-13.215) AH47(22.627,-13.215) AH48(23.13,-13.185) AJ3(1.196,-13.68) AJ47(22.432,-13.68) AK2(0.711,-14.043) AK48(22.917,-14.043) AL2(0.627,-14.704) AL48(23.001,-14.704) AM1(0,-15.189) AM2(0.498,-15.382) AM3(1.001,-15.412) AM47(22.627,-15.412) AM48(23.13,-15.382) AM49(23.628,-15.189) AN3(1.196,-15.877) AN47(22.432,-15.877) AP2(0.711,-16.24) AP48(22.917,-16.24) P2(0.711,-6.388) P48(22.917,-6.388) R3(1.196,-6.751) R47(22.432,-6.751) T1(0,-7.439) T2(0.498,-7.246) T3(1.001,-7.216) T47(22.627,-7.216) T48(23.13,-7.246) T49(23.628,-7.439) U2(0.627,-7.924) U48(23.001,-7.924) V2(0.711,-8.585) V48(22.917,-8.585) W3(1.196,-8.948) W47(22.432,-8.948) Y2(0.498,-9.443) Y3(1.001,-9.413) Y47(22.627,-9.413) Y48(23.13,-9.443)
  round 0.254 smd: AA5(1.958,-9.712) AA45(21.67,-9.712) AC4(1.754,-10.735) AC46(21.874,-10.735) AE4(1.754,-11.893) AE46(21.874,-11.893) AG5(1.958,-12.915) AG45(21.67,-12.915) AJ4(1.716,-13.588) AJ46(21.912,-13.588) AK4(1.754,-14.09) AK46(21.874,-14.09) AM5(1.958,-15.112) AM45(21.67,-15.112) AN4(1.716,-15.785) AN46(21.912,-15.785) AP4(1.754,-16.287) AP46(21.874,-16.287) AT5(1.958,-17.31) AT45(21.67,-17.31) AV4(1.716,-17.982) AV46(21.912,-17.982) AW4(1.754,-18.484) AW46(21.874,-18.484) B6(2.417,-0.503) B44(21.211,-0.503) BA2(0.498,-19.84) BA3(1.005,-19.908) BA4(1.51,-19.782) BA5(1.958,-19.507) BA45(21.67,-19.507) BA46(22.118,-19.782) BA47(22.623,-19.908) BA48(23.13,-19.84) BB3(0.496,-20.629) BB4(0.989,-20.44) BB46(22.64,-20.44) BB47(23.132,-20.629) BC8(3.621,-20.67) BC10(4.644,-20.874) BC13(5.818,-20.67) BC15(6.841,-20.874) BC17(8.015,-20.67) BC19(9.038,-20.874) BC22(10.213,-20.67) BC24(11.235,-20.874) BC26(12.393,-20.874) BC28(13.416,-20.67) BC31(14.59,-20.874) BC33(15.613,-20.67) BC35(16.787,-20.874) BC37(17.81,-20.67) BC40(18.984,-20.874) BC42(20.007,-20.67) BD7(2.9,-21.186) BD11(5.146,-20.912) BD16(7.343,-20.912) BD20(9.54,-20.912) BD30(14.088,-20.912) BD34(16.285,-20.912) BD39(18.483,-20.912) BD43(20.728,-21.186) BE6(2.723,-21.671) BE44(20.905,-21.671) BF6(2.417,-22.125) BF44(21.211,-22.125) C6(2.723,-0.957) C44(20.905,-0.957) D7(2.9,-1.441) D11(5.146,-1.716) D16(7.343,-1.716) D20(9.54,-1.716) D30(14.088,-1.716) D34(16.285,-1.716) D39(18.483,-1.716) D43(20.728,-1.441) E8(3.621,-1.958) E10(4.644,-1.754) E13(5.818,-1.958) E15(6.841,-1.754) E17(8.015,-1.958) E19(9.038,-1.754) E22(10.213,-1.958) E24(11.235,-1.754) E26(12.393,-1.754) E28(13.416,-1.958) E31(14.59,-1.754) E33(15.613,-1.958) E35(16.787,-1.754) E37(17.81,-1.958) E40(18.984,-1.754) E42(20.007,-1.958) F3(0.496,-1.999) F4(0.989,-2.187) F46(22.64,-2.187) F47(23.132,-1.999) G2(0.498,-2.788) G3(1.005,-2.72) G4(1.51,-2.846) G5(1.958,-3.121) G45(21.67,-3.121) G46(22.118,-2.846) G47(22.623,-2.72) G48(23.13,-2.788) J4(1.754,-4.144) J46(21.874,-4.144) K4(1.716,-4.645) K46(21.912,-4.645) M5(1.958,-5.318) M45(21.67,-5.318) P4(1.754,-6.341) P46(21.874,-6.341) R4(1.716,-6.843) R46(21.912,-6.843) T5(1.958,-7.515) T45(21.67,-7.515) V4(1.754,-8.538) V46(21.874,-8.538) W4(1.716,-9.04) W46(21.912,-9.04)
  oval 0.254x0.203 smd: AB3(1.128,-10.121) AB47(22.5,-10.121) AC3(1.255,-10.622) AC47(22.373,-10.622) AE3(1.255,-12.006) AE47(22.373,-12.006) AF3(1.128,-12.507) AF47(22.5,-12.507) AH4(1.501,-13.134) AH46(22.127,-13.134) AK3(1.255,-14.197) AK47(22.373,-14.197) AL3(1.128,-14.704) AL47(22.5,-14.704) AM4(1.501,-15.331) AM46(22.127,-15.331) AP3(1.255,-16.394) AP47(22.373,-16.394) AR3(1.128,-16.901) AR47(22.5,-16.901) AT1(0,-17.411) AT49(23.628,-17.411) AU4(1.501,-17.528) AU46(22.127,-17.528) AW3(1.255,-18.591) AW47(22.373,-18.591) AY3(1.128,-19.098) AY47(22.5,-19.098) BA1(0,-19.634) BA49(23.628,-19.634) G1(0,-2.994) G49(23.628,-2.994) H3(1.128,-3.53) H47(22.5,-3.53) J3(1.255,-4.037) J47(22.373,-4.037) L4(1.501,-5.1) L46(22.127,-5.1) M1(0,-5.217) M49(23.628,-5.217) N3(1.128,-5.727) N47(22.5,-5.727) P3(1.255,-6.234) P47(22.373,-6.234) T4(1.501,-7.297) T46(22.127,-7.297) U3(1.128,-7.924) U47(22.5,-7.924) V3(1.255,-8.431) V47(22.373,-8.431) Y4(1.501,-9.494) Y46(22.127,-9.494)
  oval 0.305x0.152 smd: AR2(0.627,-16.901) AR48(23.001,-16.901) AU2(0.498,-17.579) AU3(1.001,-17.609) AU47(22.627,-17.609) AU48(23.13,-17.579) AV3(1.196,-18.074) AV47(22.432,-18.074) AW2(0.711,-18.437) AW48(22.917,-18.437) AY2(0.627,-19.098) AY48(23.001,-19.098) H2(0.627,-3.53) H48(23.001,-3.53) J2(0.711,-4.19) J48(22.917,-4.19) K3(1.196,-4.553) K47(22.432,-4.553) L2(0.498,-5.049) L3(1.001,-5.019) L47(22.627,-5.019) L48(23.13,-5.049) N2(0.627,-5.727) N48(23.001,-5.727)
  oval 0.152x0.305 smd: B8(3.352,-0.498) B9(4.03,-0.627) B41(19.598,-0.627) B42(20.276,-0.498) BE8(3.322,-21.627) BE42(20.307,-21.627) BF8(3.352,-22.129) BF9(4.03,-22) BF41(19.598,-22) BF42(20.276,-22.129) C8(3.322,-1.001) C42(20.307,-1.001)
CVILU_CF2006FV0RK-NH_6P
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3)
  rect 0.787x1.499 smd: 7(-1,0) 8(-1,3) 9(3.5,0) 10(3.5,3)
CVILU_CF2020FV0RK-NH_20P
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3) 7(3,0) 8(3.5,3) 9(4,0) 10(4.5,3) 11(5,0) 12(5.5,3) 13(6,0) 14(6.5,3) 15(7,0) 16(7.5,3) 17(8,0) 18(8.5,3) 19(9,0) 20(9.5,3)
  rect 0.787x1.499 smd: 21(-1,0) 22(-1,3) 23(10.5,0) 24(10.5,3)
CYNTE_PCMB042T-1R0MS_2P
  rect 1.499x2.489 smd: 1(0,0) 2(3.7,0)
CYNTE_PCMC063T-R68MN_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
CYPD5256-96BZXI_BGA_96P
  round 0.254 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2.001,0) A6(2.501,0) A7(3.001,0) A8(3.501,0) A9(4.001,0) A10(4.501,0) A11(5.001,0) B1(0,-0.5) B2(0.5,-0.5) B3(1,-0.5) B4(1.5,-0.5) B5(2.001,-0.5) B6(2.501,-0.5) B7(3.001,-0.5) B8(3.501,-0.5) B9(4.001,-0.5) B10(4.501,-0.5) B11(5.001,-0.5) C1(0,-1) C2(0.5,-1) C10(4.501,-1) C11(5.001,-1) D1(0,-1.5) D2(0.5,-1.5) D5(2.001,-1.5) D6(2.501,-1.5) D7(3.001,-1.5) D8(3.501,-1.5) D10(4.501,-1.5) D11(5.001,-1.5) E1(0,-2.001) E2(0.5,-2.001) E4(1.5,-2.001) E5(2.001,-2.001) E6(2.501,-2.001) E7(3.001,-2.001) E8(3.501,-2.001) E10(4.501,-2.001) E11(5.001,-2.001) F1(0,-2.501) F2(0.5,-2.501) F4(1.5,-2.501) F5(2.001,-2.501) F6(2.501,-2.501) F7(3.001,-2.501) F8(3.501,-2.501) F10(4.501,-2.501) F11(5.001,-2.501) G1(0,-3.001) G2(0.5,-3.001) G4(1.5,-3.001) G5(2.001,-3.001) G6(2.501,-3.001) G7(3.001,-3.001) G8(3.501,-3.001) G10(4.501,-3.001) G11(5.001,-3.001) H1(0,-3.501) H2(0.5,-3.501) H4(1.5,-3.501) H5(2.001,-3.501) H6(2.501,-3.501) H7(3.001,-3.501) H8(3.501,-3.501) H10(4.501,-3.501) H11(5.001,-3.501) J1(0,-4.001) J2(0.5,-4.001) J10(4.501,-4.001) J11(5.001,-4.001) K1(0,-4.501) K2(0.5,-4.501) K3(1,-4.501) K4(1.5,-4.501) K5(2.001,-4.501) K6(2.501,-4.501) K7(3.001,-4.501) K8(3.501,-4.501) K9(4.001,-4.501) K10(4.501,-4.501) K11(5.001,-4.501) L1(0,-5.001) L2(0.5,-5.001) L3(1,-5.001) L4(1.5,-5.001) L5(2.001,-5.001) L6(2.501,-5.001) L7(3.001,-5.001) L8(3.501,-5.001) L9(4.001,-5.001) L10(4.501,-5.001) L11(5.001,-5.001)
D_0603
  oval 0.864x1.219 smd: 1(-0.711,0) 2(0.711,0)
D_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.14,0)
DEREN_40-42251-01001RHF_10P-T
  oval 0.838x2.21 smd: 1(0,0.1) 2(1.5,0.1) 3(3,0.1) 4(4.5,0.1) 5(6,0.1) 6(7.5,0.1) 7(9,0.1) 8(10.5,0.1) 9(12,0.1) 10(13.5,0.1)
  custom 0.75x0.75 smd: 11(-3.4,-3.15) 12(16.9,-3.15)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN65D8LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DMN66D0LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
DMN3150LW-7_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
DPS1113FIA-13_QFN18_4X4
  oval 0.762x1.295 smd: 1(0,0) 13(3.85,0)
  oval 0.762x0.305 smd: 2(0,-1) 3(0,-1.5) 4(0,-2) 10(3.85,-2) 11(3.85,-1.5) 12(3.85,-1)
  oval 0.305x0.762 smd: 5(0.925,-2.925) 6(1.425,-2.925) 7(1.925,-2.925) 8(2.425,-2.925) 9(2.925,-2.925)
  rect 2.591x2.972 smd: 14(1.925,-0.813)
EM5201V_DFN3X3-8-X
  oval 0.305x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.8)
  rect 1.6x0.61 smd: 6(0.65,2.8)
  rect 2.388x1.6 smd: 7(0.975,1.4)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
EMB80P03JS_SOT-23-3
  oval 0.787x1.194 smd: 1(0,0) 2(0.95,2.2) 3(-0.95,2.2)
F_T0603FF1000TM
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
F_T0603FF1500TM
  rect 0.711x0.991 smd: 1(0,0) 2(1.5,0)
FDV301N_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
FOX_UT12113-1160D-7H_48P
  oval 0.838x0.787 hole 0.838x0.787 unplated: (-6.225,2.6)
  round 0.787 hole 0.787 unplated: (17.175,2.6)
  oval 1.651x1.092 hole 1.295x0.711: 1(-6.645,1.2) 2(17.595,1.2)
  oval 0.279x0.889 smd: 1A1(16.2,0) 1A2(15.7,0) 1A3(15.2,0) 1A4(14.7,0) 1A5(14.2,0) 1A6(13.7,0) 1A7(13.2,0) 1A8(12.7,0) 1A9(12.2,0) 1A10(11.7,0) 1A11(11.2,0) 1A12(10.7,0) A1(0,0) A2(-0.5,0) A3(-1,0) A4(-1.5,0) A5(-2,0) A6(-2.5,0) A7(-3,0) A8(-3.5,0) A9(-4,0) A10(-4.5,0) A11(-5,0) A12(-5.5,0)
  oval 0.279x0.787 smd: 1B1(10.95,1.5) 1B2(11.45,1.5) 1B3(11.95,1.5) 1B4(12.45,1.5) 1B5(12.95,1.5) 1B6(13.45,1.5) 1B7(13.95,1.5) 1B8(14.45,1.5) 1B9(14.95,1.5) 1B10(15.45,1.5) 1B11(15.95,1.5) 1B12(16.45,1.5) B1(-5.25,1.5) B2(-4.75,1.5) B3(-4.25,1.5) B4(-3.75,1.5) B5(-3.25,1.5) B6(-2.75,1.5) B7(-2.25,1.5) B8(-1.75,1.5) B9(-1.25,1.5) B10(-0.75,1.5) B11(-0.25,1.5) B12(0.25,1.5)
  oval 1.194x2.311 hole 0.711x1.905: 3(-6.945,0.6) 4(17.895,0.6)
  oval 1.295x2.591 hole 0.711x2.007: 5(-6.945,5.65) 6(1.695,5.65) 7(9.255,5.65) 8(17.895,5.65)
  oval 1.092x1.016 hole 0.787x0.711: 9(1.145,1.2) 10(9.805,1.2)
G524B1T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
G5719CRC1U_TDFN8_2X2
  oval 0.254x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.15) 6(1,2.15) 7(0.5,2.15) 8(0,2.15)
  rect 1.549x0.838 smd: 9(0.75,1.075)
H_2P0N
  round 2.007 hole 2.007 unplated: (0,0)
H_2P5
  round 2.997 hole 2.489: 1(0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_2P8X2P0N
  oval 2.794x2.007 hole 2.794x2.007 unplated: (0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P7
  round 4.216 hole 3.708: 1(0,0)
HRS_TF31-6S-0P5SH_6P-T
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0)
  rect 1.905x2.21 smd: 7(-1.95,-3.25) 8(4.45,-3.25)
HRS_TF31C-26S-0P5SH-800_26P-T
  oval 0.305x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0)
  rect 1.905x2.21 smd: 27(14.45,3.25) 28(-1.95,3.25)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
IT8306FN-CX-R_QFN28_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 6(0,-2.25) 7(0,-2.7) 15(4.1,-2.7) 16(4.1,-2.25) 17(4.1,-1.8) 18(4.1,-1.35) 19(4.1,-0.9) 20(4.1,-0.45) 21(4.1,0)
  oval 0.254x0.889 smd: 8(0.7,-3.4) 9(1.15,-3.4) 10(1.6,-3.4) 11(2.05,-3.4) 12(2.5,-3.4) 13(2.95,-3.4) 14(3.4,-3.4) 22(3.4,0.7) 23(2.95,0.7) 24(2.5,0.7) 25(2.05,0.7) 26(1.6,0.7) 27(1.15,0.7) 28(0.7,0.7)
  rect 2.591x2.591 smd: 29(2.05,-1.35)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JUMP_43X118-NPM
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
JXT_FP241AH-010GAAM_10P
  oval 0.305x1.092 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.406x0.787 smd: 11(-1,-2.65) 12(5.5,-2.65)
JXT_FP270H-061G1AM_61P
  oval 0.305x0.787 smd: 1(0,0) 3(0.6,0) 5(1.2,0) 7(1.8,0) 9(2.4,0) 11(3,0) 13(3.6,0) 15(4.2,0) 17(4.8,0) 19(5.4,0) 21(6,0) 23(6.6,0) 25(7.2,0) 27(7.8,0) 29(8.4,0) 31(9,0) 33(9.6,0) 35(10.2,0) 37(10.8,0) 39(11.4,0) 41(12,0) 43(12.6,0) 45(13.2,0) 47(13.8,0) 49(14.4,0) 51(15,0) 53(15.6,0) 55(16.2,0) 57(16.8,0) 59(17.4,0) 61(18,0)
  oval 0.305x0.66 smd: 2(0.3,2.875) 4(0.9,2.875) 6(1.5,2.875) 8(2.1,2.875) 10(2.7,2.875) 12(3.3,2.875) 14(3.9,2.875) 16(4.5,2.875) 18(5.1,2.875) 20(5.7,2.875) 22(6.3,2.875) 24(6.9,2.875) 26(7.5,2.875) 28(8.1,2.875) 30(8.7,2.875) 32(9.3,2.875) 34(9.9,2.875) 36(10.5,2.875) 38(11.1,2.875) 40(11.7,2.875) 42(12.3,2.875) 44(12.9,2.875) 46(13.5,2.875) 48(14.1,2.875) 50(14.7,2.875) 52(15.3,2.875) 54(15.9,2.875) 56(16.5,2.875) 58(17.1,2.875) 60(17.7,2.875)
  rect 0.305x1.143 smd: 62(-0.65,0.375) 63(18.65,0.375)
L2N7002DW1T1G_SC88-6
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
L2N7002WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
L03ESDL5V0CC3-2_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
L_5X5X3_M_2P
  rect 2.159x2.794 smd: 1(0,0) 2(4.35,0)
L_7X7X3_M_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
L_7X7X4_M
  custom 0.591x0.591 smd: 1(0,0) 4(6.05,0)
  rect 0.762x0.508 smd: 2(0.8,0) 3(5.25,0)
LM393DGKR_VSSOP8
  oval 1.575x0.381 smd: 1(0,0) 2(0,-0.65) 3(0,-1.3) 4(0,-1.95) 5(4.35,-1.95) 6(4.35,-1.3) 7(4.35,-0.65) 8(4.35,0)
LMBT3904WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
LMUN5111T1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
LNG2DMTR_LGA12_2X2
  oval 0.406x0.305 smd: 1(0,0) 4(0,-1.5) 7(1.602,-1.5) 10(1.602,0)
  oval 0.508x0.305 smd: 2(0.051,-0.5) 3(0.051,-1) 8(1.551,-1) 9(1.551,-0.5)
  oval 0.305x0.508 smd: 5(0.551,-1.5) 6(1.051,-1.5) 11(1.051,0) 12(0.551,0)
LOTES_ADDR0208-P001A_260P
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(0.425,7.9) 262(-67.175,7.9)
LOTES_AP-APCI0356-P001A_75P
  round 1.092 hole 1.092 unplated: (-1.75,-1.7)
  round 1.6 hole 1.6 unplated: (20.25,-1.7)
  oval 0.305x1.499 smd: 1(0,0) 3(0.5,0) 5(1,0) 7(1.5,0) 9(2,0) 11(2.5,0) 13(3,0) 15(3.5,0) 17(4,0) 19(4.5,0) 21(5,0) 23(5.5,0) 25(6,0) 27(6.5,0) 29(7,0) 31(7.5,0) 33(8,0) 35(8.5,0) 37(9,0) 39(9.5,0) 41(10,0) 43(10.5,0) 45(11,0) 47(11.5,0) 49(12,0) 51(12.5,0) 53(13,0) 55(13.5,0) 57(14,0) 67(16.5,0) 69(17,0) 71(17.5,0) 73(18,0) 75(18.5,0)
  round 0.762 hole 0.508: 2(0.25,-2.59) 4(0.75,-1.79) 6(1.25,-2.59) 8(1.75,-1.79) 10(2.25,-2.59) 12(2.75,-1.79) 14(3.25,-2.59) 16(3.75,-1.79) 18(4.25,-2.59) 20(4.75,-1.79) 22(5.25,-2.59) 24(5.75,-1.79) 26(6.25,-2.59) 28(6.75,-1.79) 30(7.25,-2.59) 32(7.75,-1.79) 34(8.25,-2.59) 36(8.75,-1.79) 38(9.25,-2.59) 40(9.75,-1.79) 42(10.25,-2.59) 44(10.75,-1.79) 46(11.25,-2.59) 48(11.75,-1.79) 50(12.25,-2.59) 52(12.75,-1.79) 54(13.25,-2.59) 56(13.75,-1.79) 58(14.25,-2.59) 68(16.75,-1.79) 70(17.25,-2.59) 72(17.75,-1.79) 74(18.25,-2.59)
  oval 0.889x2.159 hole 0.508x1.753: 76(-2,-5.75) 77(20.5,-5.75)
LOTES_APCI0071-P001A_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
MAG_MMD05CZR47M_4P
  custom 0.54x0.54 smd: 1(0,0) 4(4.35,0)
  rect 0.762x0.508 smd: 2(0.699,0) 3(3.652,0)
MAG_MND-04ABIR60M-XGL_2P
  rect 1.448x3.708 smd: 1(0,0) 2(2.845,0)
MC74VHC1G08DFT2G_SC70-5
  oval 0.381x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MC74VHC1G09DFT2G_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MEC5105_WFBGA_169P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A6(4,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B6(4,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C6(4,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D6(4,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E6(4,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F6(4,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G6(4,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H6(4,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J6(4,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K6(4,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L6(4,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M6(4,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N6(4,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601)
MHPC_NS692417_24P
  oval 0.762x2.057 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(5.08,0) 6(6.35,0) 7(7.62,0) 8(8.89,0) 9(10.16,0) 10(11.43,0) 11(12.7,0) 12(13.97,0) 13(13.97,9.365) 14(12.7,9.365) 15(11.43,9.365) 16(10.16,9.365) 17(8.89,9.365) 18(7.62,9.365) 19(6.35,9.365) 20(5.08,9.365) 21(3.81,9.365) 22(2.54,9.365) 23(1.27,9.365) 24(0,9.365)
MM3Z22VST1G_SOD323-2
  rect 0.635x0.838 smd: 1(0,0) 2(2.225,0)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15GA750SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15HG601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX330SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX600SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM18EG221SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18KG331SN1D_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MURAT_DLW21HN900HQ2L_4P
  rect 0.889x0.356 smd: 1(0,0) 2(1.7,0) 3(1.7,0.85) 4(0,0.85)
MURAT_LQM18PN1R0MFHD_2P
  rect 0.61x0.711 smd: 1(0,0) 2(1.3,0)
MX25L25645GM2I-10G_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
NB681GD-Z_QFN13_2X3
  oval 1.702x0.254 smd: 1(0,0) 2(0,-1) 8(1.3,-0.5)
  oval 0.254x0.889 smd: 3(-0.1,-2.05) 4(0.4,-2.05) 5(0.9,-2.05) 6(1.4,-2.05) 10(1.4,1.05) 11(0.9,1.05) 12(0.4,1.05) 13(-0.1,1.05)
  oval 0.889x0.254 smd: 7(1.706,-1) 9(1.706,0)
NCP81215DMNTXG_QFN52_6X6
  oval 0.762x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 27(5.9,-4.8) 28(5.9,-4.4) 29(5.9,-4) 30(5.9,-3.6) 31(5.9,-3.2) 32(5.9,-2.8) 33(5.9,-2.4) 34(5.9,-2) 35(5.9,-1.6) 36(5.9,-1.2) 37(5.9,-0.8) 38(5.9,-0.4) 39(5.9,0)
  oval 0.254x0.762 smd: 14(0.55,-5.35) 15(0.95,-5.35) 16(1.35,-5.35) 17(1.75,-5.35) 18(2.15,-5.35) 19(2.55,-5.35) 20(2.95,-5.35) 21(3.35,-5.35) 22(3.75,-5.35) 23(4.15,-5.35) 24(4.55,-5.35) 25(4.95,-5.35) 26(5.35,-5.35) 40(5.35,0.55) 41(4.95,0.55) 42(4.55,0.55) 43(4.15,0.55) 44(3.75,0.55) 45(3.35,0.55) 46(2.95,0.55) 47(2.55,0.55) 48(2.15,0.55) 49(1.75,0.55) 50(1.35,0.55) 51(0.95,0.55) 52(0.55,0.55)
  rect 4.699x4.699 smd: 53(2.95,-2.4)
NCP302045MNTXG_PQFN33_5X5-S
  oval 0.305x0.61 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0)
  custom 0.32x0.32 smd: 9(3.135,1.215)
  custom 0.543x0.543 smd: 10(2.225,3.215)
  rect 3.81x0.61 smd: 11(1.75,4.8)
  rect 0.61x1.295 smd: 12(-0.65,3.65)
  oval 0.61x0.305 smd: 13(-0.65,2.65) 14(-0.65,2.15) 15(-0.65,1.65) 16(-0.65,1.15) 17(-0.65,0.65)
  rect 1.422x1.118 smd: 18(0.7,1.215)
  rect 0.584x0.356 smd: 19(0.09,2.625)
NPCT750JABYX_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.505x3.505 smd: 33(2.55,-1.75)
P_M74VHC1GT125DF2G_SC70_5P
  oval 0.33x0.61 smd: 1(-0.65,-1.05) 2(0,-1.05) 3(0.65,-1.05) 4(0.65,1.05) 5(-0.65,1.05)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PESD24VS2UT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PJ2301_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8331BQFN60GTR-A0_QFN60_5X9-S
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0) 11(4,0) 12(4.4,0) 13(4.8,0) 14(5.2,0) 15(5.6,0) 16(6,0) 17(6.4,0) 18(6.8,0) 19(7.2,0) 20(7.6,0) 31(7.6,4.975) 32(7.2,4.975) 33(6.8,4.975) 34(6.4,4.975) 35(6,4.975) 36(5.6,4.975) 37(5.2,4.975) 38(4.8,4.975) 39(4.4,4.975) 40(4,4.975) 41(3.6,4.975) 42(3.2,4.975) 43(2.8,4.975) 44(2.4,4.975) 45(2,4.975) 46(1.6,4.975) 47(1.2,4.975) 48(0.8,4.975) 49(0.4,4.975) 50(0,4.975)
  oval 1.016x0.203 smd: 21(8.288,0.688) 22(8.288,1.088) 23(8.288,1.488) 24(8.288,1.888) 25(8.288,2.288) 26(8.288,2.688) 27(8.288,3.088) 28(8.288,3.488) 29(8.288,3.888) 30(8.288,4.288) 51(-0.688,4.288) 52(-0.688,3.888) 53(-0.688,3.488) 54(-0.688,3.088) 55(-0.688,2.688) 56(-0.688,2.288) 57(-0.688,1.888) 58(-0.688,1.488) 59(-0.688,1.088) 60(-0.688,0.688)
  rect 7.01x2.997 smd: 61(3.8,2.488)
PS8338BQFN60GTR-A1_QFN60_5X9
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 31(5.1,-7.6) 32(5.1,-7.2) 33(5.1,-6.8) 34(5.1,-6.4) 35(5.1,-6) 36(5.1,-5.6) 37(5.1,-5.2) 38(5.1,-4.8) 39(5.1,-4.4) 40(5.1,-4) 41(5.1,-3.6) 42(5.1,-3.2) 43(5.1,-2.8) 44(5.1,-2.4) 45(5.1,-2) 46(5.1,-1.6) 47(5.1,-1.2) 48(5.1,-0.8) 49(5.1,-0.4) 50(5.1,0)
  oval 0.203x0.889 smd: 21(0.75,-8.35) 22(1.15,-8.35) 23(1.55,-8.35) 24(1.95,-8.35) 25(2.35,-8.35) 26(2.75,-8.35) 27(3.15,-8.35) 28(3.55,-8.35) 29(3.95,-8.35) 30(4.35,-8.35) 51(4.35,0.75) 52(3.95,0.75) 53(3.55,0.75) 54(3.15,0.75) 55(2.75,0.75) 56(2.35,0.75) 57(1.95,0.75) 58(1.55,0.75) 59(1.15,0.75) 60(0.75,0.75)
  rect 2.997x7.01 smd: 61(2.55,-3.8)
PS8461QFN66GTR-A0_QFN66_5X10
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 23(0,-8.8) 34(5.1,-8.8) 35(5.1,-8.4) 36(5.1,-8) 37(5.1,-7.6) 38(5.1,-7.2) 39(5.1,-6.8) 40(5.1,-6.4) 41(5.1,-6) 42(5.1,-5.6) 43(5.1,-5.2) 44(5.1,-4.8) 45(5.1,-4.4) 46(5.1,-4) 47(5.1,-3.6) 48(5.1,-3.2) 49(5.1,-2.8) 50(5.1,-2.4) 51(5.1,-2) 52(5.1,-1.6) 53(5.1,-1.2) 54(5.1,-0.8) 55(5.1,-0.4) 56(5.1,0)
  oval 0.203x0.889 smd: 24(0.75,-9.45) 25(1.15,-9.45) 26(1.55,-9.45) 27(1.95,-9.45) 28(2.35,-9.45) 29(2.75,-9.45) 30(3.15,-9.45) 31(3.55,-9.45) 32(3.95,-9.45) 33(4.35,-9.45) 57(4.35,0.65) 58(3.95,0.65) 59(3.55,0.65) 60(3.15,0.65) 61(2.75,0.65) 62(2.35,0.65) 63(1.95,0.65) 64(1.55,0.65) 65(1.15,0.65) 66(0.75,0.65)
  rect 3.607x8.611 smd: 67(2.55,-4.4)
PS8713BTQFN24GTR2-A_TQFN24_4X4
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 13(4.1,-2.5) 14(4.1,-2) 15(4.1,-1.5) 16(4.1,-1) 17(4.1,-0.5) 18(4.1,0)
  oval 0.254x0.889 smd: 7(0.8,-3.3) 8(1.3,-3.3) 9(1.8,-3.3) 10(2.3,-3.3) 11(2.8,-3.3) 12(3.3,-3.3) 19(3.3,0.8) 20(2.8,0.8) 21(2.3,0.8) 22(1.8,0.8) 23(1.3,0.8) 24(0.8,0.8)
  rect 2.692x2.692 smd: 25(2.05,-1.25)
Q_N_DFN33-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.625x0.625 smd: 5(0.975,2.15)
Q_N_DFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
Q_P_DFN33-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.625x0.625 smd: 5(0.975,2.15)
Q_P_DFN56-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
Q_P_SO8
  oval 0.635x1.854 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,5.165) 6(2.54,5.165) 7(1.27,5.165) 8(0,5.165)
R0201_0OHM
  custom 0.089x0.089 smd: 1(0,0)
  rect 0.381x0.356 smd: 2(0.584,0)
R0402_0OHM
  custom 0.14x0.14 smd: 1(0,0)
  rect 0.508x0.559 smd: 2(0.914,0)
R0603_0OHM
  custom 0.222x0.222 smd: 1(0,0)
  rect 0.635x0.889 smd: 2(1.397,0)
R0805_0OHM
  custom 0.349x0.349 smd: 1(0,0)
  rect 0.813x1.397 smd: 2(1.702,0)
R1206_0OHM
  custom 0.413x0.413 smd: 1(0,0)
  rect 1.016x1.651 smd: 2(2.667,0)
R_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P-D
  custom 0.371x0.371 smd: 1(0,0) 4(3.327,0)
  custom 0.114x0.114 smd: 2(0.775,0) 3(2.553,0)
RB520SM-30T2R_EMD2-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751S40T1G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.7,0)
RB751S-40_SOD523-2
  rect 0.61x0.711 smd: 1(0,0) 2(1.7,0)
RB751V40_SC76-2
  rect 0.61x0.61 smd: 1(0,0) 2(2.2,0)
RB751VM-40TE-17_SOD323-2
  rect 0.787x0.889 smd: 1(0,0) 2(2.1,0)
RT8207PGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT9069-33GB_SOT23-5
  oval 0.711x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.6) 5(0,2.6)
RTS5243-GR_QFN48_6X6
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
SANTA_130456-911_13P-T
  round 1.194 hole 0.889: 1(0,0) 2(-1.02,-1.1) 3(-2.04,0) 4(-3.06,-1.1) 5(-4.08,0) 6(-5.1,-1.1) 7(-6.12,0) 8(-7.14,-1.1)
  oval 1.092x2.997 hole 0.508x2.388: 9(-11.595,-7.5) 10(4.455,-7.5)
  round 1.295 hole 0.991: A1(1,2.75) A2(3.29,2.75) B1(-10.43,2.75) B2(-9.28,0.75) B3(-8.14,2.75)
SBR1A20T5-7_SOD523-2-2
  rect 0.61x0.711 smd: 1(0,0) 2(1.4,0)
SBR3A40SA-13_SMA2
  rect 2.489x1.702 smd: 1(0,0) 2(4,0)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SDMP0340LAT-7-F_SOT-523-3
  oval 0.406x0.508 smd: 1(0,0) 2(-0.5,-1.3) 3(0.5,-1.3)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SHORTPADS-NPM
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI1303DL-T1-E3_SOT323-3
  oval 0.559x0.66 smd: 1(0,0) 2(-0.623,-1.791) 3(0.623,-1.791)
SINGA_2SJ3088-025111F_6P-T
  round 1.194 hole 1.194 unplated: (1.6,2.6) (6,5.1)
  oval 0.991x1.803 hole 0.61x1.397: 1(0,0) 2(7.5,6.6) 3(0.1,8.7) 4(8.4,8.7) 5(6,0) 6(7.6,0)
  oval 0.991x1.905 hole 0.61x1.499: 7(8.4,4.2) 8(-0.8,4.2)
SINGA_2UB1593-120111F_9P
  round 1.295 hole 0.787: 1(0,0) 2(2.5,0) 3(4.5,0) 4(7,0) 5(7.5,1.5) 6(5.5,1.5) 7(3.5,1.5) 8(1.5,1.5) 9(-0.5,1.5)
  oval 1.397x2.896 hole 0.787x2.311: 10(-3.7,0.045) 11(10.7,0.045)
  oval 1.397x2.311 hole 0.787x1.702: 12(-3.7,-6.78) 13(10.7,-6.78)
SLGC55544CVTR_TQFN16_3X3
  oval 0.254x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 9(1.5,3.1) 10(1,3.1) 11(0.5,3.1) 12(0,3.1)
  oval 0.889x0.254 smd: 5(2.3,0.8) 6(2.3,1.3) 7(2.3,1.8) 8(2.3,2.3) 13(-0.8,2.3) 14(-0.8,1.8) 15(-0.8,1.3) 16(-0.8,0.8)
  rect 1.702x1.702 smd: 17(0.75,1.55)
SN74AHC1G08DCKR_SC70-5
  oval 0.381x1.295 smd: 1(0,0.15) 2(0.65,0.15) 3(1.3,0.15) 4(1.3,1.89) 5(0,1.89)
SS5P10-M3-86A_TO277A3
  rect 4.801x4.724 smd: 1(0,0)
  rect 1.397x1.27 smd: 2(-1.04,-3.805) 3(1.04,-3.805)
SW_SKRBAAE010_4P
  rect 0.991x0.889 smd: 1(0,0) 2(0,-3.9) 3(3.85,0) 4(3.85,-3.9)
SW_SS3-CMFTQR9_3P
  oval 0.991x2.489 smd: 1(0,0) 2(2,0) 3(4,0)
  round 1.651 hole 0.889: 4(-0.15,-3.75) 5(6.15,-3.75)
SY8288BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8288CRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
T-SOL_156-1110302600_19P
  round 1.194 hole 1.194 unplated: (-17,-26.375) (3,-26.375)
  oval 0.711x1.549 smd: 1(0,0) 2(-1.5,0) 4(-9,0) 5(-10.5,0) 6(-13.5,0) 7(-15,0) 8(-16.5,0) 9(1.5,0) 17(-12,0) 18(-18,0)
  oval 0.61x1.549 smd: 3(-4.45,0)
  rect 1.803x1.702 smd: 10(-12.95,-26.53) 13(-2.45,-26.53)
  oval 0.787x1.27 smd: 11(-2.575,-20.08) 12(-4.075,-20.08) 14(-8.55,-20.08) 15(-10.075,-20.08) 16(-11.575,-20.08)
  rect 1.092x1.245 smd: 19(4.8,0.3) 21(-19.25,0.3)
  rect 0.991x1.245 smd: 20(-5.7,0.3)
  rect 0.991x1.803 smd: 22(6.75,-14.675) 23(6.75,-27.625) 24(-20.75,-21.175) 25(-20.75,-27.625)
T-SOL_159-1201300600_8P
  oval 0.508x1.245 smd: 1(0,0) 2(0.7,0) 3(1.4,0) 4(2.1,0) 5(2.8,0) 6(3.5,0) 7(4.2,0) 8(4.9,0)
  rect 1.295x1.295 smd: 9(-4.515,-1.515) 10(9.415,-1.515) 11(-4.515,-12.515) 12(9.415,-12.515)
TAI-T_HCB2012VF-601T20_2P
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAI-T_HPC252012NF-2R2M_2P
  rect 0.94x2.21 smd: 1(0,0) 2(1.75,0)
TAIYO_FBMJ4516HS720NT_2P
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SH09FU_SSOP5
  oval 0.381x1.321 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.8) 5(0,1.8)
THUNDERBOLT_BGA_337P
  round 0.254 smd: A1(0,0) A23(-10.12,0) AA2(-0.46,9.2) AA22(-9.66,9.2) AB2(-0.46,9.66) AB3(-0.92,9.66) AB4(-1.38,9.66) AB5(-1.84,9.66) AB6(-2.3,9.66) AB7(-2.76,9.66) AB8(-3.22,9.66) AB9(-3.68,9.66) AB10(-4.14,9.66) AB11(-4.6,9.66) AB12(-5.06,9.66) AB13(-5.52,9.66) AB14(-5.98,9.66) AB15(-6.44,9.66) AB16(-6.9,9.66) AB17(-7.36,9.66) AB18(-7.82,9.66) AB19(-8.28,9.66) AB20(-8.74,9.66) AB21(-9.2,9.66) AB22(-9.66,9.66) AC1(0,10.12) AC23(-10.12,10.12) B2(-0.46,0.46) B3(-0.92,0.46) B4(-1.38,0.46) B5(-1.84,0.46) B6(-2.3,0.46) B7(-2.76,0.46) B8(-3.22,0.46) B9(-3.68,0.46) B10(-4.14,0.46) B11(-4.6,0.46) B12(-5.06,0.46) B13(-5.52,0.46) B14(-5.98,0.46) B15(-6.44,0.46) B16(-6.9,0.46) B17(-7.36,0.46) B18(-7.82,0.46) B19(-8.28,0.46) B20(-8.74,0.46) B21(-9.2,0.46) B22(-9.66,0.46) C2(-0.46,0.92) C22(-9.66,0.92) D2(-0.46,1.38) D4(-1.16,1.16) D5(-1.81,1.16) D6(-2.46,1.16) D8(-3.11,1.16) D9(-3.76,1.16) D11(-4.41,1.16) D12(-5.06,1.16) D13(-5.71,1.16) D15(-6.36,1.16) D16(-7.01,1.16) D18(-7.66,1.16) D19(-8.31,1.16) D20(-8.96,1.16) D22(-9.66,1.38) E2(-0.46,1.84) E4(-1.16,1.81) E5(-1.81,1.81) E6(-2.46,1.81) E8(-3.11,1.81) E9(-3.76,1.81) E11(-4.41,1.81) E12(-5.06,1.81) E13(-5.71,1.81) E15(-6.36,1.81) E16(-7.01,1.81) E18(-7.66,1.81) E19(-8.31,1.81) E20(-8.96,1.81) E22(-9.66,1.84) F2(-0.46,2.3) F4(-1.16,2.46) F5(-1.81,2.46) F6(-2.46,2.46) F8(-3.11,2.46) F9(-3.76,2.46) F11(-4.41,2.46) F12(-5.06,2.46) F13(-5.71,2.46) F15(-6.36,2.46) F16(-7.01,2.46) F18(-7.66,2.46) F19(-8.31,2.46) F20(-8.96,2.46) F22(-9.66,2.3) G2(-0.46,2.76) G22(-9.66,2.76) H2(-0.46,3.22) H4(-1.16,3.11) H5(-1.81,3.11) H6(-2.46,3.11) H8(-3.11,3.11) H9(-3.76,3.11) H11(-4.41,3.11) H12(-5.06,3.11) H13(-5.71,3.11) H15(-6.36,3.11) H16(-7.01,3.11) H18(-7.66,3.11) H19(-8.31,3.11) H20(-8.96,3.11) H22(-9.66,3.22) J2(-0.46,3.68) J4(-1.16,3.76) J5(-1.81,3.76) J6(-2.46,3.76) J8(-3.11,3.76) J9(-3.76,3.76) J11(-4.41,3.76) J12(-5.06,3.76) J13(-5.71,3.76) J15(-6.36,3.76) J16(-7.01,3.76) J18(-7.66,3.76) J19(-8.31,3.76) J20(-8.96,3.76) J22(-9.66,3.68) K2(-0.46,4.14) K22(-9.66,4.14) L2(-0.46,4.6) L4(-1.16,4.41) L5(-1.81,4.41) L6(-2.46,4.41) L8(-3.11,4.41) L9(-3.76,4.41) L11(-4.41,4.41) L12(-5.06,4.41) L13(-5.71,4.41) L15(-6.36,4.41) L16(-7.01,4.41) L18(-7.66,4.41) L19(-8.31,4.41) L20(-8.96,4.41) L22(-9.66,4.6) M2(-0.46,5.06) M4(-1.16,5.06) M5(-1.81,5.06) M6(-2.46,5.06) M8(-3.11,5.06) M9(-3.76,5.06) M11(-4.41,5.06) M12(-5.06,5.06) M13(-5.71,5.06) M15(-6.36,5.06) M16(-7.01,5.06) M18(-7.66,5.06) M19(-8.31,5.06) M20(-8.96,5.06) M22(-9.66,5.06) N2(-0.46,5.52) N4(-1.16,5.71) N5(-1.81,5.71) N6(-2.46,5.71) N8(-3.11,5.71) N9(-3.76,5.71) N11(-4.41,5.71) N12(-5.06,5.71) N13(-5.71,5.71) N15(-6.36,5.71) N16(-7.01,5.71) N18(-7.66,5.71) N19(-8.31,5.71) N20(-8.96,5.71) N22(-9.66,5.52) P2(-0.46,5.98) P22(-9.66,5.98) R2(-0.46,6.44) R4(-1.16,6.36) R5(-1.81,6.36) R6(-2.46,6.36) R8(-3.11,6.36) R9(-3.76,6.36) R11(-4.41,6.36) R12(-5.06,6.36) R13(-5.71,6.36) R15(-6.36,6.36) R16(-7.01,6.36) R18(-7.66,6.36) R19(-8.31,6.36) R20(-8.96,6.36) R22(-9.66,6.44) T2(-0.46,6.9) T4(-1.16,7.01) T5(-1.81,7.01) T6(-2.46,7.01) T8(-3.11,7.01) T9(-3.76,7.01) T11(-4.41,7.01) T12(-5.06,7.01) T13(-5.71,7.01) T15(-6.36,7.01) T16(-7.01,7.01) T18(-7.66,7.01) T19(-8.31,7.01) T20(-8.96,7.01) T22(-9.66,6.9) U2(-0.46,7.36) U22(-9.66,7.36) V2(-0.46,7.82) V4(-1.16,7.66) V5(-1.81,7.66) V6(-2.46,7.66) V8(-3.11,7.66) V9(-3.76,7.66) V11(-4.41,7.66) V12(-5.06,7.66) V13(-5.71,7.66) V15(-6.36,7.66) V16(-7.01,7.66) V18(-7.66,7.66) V19(-8.31,7.66) V20(-8.96,7.66) V22(-9.66,7.82) W2(-0.46,8.28) W4(-1.16,8.31) W5(-1.81,8.31) W6(-2.46,8.31) W8(-3.11,8.31) W9(-3.76,8.31) W11(-4.41,8.31) W12(-5.06,8.31) W13(-5.71,8.31) W15(-6.36,8.31) W16(-7.01,8.31) W18(-7.66,8.31) W19(-8.31,8.31) W20(-8.96,8.31) W22(-9.66,8.28) Y2(-0.46,8.74) Y4(-1.16,8.96) Y5(-1.81,8.96) Y6(-2.46,8.96) Y8(-3.11,8.96) Y9(-3.76,8.96) Y11(-4.41,8.96) Y12(-5.06,8.96) Y13(-5.71,8.96) Y15(-6.36,8.96) Y16(-7.01,8.96) Y18(-7.66,8.96) Y19(-8.31,8.96) Y20(-8.96,8.96) Y22(-9.66,8.74)
  oval 0.178x0.33 smd: A2(-0.46,0) A3(-0.92,0) A4(-1.38,0) A5(-1.84,0) A6(-2.3,0) A7(-2.76,0) A8(-3.22,0) A9(-3.68,0) A10(-4.14,0) A11(-4.6,0) A12(-5.06,0) A13(-5.52,0) A14(-5.98,0) A15(-6.44,0) A16(-6.9,0) A17(-7.36,0) A18(-7.82,0) A19(-8.28,0) A20(-8.74,0) A21(-9.2,0) A22(-9.66,0) AC2(-0.46,10.12) AC3(-0.92,10.12) AC4(-1.38,10.12) AC5(-1.84,10.12) AC6(-2.3,10.12) AC7(-2.76,10.12) AC8(-3.22,10.12) AC9(-3.68,10.12) AC10(-4.14,10.12) AC11(-4.6,10.12) AC12(-5.06,10.12) AC13(-5.52,10.12) AC14(-5.98,10.12) AC15(-6.44,10.12) AC16(-6.9,10.12) AC17(-7.36,10.12) AC18(-7.82,10.12) AC19(-8.28,10.12) AC20(-8.74,10.12) AC21(-9.2,10.12) AC22(-9.66,10.12)
  oval 0.33x0.178 smd: AA1(0,9.2) AA23(-10.12,9.2) AB1(0,9.66) AB23(-10.12,9.66) B1(0,0.46) B23(-10.12,0.46) C1(0,0.92) C23(-10.12,0.92) D1(0,1.38) D23(-10.12,1.38) E1(0,1.84) E23(-10.12,1.84) F1(0,2.3) F23(-10.12,2.3) G1(0,2.76) G23(-10.12,2.76) H1(0,3.22) H23(-10.12,3.22) J1(0,3.68) J23(-10.12,3.68) K1(0,4.14) K23(-10.12,4.14) L1(0,4.6) L23(-10.12,4.6) M1(0,5.06) M23(-10.12,5.06) N1(0,5.52) N23(-10.12,5.52) P1(0,5.98) P23(-10.12,5.98) R1(0,6.44) R23(-10.12,6.44) T1(0,6.9) T23(-10.12,6.9) U1(0,7.36) U23(-10.12,7.36) V1(0,7.82) V23(-10.12,7.82) W1(0,8.28) W23(-10.12,8.28) Y1(0,8.74) Y23(-10.12,8.74)
