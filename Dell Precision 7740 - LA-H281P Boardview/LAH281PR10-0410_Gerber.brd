# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Nets (continued)
BST_5VR: PR501.1 PU500.1(BS)
BST_+1VSP: PR802.1 PU800.10(VBST)
BST_IO: PR302.1 PU300.9(BST)
BST_IO_R: PC305.1 PR302.2
BT_RADIO_DIS#: DZ2.1 RE11.1 UE1.C2(GPIO166)
BT_RADIO_DIS#_R: DZ2.2 JNGFF1.46
C10_PWR_GATE#: RC562.2 RZ542.1 UZ35.1(IN1) UZ61.4(Y)
CAM_MIC_CBL_DET#: JEDP1.17 RH319.2 UH1.AW13(GPP_G0/SD_CMD)
CCG5_AR_RST#: JCCG1.4 RT37.2 UT5.B2(SWD_IO/AR_RST# /GPIO_B2)
CCG5_I2C_INT1#: RE91.1 UE1.F10(GPIO225/UART0_RTS#) UT5.L5(I2C_INT_EC/GPIO_L5)
CCG5_ILIM1#: QT9.2(G) RT584.2 RT589.2
CCG5_ILIM2#: QT8.2(G) RT583.2 RT590.2
CCG5_SMBCLK: JCCG1.6 RE303.1 RT580.2 RT582.1 UE1.C3(GPIO144/SMB04_CLK/SPI1_CS#/UART) UT5.L6(I2C_SCL_SCB1_EC/GPIO_L6)
CCG5_SMBDAT: JCCG1.5 RE302.1 RT579.2 RT581.1 UE1.B4(GPIO143/SMB04_DATA/SPI1_MISO/UA) UT5.K6(I2C_SDA_SCB1_EC/GPIO_K6)
CCG5_SWD_CLK1: JCCG1.3 RT526.1 RT527.1 UT5.C2(SWD_CLK/I2C_CFG_EC/GPIO_C2)
CCG5_VBUS_5V_ON1#: PR2150.1 RT517.2 UT5.K3(VBUS_P_CTRL_P1) UT10.2(A)
CCG5_VBUS_5V_ON2#: PR2106.1 RT519.2 UT5.B4(VBUS_P_CTRL_P2/ P4_2) UT12.2(A)
CCG5_VBUS_DISCHARGE_P1: QT6.2(G) RT567.1 UT5.J10(SDA_3 / VSEL_2_P1 / GPIO_J10)
CCG5_VBUS_DISCHARGE_P2: QT7.2(G) RT568.1 UT5.H10(VSEL_2_P2 / GPIO_H10)
CCG5_XRES1: CT350.2 JCCG1.2 RT525.2 UT5.H6(XRES)
CFG0: JXDP1.9 RC126.1 RC321.1 UC1.BN25(CFG_0)
CFG1: JXDP1.11 RC436.1 UC1.BN27(CFG_1)
CFG2: JXDP1.15 RC181.1 UC1.BN26(CFG_2)
CFG3: JXDP1.17 RC121.2 UC1.BN28(CFG_3)
CFG4: JXDP1.27 RC322.1 UC1.BR20(CFG_4)
CFG5: JXDP1.29 RC323.1 UC1.BM20(CFG_5)
CFG6: JXDP1.33 RC324.1 UC1.BT20(CFG_6)
CFG7: JXDP1.35 RC325.1 UC1.BP20(CFG_7)
CFG8: JXDP1.10 RC437.1 UC1.BR23(CFG_8)
CFG9: JXDP1.12 RC438.1 RC439.1 UC1.BR22(CFG_9)
CFG10: JXDP1.16 RC440.1 UC1.BT23(CFG_10)
CFG11: JXDP1.18 RC441.1 UC1.BT22(CFG_11)
CFG12: JXDP1.28 RC442.1 UC1.BM19(CFG_12)
CFG13: JXDP1.30 RC443.1 UC1.BR19(CFG_13)
CFG14: JXDP1.34 UC1.BP19(CFG_14)
CFG15: JXDP1.36 UC1.BT19(CFG_15)
CFG16: JXDP1.6 UC1.BP23(CFG_16)
CFG17: JXDP1.4 UC1.BN23(CFG_17)
CFG18: JXDP1.24 UC1.BN22(CFG_18)
CFG19: JXDP1.22 UC1.BP22(CFG_19)
CHR_USB20_N1: LI3.3 RI60.1 UI1.11(DM_IN)
CHR_USB20_N2: LI4.3 RI68.1 UI2.11(DM_IN)
CHR_USB20_N3: LI7.3 RI84.1 UI3.11(DM_IN)
CHR_USB20_P1: LI3.2 RI61.1 UI1.10(DP_IN)
CHR_USB20_P2: LI4.2 RI70.1 UI2.10(DP_IN)
CHR_USB20_P3: LI7.2 RI87.1 UI3.10(DP_IN)
CLK_CNV_PRX_DTX_N: RZ526.1 UH1.BD4(CNV_WR_CLKN)
CLK_CNV_PRX_DTX_P: RZ525.1 UH1.BE3(CNV_WR_CLKP)
CLK_CNV_PTX_DRX_N: RZ524.1 UH1.BC5(CNV_WT_CLKN)
CLK_CNV_PTX_DRX_N_R: JNGFF1.63 RZ524.2
CLK_CNV_PTX_DRX_P: RZ523.1 UH1.BB6(CNV_WT_CLKP)
CLK_CNV_PTX_DRX_P_R: JNGFF1.65 RZ523.2
CLK_PCIE_N1: UH1.AH9(CLKOUT_PCIE_N1) UR1.8(REFCLKN)
CLK_PCIE_N2: JNGFF2.45 UH1.AE14(CLKOUT_PCIE_N2)
CLK_PCIE_N3: UH1.AE6(CLKOUT_PCIE_N3) UL1.45(PE_CLKN)
CLK_PCIE_N4: UH1.AC2(CLKOUT_PCIE_N4) UT1.T19(REFCLK_100_IN_N)
CLK_PCIE_N6: JNGFF1.41 UH1.W4(CLKOUT_PCIE_N6)
CLK_PCIE_N7: JNGFF3.53(REFCLKN) UH1.W7(CLKOUT_PCIE_N7)
CLK_PCIE_N8: JNGFF4.53(REFCLKN) UH1.AC14(CLKOUT_PCIE_N8)
CLK_PCIE_N9: JNGFF5.53(REFCLKN) UH1.U2(CLKOUT_PCIE_N9)
CLK_PCIE_N10: JNGFF6.53(REFCLKN) UH1.AC9(CLKOUT_PCIE_N10)
CLK_PCIE_P1: UH1.AH10(CLKOUT_PCIE_P1) UR1.7(REFCLKP)
CLK_PCIE_P2: JNGFF2.47 UH1.AE15(CLKOUT_PCIE_P2)
CLK_PCIE_P3: UH1.AE7(CLKOUT_PCIE_P3) UL1.44(PE_CLKP)
CLK_PCIE_P4: UH1.AC3(CLKOUT_PCIE_P4) UT1.V19(REFCLK_100_IN_P)
CLK_PCIE_P6: JNGFF1.39 UH1.W3(CLKOUT_PCIE_P6)
CLK_PCIE_P7: JNGFF3.55(REFCLKP) UH1.W6(CLKOUT_PCIE_P7)
CLK_PCIE_P8: JNGFF4.55(REFCLKP) UH1.AC15(CLKOUT_PCIE_P8)
CLK_PCIE_P9: JNGFF5.55(REFCLKP) UH1.U3(CLKOUT_PCIE_P9)
CLK_PCIE_P10: JNGFF6.55(REFCLKP) UH1.AC11(CLKOUT_PCIE_P10)
CLK_PEG_N0: JDGFF1.H8 UH1.AJ6(CLKOUT_PCIE_N0)
CLK_PEG_P0: JDGFF1.H7 UH1.AJ7(CLKOUT_PCIE_P0)
CLK_TP_SIO_I2C_DAT: CZ81.1 RZ23.2 RZ346.1 UE1.E10(GPIO154/SMB02_DATA/PS2_CLK1B)
CLK_TP_SIO_R: JKBTP1.14(14    14) RZ19.2 RZ23.1
CLKDET#: T258.1 UH1.BF35(GPP_A18/ISH_GP0)
CLKREQ_CNV: QZ18.2(G) RH733.1 RZ4.1 UH1.BA17(GPP_D6/I2S2_TXD/MODEM_CLKREQ)
CLKREQ_CNV_R: QZ18.3(D) RZ4.2 RZ376.2 RZ532.2
CLKREQ_PCIE#1: RH124.1 UH1.BE31(GPP_B6/SRCCLKREQ1#) UR1.2(CLKREQ#)
CLKREQ_PCIE#2: JNGFF2.44 RH126.1 UH1.AR32(GPP_B7/SRCCLKREQ2#)
CLKREQ_PCIE#3: RH127.1 UH1.BB30(GPP_B8/SRCCLKREQ3#) UL1.48(CLK_REQ_N)
CLKREQ_PCIE#4: RH128.1 RT502.1 UH1.BA30(GPP_B9/SRCCLKREQ4#) UT1.Y6(PCIE_CLKREQ#)
CLKREQ_PCIE#6: JNGFF1.45 RH130.1 UH1.AE47(GPP_H0/SRCCLKREQ6#)
CLKREQ_PCIE#7: JNGFF3.52(CLKREQ#) RH131.1 UH1.AC48(GPP_H1/SRCCLKREQ7#)
CLKREQ_PCIE#8: JNGFF4.52(CLKREQ#) RH132.1 UH1.AE41(GPP_H2/SRCCLKREQ8#)
CLKREQ_PCIE#9: JNGFF5.52(CLKREQ#) RH133.1 UH1.AF48(GPP_H3/SRCCLKREQ9#)
CLKREQ_PCIE#10: JNGFF6.52(CLKREQ#) RH134.1 UH1.AC41(GPP_H4/SRCCLKREQ10#)
CLKREQ_PEG#0: QV42.1(D) RH123.1 UH1.BF31(GPP_B5/SRCCLKREQ0#)
CLKRUN#: T318.1 UH1.AV32(GPP_A8/CLKRUN#)
CMPIN: PR729.1 PR730.1 PU700.13(CMPIN)
CMPOUT: PQ2003.2(G1) PQ2003.3(D1) PQ2010.2(G) PR2151.1 PU700.14(CMPOUT)
CNV_BRI_PRX_DTX: RH614.2 RZ533.2 UH1.AY2(GPP_J5/CNV_BRI_RSP/UART0B_RXD)
CNV_BRI_PTX_DRX: RH603.1 RH604.2 RZ536.2 UH1.AV4(GPP_J4/CNV_BRI_DT/UART0B_RTS#)
CNV_COEX1: RH607.2 RH608.1 RZ373.2 UH1.AU9(GPP_J9/CNV_MFUART2_TXD)
CNV_COEX2: RZ372.2 UH1.AW2(GPP_J8/CNV_MFUART2_RXD)
CNV_COEX3: RZ374.2 UH1.AV6(GPP_J0/CNV_PA_BLANKING)
CNV_PRX_DTX_N0: RZ527.1 UH1.BB3(CNV_WR_D0N)
CNV_PRX_DTX_N1: RZ529.1 UH1.BA3(CNV_WR_D1N)
CNV_PRX_DTX_P0: RZ528.1 UH1.BB4(CNV_WR_D0P)
CNV_PRX_DTX_P1: RZ530.1 UH1.BA2(CNV_WR_D1P)
CNV_PTX_C_DRX_N0: CZ537.2 JNGFF1.57
CNV_PTX_C_DRX_N1: CZ539.2 JNGFF1.51
CNV_PTX_C_DRX_P0: CZ536.2 JNGFF1.59
CNV_PTX_C_DRX_P1: CZ538.2 JNGFF1.53
CNV_PTX_DRX_N0: CZ537.1 UH1.BE6(CNV_WT_D0N)
CNV_PTX_DRX_N1: CZ539.1 UH1.BG6(CNV_WT_D1N)
CNV_PTX_DRX_P0: CZ536.1 UH1.BD7(CNV_WT_D0P)
CNV_PTX_DRX_P1: CZ538.1 UH1.BF6(CNV_WT_D1P)
CNV_RF_RESET#: QZ17.2(G) RH617.1 RZ3.1 UH1.BE16(GPP_D5/I2S2_SFRM/CNV_RF_RESET#)
CNV_RF_RESET#_R: QZ17.3(D) RZ3.2 RZ378.2 RZ531.2
CNV_RGI_PRX_DTX: RH613.2 RZ535.2 UH1.AV3(GPP_J7/CNV_RGI_RSP/UART0B_CTS#)
CNV_RGI_PTX_DRX: RH605.1 RH606.1 RZ534.2 UH1.BA4(GPP_J6/CNV_RGI_DT/UART0B_TXD)
CNV_WT_RCOMP: RH612.2 UH1.BA1(CNV_WT_RCOMP)
COMP_1PH: PC1107.2 PC1108.2 PU1100.50(COMP_1PH)
COMP_2PH: PC1117.2 PC1119.2 PU1100.33(COMP_2PH)
COMP_4PH: PC1113.1 PR1133.1 PU1100.6(COMP_4PH)
CONTACTLESS_DET#: DZ8.2 RH90.2 UH1.BG8(GPP_G4/SD_DATA3)
CONTACTLESS_DET#_R: DZ8.1 JUSH1.4
CORE_SW1: PC1216.1 PL1202.1 PU1200.11(SW1) PU1200.12(SW2)
CORE_SW2: PC1226.1 PL1203.1 PU1201.11(SW1) PU1201.12(SW2)
CORE_SW3: PC1236.1 PL1204.1 PU1202.11(SW1) PU1202.12(SW2)
CORE_SW4: PC1246.1 PL1205.1 PU1203.11(SW1) PU1203.12(SW2)
CPU_2_PCH_TRIGGER: RC177.1 UH1.AK2(TRIGGER_IN)
CPU_2_PCH_TRIGGER_R: RC177.2 UC1.J23(PROC_TRIGOUT)
CPU_24MHZ_R_D: RH169.1 UC1.E31(CLK24P)
CPU_24MHZ_R_D#: RH170.1 UC1.D31(CLK24N)
CPU_C10_GATE#: PR309.1 RC562.1 RH446.2 RH616.1 RZ543.1 UZ61.2(A)
CPU_DP1_AUXN: CV877.1 UC1.E27(DDI1_AUXN)
CPU_DP1_AUXN_C: CV877.2 UV66.59(IN2_AUXN)
CPU_DP1_AUXP: CV876.1 UC1.D27(DDI1_AUXP)
CPU_DP1_AUXP_C: CV876.2 UV66.60(IN2_AUXP)
CPU_DP1_N0: CV869.2 UC1.K37(DDI1_TXN_0)
CPU_DP1_N0_C: CV869.1 UV66.15(IN2_D0N)
CPU_DP1_N1: CV871.2 UC1.J34(DDI1_TXN_1)
CPU_DP1_N1_C: CV871.1 UV66.18(IN2_D1N)
CPU_DP1_N2: CV873.2 UC1.H36(DDI1_TXN_2)
CPU_DP1_N2_C: CV873.1 UV66.21(IN2_D2N)
CPU_DP1_N3: CV875.2 UC1.J38(DDI1_TXN_3)
CPU_DP1_N3_C: CV875.1 UV66.23(IN2_D3N)
CPU_DP1_P0: CV868.2 UC1.K36(DDI1_TXP_0)
CPU_DP1_P0_C: CV868.1 UV66.14(IN2_D0P)
CPU_DP1_P1: CV870.2 UC1.J35(DDI1_TXP_1)
CPU_DP1_P1_C: CV870.1 UV66.17(IN2_D1P)
CPU_DP1_P2: CV872.2 UC1.H37(DDI1_TXP_2)
CPU_DP1_P2_C: CV872.1 UV66.20(IN2_D2P)
CPU_DP1_P3: CV874.2 UC1.J37(DDI1_TXP_3)
CPU_DP1_P3_C: CV874.1 UV66.22(IN2_D3P)
CPU_DP2_AUXN: CV74.1 UC1.E26(DDI2_AUXN)
CPU_DP2_AUXN_C: CV74.2 UV8.25(IN_AUXN)
CPU_DP2_AUXP: CV73.1 UC1.F26(DDI2_AUXP)
CPU_DP2_AUXP_C: CV73.2 UV8.24(IN_AUXP)
CPU_DP2_N0: CV66.1 UC1.H33(DDI2_TXN_0)
CPU_DP2_N0_C: CV66.2 UV8.7(IN_D0N)
CPU_DP2_N1: CV68.1 UC1.G38(DDI2_TXN_1)
CPU_DP2_N1_C: CV68.2 UV8.10(IN_D1N)
CPU_DP2_N2: CV70.1 UC1.F35(DDI2_TXN_2)
CPU_DP2_N2_C: CV70.2 UV8.13(IN_D2N)
CPU_DP2_N3: CV72.1 UC1.E36(DDI2_TXN_3)
CPU_DP2_N3_C: CV72.2 UV8.16(IN_D3N)
CPU_DP2_P0: CV65.1 UC1.H34(DDI2_TXP_0)
CPU_DP2_P0_C: CV65.2 UV8.6(IN_D0P)
CPU_DP2_P1: CV67.1 UC1.F37(DDI2_TXP_1)
CPU_DP2_P1_C: CV67.2 UV8.9(IN_D1P)
CPU_DP2_P2: CV69.1 UC1.F34(DDI2_TXP_2)
CPU_DP2_P2_C: CV69.2 UV8.12(IN_D2P)
CPU_DP2_P3: CV71.1 UC1.E37(DDI2_TXP_3)
CPU_DP2_P3_C: CV71.2 UV8.15(IN_D3P)
CPU_DP3_AUXN: JDGFF4.B6 UC1.B27(DDI3_AUXN)
CPU_DP3_AUXP: JDGFF4.B5 UC1.A27(DDI3_AUXP)
CPU_DP3_N0: JDGFF4.A2 UC1.D34(DDI3_TXN_0)
CPU_DP3_N1: JDGFF4.A5 UC1.B34(DDI3_TXN_1)
CPU_DP3_N2: JDGFF4.A8 UC1.E33(DDI3_TXN_2)
CPU_DP3_N3: JDGFF4.B3 UC1.B33(DDI3_TXN_3)
CPU_DP3_P0: JDGFF4.A1 UC1.C34(DDI3_TXP_0)
CPU_DP3_P1: JDGFF4.A4 UC1.B36(DDI3_TXP_1)
CPU_DP3_P2: JDGFF4.A7 UC1.F33(DDI3_TXP_2)
CPU_DP3_P3: JDGFF4.B2 UC1.C33(DDI3_TXP_3)
CPU_EDP_HPD: RH1.2 UH1.AN6(GPP_I4/EDP_HPD/DISP_MISC4) UV64.3(IN1_HPD)
CPU_VIDALERT#: RC153.2 UC1.BH31(VIDALERT#)
CPU_XDP_HOOK6: JXDP1.46 RC115.1 RC144.1
CPU_XDP_PRDY#: JXDP1.5 RC314.1 T189.1 UC1.BP27(PROC_PRDY#)
CPU_XDP_PREQ#: JXDP1.3 RC138.2 RC315.1 T190.1 UC1.BL30(PROC_PREQ#)
CPU_XDP_PRS: JXDP1.60 RC127.1
CPU_XDP_TCLK: JXDP1.57 RC139.1 RC143.1 T181.1 UC1.BR28(PROC_TCK)
CPU_XDP_TDI: JXDP1.56 RC229.1 T185.1 UC1.BL32(PROC_TDI)
CPU_XDP_TDO: CC306.1 JXDP1.52 RC135.1 RC230.1 T184.1 UC1.BT28(PROC_TDO)
CPU_XDP_TMS: JXDP1.58 RC228.1 T180.1 UC1.BP28(PROC_TMS)
CPU_XDP_TRST#: CC308.1 JXDP1.54 RC136.1 T179.1 UC1.BP30(PROC_TRST#) UH1.AM4(CPU_TRST#)
CS_1.2V: PR201.2 PU200.13(CS)
CSCOMP_2PH: PC1124.1 PC1125.1 PH1102.1 PR1139.2 PR1141.1 PU1100.31(CSCOMP_2PH)
CSCOMP_4PH: PC1121.1 PC1122.2 PH1101.1 PR1138.1 PR1140.1 PU1100.8(CSCOMP_4PH)
CSN_1PH: PH1100.1 PL1800.3 PR1169.1
CSN_1PH_R: PC1102.1 PC1104.1 PC1137.1 PR1169.2 PU1100.48(CSN_1PH)
CSON_1: PC719.2 PC720.1 PR715.3 PR728.1
CSOP_1: PC718.2 PC719.1 PR715.2 PR727.1
CSP1_2PH: PC1132.2 PR1160.1 PU1100.28(CSP1_2PH)
CSP1_4PH: PC1131.2 PR1154.2 PU1100.11(CSP1_4PH)
CSP2_4PH: PC1133.2 PR1161.2 PU1100.12(CSP2_4PH)
CSP3_4PH: PC1135.2 PR1163.2 PU1100.13(CSP3_4PH)
CSP4_4PH: PC1136.2 PR1164.2 PU1100.26(CSP4_4PH)
CSP_1PH: PC1102.2 PC1104.2 PR1101.2 PR1102.1 PU1100.47(CSP_1PH)
CSREF_2PH: PC1126.1 PC1132.1 PR1703.2 PU1100.29(CSREF_2PH)
CSREF_4PH: PC1123.2 PC1131.1 PC1133.1 PC1135.1 PC1136.1 PR1203.2 PR1207.2 PR1214.2 PR1215.2 PU1100.10(CSREF_4PH)
CSSN_1: PR700.3 PR702.1 PR704.1
CSSN_2: PC701.2 PC702.1 PR704.2 PU700.1(ACN)
CSSP_1: PR700.2 PR702.2 PR703.1
CSSP_2: PC700.2 PC701.1 PR703.2 PU700.2(ACP)
CSSUM_2PH: PC1124.2 PC1125.2 PR1144.2 PR1145.1 PU1100.30(CSSUM_2PH)
CSSUM_4PH: PC1121.2 PC1122.1 PR1142.2 PR1143.2 PR1146.2 PR1148.2 PR1149.2 PU1100.9(CSSUM_4PH)
CV2_ON: JUSH1.24 RE539.2
CV2_ON_R: RE539.1 RE736.2 UE1.H8(GPIO222/SER_IRQ)
DAT_TP_SIO_I2C_CLK: CZ80.1 RZ22.2 RZ347.1 UE1.C12(GPIO155/SMB02_CLK/PS2_DAT1B)
DAT_TP_SIO_R: JKBTP1.13 RZ18.2 RZ22.1
DCIN1_EN: PR15.1 UE1.K4(GPIO215/ADC13)
DCIN2_EN: PR36.1 UE1.L12(GPIO107/NSMI)
DCIN3_EN: PR54.1 UE1.J6(GPIO202/ADC02)
DCIN_ACOK: PC2018.1 PQ2007.5(G2) PR2009.1 PR2039.1 PR2042.2 PU2004.7(O)
DDR4_DRAMRST#_PCH: CD5.1 RD4.2 RD76.1 RD77.1 UH1.BB46(DRAM_RESET#)
DDR_A_ACT#: JDIMM1.114(ACT_N) JDIMM2.114(ACT_N) UC1.AU3(DDR0_CAA_8/DDR0_ACT#)
DDR_A_ALERT#: JDIMM1.116(ALERT_N) JDIMM2.116(ALERT_N) UC1.AU5(NC/DDR0_ALERT#)
DDR_A_BA0: JDIMM1.150(BA0) JDIMM2.150(BA0) UC1.AH5(DDR0_CAB_4/DDR0_BA_0)
DDR_A_BA1: JDIMM1.145(BA1) JDIMM2.145(BA1) UC1.AH1(DDR0_CAB_6/DDR0_BA_1)
DDR_A_BG0: JDIMM1.115(BG0) JDIMM2.115(BG0) UC1.AU1(DDR0_CAA_5/DDR0_BG_0)
DDR_A_BG1: JDIMM1.113(BG1) JDIMM2.113(BG1) UC1.AU2(DDR0_CAA_9/DDR0_BG_1)
DDR_A_CB0: JDIMM1.87(CB5/NC) JDIMM2.87(CB5/NC) UC1.BA2(NC/DDR0_ECC_0)
DDR_A_CB1: JDIMM1.88(CB4/NC) JDIMM2.88(CB4/NC) UC1.BA1(NC/DDR0_ECC_1)
DDR_A_CB2: JDIMM1.105(CB3/NC) JDIMM2.105(CB3/NC) UC1.AY4(NC/DDR0_ECC_2)
DDR_A_CB3: JDIMM1.101(CB2/NC) JDIMM2.101(CB2/NC) UC1.AY5(NC/DDR0_ECC_3)
DDR_A_CB4: JDIMM1.92(CB0/NC) JDIMM2.92(CB0/NC) UC1.BA5(NC/DDR0_ECC_4)
DDR_A_CB5: JDIMM1.91(CB1/NC) JDIMM2.91(CB1/NC) UC1.BA4(NC/DDR0_ECC_5)
DDR_A_CB6: JDIMM1.104(CB7/NC) JDIMM2.104(CB7/NC) UC1.AY1(NC/DDR0_ECC_6)
DDR_A_CB7: JDIMM1.100(CB6/NC) JDIMM2.100(CB6/NC) UC1.AY2(NC/DDR0_ECC_7)
DDR_A_CKE0: JDIMM2.109(CKE0) UC1.AT1(DDR0_CKE_0/DDR0_CKE_0)
DDR_A_CKE1: JDIMM2.110(CKE1) UC1.AT2(DDR0_CKE_1/DDR0_CKE_1)
DDR_A_CKE2: JDIMM1.109(CKE0) UC1.AT3(DDR0_CKE_2/DDR0_CKE_2)
DDR_A_CKE3: JDIMM1.110(CKE1) UC1.AT5(DDR0_CKE_3/DDR0_CKE_3)
DDR_A_CLK0: JDIMM2.137(CK0_T) UC1.AG1(DDR0_CKP_0/DDR0_CKP_0)
DDR_A_CLK1: JDIMM2.138(CK1_T/NF) UC1.AK2(DDR0_CKP_1/DDR0_CKP_1)
DDR_A_CLK2: JDIMM1.137(CK0_T) UC1.AL3(NC/DDR0_CKP_2)
DDR_A_CLK3: JDIMM1.138(CK1_T/NF) UC1.AL2(NC/DDR0_CKP_3)
DDR_A_CLK#0: JDIMM2.139(CK0_C) UC1.AG2(DDR0_CKN_0/DDR0_CKN_0)
DDR_A_CLK#1: JDIMM2.140(CK1_C/NF) UC1.AK1(DDR0_CKN_1/DDR0_CKN_1)
DDR_A_CLK#2: JDIMM1.139(CK0_C) UC1.AK3(NC/DDR0_CKN_2)
DDR_A_CLK#3: JDIMM1.140(CK1_C/NF) UC1.AL1(NC/DDR0_CKN_3)
DDR_A_CS#0: JDIMM2.149(CS0_N) UC1.AD5(DDR0_CS#_0/DDR0_CS#_0)
DDR_A_CS#1: JDIMM2.157(CS1_N) UC1.AE2(DDR0_CS#_1/DDR0_CS#_1)
DDR_A_CS#2: JDIMM1.149(CS0_N) UC1.AD2(NC/DDR0_CS#_2)
DDR_A_CS#3: JDIMM1.157(CS1_N) UC1.AE5(NC/DDR0_CS#_3)
DDR_A_D0: JDIMM1.7(DQ1) JDIMM2.8(DQ0) UC1.BR6(DDR0_DQ_0/DDR0_DQ_0)
DDR_A_D1: JDIMM1.4(DQ4) JDIMM2.3(DQ5) UC1.BT6(DDR0_DQ_1/DDR0_DQ_1)
DDR_A_D2: JDIMM1.20(DQ2) JDIMM2.21(DQ3) UC1.BP3(DDR0_DQ_2/DDR0_DQ_2)
DDR_A_D3: JDIMM1.21(DQ3) JDIMM2.20(DQ2) UC1.BR3(DDR0_DQ_3/DDR0_DQ_3)
DDR_A_D4: JDIMM1.3(DQ5) JDIMM2.4(DQ4) UC1.BN5(DDR0_DQ_4/DDR0_DQ_4)
DDR_A_D5: JDIMM1.8(DQ0) JDIMM2.7(DQ1) UC1.BP6(DDR0_DQ_5/DDR0_DQ_5)
DDR_A_D6: JDIMM1.16(DQ6) JDIMM2.17(DQ7) UC1.BP2(DDR0_DQ_6/DDR0_DQ_6)
DDR_A_D7: JDIMM1.17(DQ7) JDIMM2.16(DQ6) UC1.BN3(DDR0_DQ_7/DDR0_DQ_7)
DDR_A_D8: JDIMM1.28(DQ8) JDIMM2.29(DQ9) UC1.BL4(DDR0_DQ_8/DDR0_DQ_8)
DDR_A_D9: JDIMM1.24(DQ12) JDIMM2.25(DQ13) UC1.BL5(DDR0_DQ_9/DDR0_DQ_9)
DDR_A_D10: JDIMM1.38(DQ14) JDIMM2.37(DQ15) UC1.BL2(DDR0_DQ_10/DDR0_DQ_10)
DDR_A_D11: JDIMM1.42(DQ11) JDIMM2.41(DQ10) UC1.BM1(DDR0_DQ_11/DDR0_DQ_11)
DDR_A_D12: JDIMM1.29(DQ9) JDIMM2.28(DQ8) UC1.BK4(DDR0_DQ_12/DDR0_DQ_12)
DDR_A_D13: JDIMM1.25(DQ13) JDIMM2.24(DQ12) UC1.BK5(DDR0_DQ_13/DDR0_DQ_13)
DDR_A_D14: JDIMM1.41(DQ10) JDIMM2.42(DQ11) UC1.BK1(DDR0_DQ_14/DDR0_DQ_14)
DDR_A_D15: JDIMM1.37(DQ15) JDIMM2.38(DQ14) UC1.BK2(DDR0_DQ_15/DDR0_DQ_15)
DDR_A_D16: JDIMM1.46(DQ20) JDIMM2.45(DQ21) UC1.BG4(DDR0_DQ_16/DDR0_DQ_32)
DDR_A_D17: JDIMM1.50(DQ16) JDIMM2.49(DQ17) UC1.BG5(DDR0_DQ_17/DDR0_DQ_33)
DDR_A_D18: JDIMM1.63(DQ19) JDIMM2.62(DQ18) UC1.BF4(DDR0_DQ_18/DDR0_DQ_34)
DDR_A_D19: JDIMM1.58(DQ22) JDIMM2.59(DQ23) UC1.BF5(DDR0_DQ_19/DDR0_DQ_35)
DDR_A_D20: JDIMM1.49(DQ17) JDIMM2.50(DQ16) UC1.BG2(DDR0_DQ_20/DDR0_DQ_36)
DDR_A_D21: JDIMM1.45(DQ21) JDIMM2.46(DQ20) UC1.BG1(DDR0_DQ_21/DDR0_DQ_37)
DDR_A_D22: JDIMM1.59(DQ23) JDIMM2.58(DQ22) UC1.BF1(DDR0_DQ_22/DDR0_DQ_38)
DDR_A_D23: JDIMM1.62(DQ18) JDIMM2.63(DQ19) UC1.BF2(DDR0_DQ_23/DDR0_DQ_39)
DDR_A_D24: JDIMM1.66(DQ28) JDIMM2.67(DQ29) UC1.BD2(DDR0_DQ_24/DDR0_DQ_40)
DDR_A_D25: JDIMM1.70(DQ24) JDIMM2.71(DQ25) UC1.BD1(DDR0_DQ_25/DDR0_DQ_41)
DDR_A_D26: JDIMM1.80(DQ31) JDIMM2.79(DQ30) UC1.BC4(DDR0_DQ_26/DDR0_DQ_42)
DDR_A_D27: JDIMM1.79(DQ30) JDIMM2.80(DQ31) UC1.BC5(DDR0_DQ_27/DDR0_DQ_43)
DDR_A_D28: JDIMM1.71(DQ25) JDIMM2.70(DQ24) UC1.BD5(DDR0_DQ_28/DDR0_DQ_44)
DDR_A_D29: JDIMM1.67(DQ29) JDIMM2.66(DQ28) UC1.BD4(DDR0_DQ_29/DDR0_DQ_45)
DDR_A_D30: JDIMM1.83(DQ26) JDIMM2.84(DQ27) UC1.BC1(DDR0_DQ_30/DDR0_DQ_46)
DDR_A_D31: JDIMM1.84(DQ27) JDIMM2.83(DQ26) UC1.BC2(DDR0_DQ_31/DDR0_DQ_47)
DDR_A_D32: JDIMM1.174(DQ32) JDIMM2.173(DQ33) UC1.AB1(DDR0_DQ_32/DDR1_DQ_0)
DDR_A_D33: JDIMM1.169(DQ37) JDIMM2.170(DQ36) UC1.AB2(DDR0_DQ_33/DDR1_DQ_1)
DDR_A_D34: JDIMM1.186(DQ35) JDIMM2.187(DQ34) UC1.AA4(DDR0_DQ_34/DDR1_DQ_2)
DDR_A_D35: JDIMM1.182(DQ39) JDIMM2.183(DQ38) UC1.AA5(DDR0_DQ_35/DDR1_DQ_3)
DDR_A_D36: JDIMM1.170(DQ36) JDIMM2.169(DQ37) UC1.AB5(DDR0_DQ_36/DDR1_DQ_4)
DDR_A_D37: JDIMM1.173(DQ33) JDIMM2.174(DQ32) UC1.AB4(DDR0_DQ_37/DDR1_DQ_5)
DDR_A_D38: JDIMM1.183(DQ38) JDIMM2.182(DQ39) UC1.AA2(DDR0_DQ_38/DDR1_DQ_6)
DDR_A_D39: JDIMM1.187(DQ34) JDIMM2.186(DQ35) UC1.AA1(DDR0_DQ_39/DDR1_DQ_7)
DDR_A_D40: JDIMM1.190(DQ45) JDIMM2.191(DQ44) UC1.V5(DDR0_DQ_40/DDR1_DQ_8)
DDR_A_D41: JDIMM1.195(DQ40) JDIMM2.194(DQ41) UC1.V2(DDR0_DQ_41/DDR1_DQ_9)
DDR_A_D42: JDIMM1.208(DQ43) JDIMM2.207(DQ42) UC1.U1(DDR0_DQ_42/DDR1_DQ_10)
DDR_A_D43: JDIMM1.203(DQ46) JDIMM2.204(DQ47) UC1.U2(DDR0_DQ_43/DDR1_DQ_11)
DDR_A_D44: JDIMM1.191(DQ44) JDIMM2.190(DQ45) UC1.V1(DDR0_DQ_44/DDR1_DQ_12)
DDR_A_D45: JDIMM1.194(DQ41) JDIMM2.195(DQ40) UC1.V4(DDR0_DQ_45/DDR1_DQ_13)
DDR_A_D46: JDIMM1.207(DQ42) JDIMM2.208(DQ43) UC1.U5(DDR0_DQ_46/DDR1_DQ_14)
DDR_A_D47: JDIMM1.204(DQ47) JDIMM2.203(DQ46) UC1.U4(DDR0_DQ_47/DDR1_DQ_15)
DDR_A_D48: JDIMM1.212(DQ53) JDIMM2.211(DQ52) UC1.R2(DDR0_DQ_48/DDR1_DQ_32)
DDR_A_D49: JDIMM1.216(DQ48) JDIMM2.215(DQ49) UC1.P5(DDR0_DQ_49/DDR1_DQ_33)
DDR_A_D50: JDIMM1.211(DQ52) JDIMM2.212(DQ53) UC1.R4(DDR0_DQ_50/DDR1_DQ_34)
DDR_A_D51: JDIMM1.229(DQ51) JDIMM2.228(DQ50) UC1.P4(DDR0_DQ_51/DDR1_DQ_35)
DDR_A_D52: JDIMM1.215(DQ49) JDIMM2.216(DQ48) UC1.R5(DDR0_DQ_52/DDR1_DQ_36)
DDR_A_D53: JDIMM1.224(DQ54) JDIMM2.225(DQ55) UC1.P2(DDR0_DQ_53/DDR1_DQ_37)
DDR_A_D54: JDIMM1.225(DQ55) JDIMM2.224(DQ54) UC1.R1(DDR0_DQ_54/DDR1_DQ_38)
DDR_A_D55: JDIMM1.228(DQ50) JDIMM2.229(DQ51) UC1.P1(DDR0_DQ_55/DDR1_DQ_39)
DDR_A_D56: JDIMM1.232(DQ60) JDIMM2.233(DQ61) UC1.M4(DDR0_DQ_56/DDR1_DQ_40)
DDR_A_D57: JDIMM1.233(DQ61) JDIMM2.232(DQ60) UC1.M1(DDR0_DQ_57/DDR1_DQ_41)
DDR_A_D58: JDIMM1.249(DQ58) JDIMM2.250(DQ59) UC1.L4(DDR0_DQ_58/DDR1_DQ_42)
DDR_A_D59: JDIMM1.246(DQ63) JDIMM2.245(DQ62) UC1.L2(DDR0_DQ_59/DDR1_DQ_43)
DDR_A_D60: JDIMM1.236(DQ57) JDIMM2.237(DQ56) UC1.M5(DDR0_DQ_60/DDR1_DQ_44)
DDR_A_D61: JDIMM1.237(DQ56) JDIMM2.236(DQ57) UC1.M2(DDR0_DQ_61/DDR1_DQ_45)
DDR_A_D62: JDIMM1.245(DQ62) JDIMM2.246(DQ63) UC1.L5(DDR0_DQ_62/DDR1_DQ_46)
DDR_A_D63: JDIMM1.250(DQ59) JDIMM2.249(DQ58) UC1.L1(DDR0_DQ_63/DDR1_DQ_47)
DDR_A_DQS0: JDIMM1.13(DQS0_T) JDIMM2.13(DQS0_T) UC1.BP5(DDR0_DQSP_0/DDR0_DQSP_0)
DDR_A_DQS1: JDIMM1.34(DQS1_T) JDIMM2.34(DQS1_T) UC1.BK3(DDR0_DQSP_1/DDR0_DQSP_1)
DDR_A_DQS2: JDIMM1.55(DQS2_T) JDIMM2.55(DQS2_T) UC1.BF3(DDR0_DQSP_2/DDR0_DQSP_4)
DDR_A_DQS3: JDIMM1.76(DQS3_T) JDIMM2.76(DQS3_T) UC1.BC3(DDR0_DQSP_3/DDR0_DQSP_5)
DDR_A_DQS4: JDIMM1.179(DQS4_T) JDIMM2.179(DQS4_T) UC1.AB3(DDR0_DQSP_4/DDR1_DQSP_0)
DDR_A_DQS5: JDIMM1.200(DQS5_T) JDIMM2.200(DQS5_T) UC1.V3(DDR0_DQSP_5/DDR1_DQSP_1)
DDR_A_DQS6: JDIMM1.221(DQS6_T) JDIMM2.221(DQS6_T) UC1.R3(DDR0_DQSP_6/DDR1_DQSP_4)
DDR_A_DQS7: JDIMM1.242(DQS7_T) JDIMM2.242(DQS7_T) UC1.M3(DDR0_DQSP_7/DDR1_DQSP_5)
DDR_A_DQS8: JDIMM1.97(DQS8_T) JDIMM2.97(DQS8_T) UC1.AY3(DDR0_DQSP_8/DDR0_DQSP_8)
DDR_A_DQS#0: JDIMM1.11(DQS0_C) JDIMM2.11(DQS0_C) UC1.BR5(DDR0_DQSN_0/DDR0_DQSN_0)
DDR_A_DQS#1: JDIMM1.32(DQS1_C) JDIMM2.32(DQS1_C) UC1.BL3(DDR0_DQSN_1/DDR0_DQSN_1)
DDR_A_DQS#2: JDIMM1.53(DQS2_C) JDIMM2.53(DQS2_C) UC1.BG3(DDR0_DQSN_2/DDR0_DQSN_4)
DDR_A_DQS#3: JDIMM1.74(DQS3_C) JDIMM2.74(DQS3_C) UC1.BD3(DDR0_DQSN_3/DDR0_DQSN_5)
DDR_A_DQS#4: JDIMM1.177(DQS4_C) JDIMM2.177(DQS4_C) UC1.AA3(DDR0_DQSN_4/DDR1_DQSN_0)
DDR_A_DQS#5: JDIMM1.198(DQS5_C) JDIMM2.198(DQS5_C) UC1.U3(DDR0_DQSN_5/DDR1_DQSN_1)
DDR_A_DQS#6: JDIMM1.219(DQS6_C) JDIMM2.219(DQS6_C) UC1.P3(DDR0_DQSN_6/DDR1_DQSN_4)
DDR_A_DQS#7: JDIMM1.240(DQS7_C) JDIMM2.240(DQS7_C) UC1.L3(DDR0_DQSN_7/DDR1_DQSN_5)
DDR_A_DQS#8: JDIMM1.95(DQS8_C) JDIMM2.95(DQS8_C) UC1.BA3(DDR0_DQSN_8/DDR0_DQSN_8)
DDR_A_DRAMRST#: CD15.1 CD48.1 JDIMM1.108(RESET_N) JDIMM2.108(RESET_N) RD76.2
DDR_A_MA0: JDIMM1.144(A0) JDIMM2.144(A0) UC1.AH3(DDR0_CAB_9/DDR0_MA_0)
DDR_A_MA1: JDIMM1.133(A1) JDIMM2.133(A1) UC1.AP4(DDR0_CAB_8/DDR0_MA_1)
DDR_A_MA2: JDIMM1.132(A2) JDIMM2.132(A2) UC1.AN4(DDR0_CAB_5/DDR0_MA_2)
DDR_A_MA3: JDIMM1.131(A3) JDIMM2.131(A3) UC1.AP5(NC/DDR0_MA_3)
DDR_A_MA4: JDIMM1.128(A4) JDIMM2.128(A4) UC1.AP2(NC/DDR0_MA_4)
DDR_A_MA5: JDIMM1.126(A5) JDIMM2.126(A5) UC1.AP1(DDR0_CAA_0/DDR0_MA_5)
DDR_A_MA6: JDIMM1.127(A6) JDIMM2.127(A6) UC1.AP3(DDR0_CAA_2/DDR0_MA_6)
DDR_A_MA7: JDIMM1.122(A7) JDIMM2.122(A7) UC1.AN1(DDR0_CAA_4/DDR0_MA_7)
DDR_A_MA8: JDIMM1.125(A8) JDIMM2.125(A8) UC1.AN3(DDR0_CAA_3/DDR0_MA_8)
DDR_A_MA9: JDIMM1.121(A9) JDIMM2.121(A9) UC1.AT4(DDR0_CAA_1/DDR0_MA_9)
DDR_A_MA10: JDIMM1.146(A10/AP) JDIMM2.146(A10/AP) UC1.AH2(DDR0_CAB_7/DDR0_MA_10)
DDR_A_MA11: JDIMM1.120(A11) JDIMM2.120(A11) UC1.AN2(DDR0_CAA_7/DDR0_MA_11)
DDR_A_MA12: JDIMM1.119(A12) JDIMM2.119(A12) UC1.AU4(DDR0_CAA_6/DDR0_MA_12)
DDR_A_MA13: JDIMM1.158(A13) JDIMM2.158(A13) UC1.AE3(DDR0_CAB_0/DDR0_MA_13)
DDR_A_MA14: JDIMM1.151(WE_N/A14) JDIMM2.151(WE_N/A14) UC1.AG4(DDR0_CAB_2/DDR0_MA_14)
DDR_A_MA15: JDIMM1.156(CAS_N/A15) JDIMM2.156(CAS_N/A15) UC1.AD1(DDR0_CAB_1/DDR0_MA_15)
DDR_A_MA16: JDIMM1.152(RAS_N/A16) JDIMM2.152(RAS_N/A16) UC1.AH4(DDR0_CAB_3/DDR0_MA_16)
DDR_A_ODT0: JDIMM2.155(ODT0) UC1.AD3(DDR0_ODT_0/DDR0_ODT_0)
DDR_A_ODT1: JDIMM2.161(ODT1) UC1.AE4(NC/DDR0_ODT_1)
DDR_A_ODT2: JDIMM1.155(ODT0) UC1.AE1(NC/DDR0_ODT_2)
DDR_A_ODT3: JDIMM1.161(ODT1) UC1.AD4(NC/DDR0_ODT_3)
DDR_A_PARITY: JDIMM1.143(PARITY) JDIMM2.143(PARITY) UC1.AG3(NC/DDR0_PAR)
DDR_B_ACT#: JDIMM3.114(ACT_N) JDIMM4.114(ACT_N) UC1.AT9(DDR1_CAA_8/DDR1_ACT#)
DDR_B_ALERT#: JDIMM3.116(ALERT_N) JDIMM4.116(ALERT_N) UC1.AR8(NC/DDR1_ALERT#)
DDR_B_BA0: JDIMM3.150(BA0) JDIMM4.150(BA0) UC1.AH8(DDR1_CAB_4/DDR1_BA_0)
DDR_B_BA1: JDIMM3.145(BA1) JDIMM4.145(BA1) UC1.AH9(DDR1_CAB_6/DDR1_BA_1)
DDR_B_BG0: JDIMM3.115(BG0) JDIMM4.115(BG0) UC1.AR9(DDR1_CAA_5/DDR1_BG_0)
DDR_B_BG1: JDIMM3.113(BG1) JDIMM4.113(BG1) UC1.AR7(DDR1_CAA_9/DDR1_BG_1)
DDR_B_CB0: JDIMM3.104(CB7/NC) JDIMM4.104(CB7/NC) UC1.AW11(NC/DDR1_ECC_0)
DDR_B_CB1: JDIMM3.88(CB4/NC) JDIMM4.88(CB4/NC) UC1.AY11(NC/DDR1_ECC_1)
DDR_B_CB2: JDIMM3.91(CB1/NC) JDIMM4.91(CB1/NC) UC1.AY8(NC/DDR1_ECC_2)
DDR_B_CB3: JDIMM3.92(CB0/NC) JDIMM4.92(CB0/NC) UC1.AW8(NC/DDR1_ECC_3)
DDR_B_CB4: JDIMM3.87(CB5/NC) JDIMM4.87(CB5/NC) UC1.AY10(NC/DDR1_ECC_4)
DDR_B_CB5: JDIMM3.105(CB3/NC) JDIMM4.105(CB3/NC) UC1.AW10(NC/DDR1_ECC_5)
DDR_B_CB6: JDIMM3.100(CB6/NC) JDIMM4.100(CB6/NC) UC1.AY7(NC/DDR1_ECC_6)
DDR_B_CB7: JDIMM3.101(CB2/NC) JDIMM4.101(CB2/NC) UC1.AW7(NC/DDR1_ECC_7)
DDR_B_CKE0: JDIMM4.109(CKE0) UC1.AT8(DDR1_CKE_0/DDR1_CKE_0)
DDR_B_CKE1: JDIMM4.110(CKE1) UC1.AT10(DDR1_CKE_1/DDR1_CKE_1)
DDR_B_CKE2: JDIMM3.109(CKE0) UC1.AT7(DDR1_CKE_2/DDR1_CKE_2)
DDR_B_CKE3: JDIMM3.110(CKE1) UC1.AT11(DDR1_CKE_3/DDR1_CKE_3)
DDR_B_CLK0: JDIMM4.137(CK0_T) UC1.AM9(DDR1_CKP_0/DDR1_CKP_0)
DDR_B_CLK1: JDIMM4.138(CK1_T/NF) UC1.AM7(DDR1_CKP_1/DDR1_CKP_1)
DDR_B_CLK2: JDIMM3.137(CK0_T) UC1.AM11(NC/DDR1_CKP_2)
DDR_B_CLK3: JDIMM3.138(CK1_T/NF) UC1.AJ10(NC/DDR1_CKP_3)
DDR_B_CLK#0: JDIMM4.139(CK0_C) UC1.AN9(DDR1_CKN_0/DDR1_CKN_0)
DDR_B_CLK#1: JDIMM4.140(CK1_C/NF) UC1.AM8(DDR1_CKN_1/DDR1_CKN_1)
DDR_B_CLK#2: JDIMM3.139(CK0_C) UC1.AM10(NC/DDR1_CKN_2)
DDR_B_CLK#3: JDIMM3.140(CK1_C/NF) UC1.AJ11(NC/DDR1_CKN_3)
DDR_B_CS#0: JDIMM4.149(CS0_N) UC1.AF11(DDR1_CS#_0/DDR1_CS#_0)
DDR_B_CS#1: JDIMM4.157(CS1_N) UC1.AE7(DDR1_CS#_1/DDR1_CS#_1)
DDR_B_CS#2: JDIMM3.149(CS0_N) UC1.AF10(NC/DDR1_CS#_2)
DDR_B_CS#3: JDIMM3.157(CS1_N) UC1.AE10(NC/DDR1_CS#_3)
DDR_B_D0: JDIMM3.8(DQ0) JDIMM4.7(DQ1) UC1.BT11(DDR1_DQ_0/DDR0_DQ_16)
DDR_B_D1: JDIMM3.7(DQ1) JDIMM4.8(DQ0) UC1.BR11(DDR1_DQ_1/DDR0_DQ_17)
DDR_B_D2: JDIMM3.16(DQ6) JDIMM4.17(DQ7) UC1.BT9(DDR1_DQ_2/DDR0_DQ_18)
DDR_B_D3: JDIMM3.21(DQ3) JDIMM4.20(DQ2) UC1.BR8(DDR1_DQ_3/DDR0_DQ_19)
DDR_B_D4: JDIMM3.3(DQ5) JDIMM4.4(DQ4) UC1.BP11(DDR1_DQ_4/DDR0_DQ_20)
DDR_B_D5: JDIMM3.4(DQ4) JDIMM4.3(DQ5) UC1.BN11(DDR1_DQ_5/DDR0_DQ_21)
DDR_B_D6: JDIMM3.17(DQ7) JDIMM4.16(DQ6) UC1.BP8(DDR1_DQ_6/DDR0_DQ_22)
DDR_B_D7: JDIMM3.20(DQ2) JDIMM4.21(DQ3) UC1.BN8(DDR1_DQ_7/DDR0_DQ_23)
DDR_B_D8: JDIMM3.24(DQ12) JDIMM4.25(DQ13) UC1.BL12(DDR1_DQ_8/DDR0_DQ_24)
DDR_B_D9: JDIMM3.29(DQ9) JDIMM4.28(DQ8) UC1.BL11(DDR1_DQ_9/DDR0_DQ_25)
DDR_B_D10: JDIMM3.25(DQ13) JDIMM4.24(DQ12) UC1.BL8(DDR1_DQ_10/DDR0_DQ_26)
DDR_B_D11: JDIMM3.38(DQ14) JDIMM4.37(DQ15) UC1.BJ8(DDR1_DQ_11/DDR0_DQ_27)
DDR_B_D12: JDIMM3.37(DQ15) JDIMM4.38(DQ14) UC1.BJ11(DDR1_DQ_12/DDR0_DQ_28)
DDR_B_D13: JDIMM3.41(DQ10) JDIMM4.42(DQ11) UC1.BJ10(DDR1_DQ_13/DDR0_DQ_29)
DDR_B_D14: JDIMM3.28(DQ8) JDIMM4.29(DQ9) UC1.BL7(DDR1_DQ_14/DDR0_DQ_30)
DDR_B_D15: JDIMM3.42(DQ11) JDIMM4.41(DQ10) UC1.BJ7(DDR1_DQ_15/DDR0_DQ_31)
DDR_B_D16: JDIMM3.50(DQ16) JDIMM4.49(DQ17) UC1.BG11(DDR1_DQ_16/DDR0_DQ_48)
DDR_B_D17: JDIMM3.46(DQ20) JDIMM4.45(DQ21) UC1.BG10(DDR1_DQ_17/DDR0_DQ_49)
DDR_B_D18: JDIMM3.45(DQ21) JDIMM4.46(DQ20) UC1.BG8(DDR1_DQ_18/DDR0_DQ_50)
DDR_B_D19: JDIMM3.59(DQ23) JDIMM4.58(DQ22) UC1.BF8(DDR1_DQ_19/DDR0_DQ_51)
DDR_B_D20: JDIMM3.63(DQ19) JDIMM4.62(DQ18) UC1.BF11(DDR1_DQ_20/DDR0_DQ_52)
DDR_B_D21: JDIMM3.62(DQ18) JDIMM4.63(DQ19) UC1.BF10(DDR1_DQ_21/DDR0_DQ_53)
DDR_B_D22: JDIMM3.49(DQ17) JDIMM4.50(DQ16) UC1.BG7(DDR1_DQ_22/DDR0_DQ_54)
DDR_B_D23: JDIMM3.58(DQ22) JDIMM4.59(DQ23) UC1.BF7(DDR1_DQ_23/DDR0_DQ_55)
DDR_B_D24: JDIMM3.84(DQ27) JDIMM4.83(DQ26) UC1.BB11(DDR1_DQ_24/DDR0_DQ_56)
DDR_B_D25: JDIMM3.67(DQ29) JDIMM4.66(DQ28) UC1.BC11(DDR1_DQ_25/DDR0_DQ_57)
DDR_B_D26: JDIMM3.80(DQ31) JDIMM4.79(DQ30) UC1.BB8(DDR1_DQ_26/DDR0_DQ_58)
DDR_B_D27: JDIMM3.70(DQ24) JDIMM4.71(DQ25) UC1.BC8(DDR1_DQ_27/DDR0_DQ_59)
DDR_B_D28: JDIMM3.66(DQ28) JDIMM4.67(DQ29) UC1.BC10(DDR1_DQ_28/DDR0_DQ_60)
DDR_B_D29: JDIMM3.79(DQ30) JDIMM4.80(DQ31) UC1.BB10(DDR1_DQ_29/DDR0_DQ_61)
DDR_B_D30: JDIMM3.71(DQ25) JDIMM4.70(DQ24) UC1.BC7(DDR1_DQ_30/DDR0_DQ_62)
DDR_B_D31: JDIMM3.83(DQ26) JDIMM4.84(DQ27) UC1.BB7(DDR1_DQ_31/DDR0_DQ_63)
DDR_B_D32: JDIMM3.187(DQ34) JDIMM4.186(DQ35) UC1.AA11(DDR1_DQ_32/DDR1_DQ_16)
DDR_B_D33: JDIMM3.183(DQ38) JDIMM4.182(DQ39) UC1.AA10(DDR1_DQ_33/DDR1_DQ_17)
DDR_B_D34: JDIMM3.173(DQ33) JDIMM4.174(DQ32) UC1.AC11(DDR1_DQ_34/DDR1_DQ_18)
DDR_B_D35: JDIMM3.169(DQ37) JDIMM4.170(DQ36) UC1.AC10(DDR1_DQ_35/DDR1_DQ_19)
DDR_B_D36: JDIMM3.182(DQ39) JDIMM4.183(DQ38) UC1.AA7(DDR1_DQ_36/DDR1_DQ_20)
DDR_B_D37: JDIMM3.186(DQ35) JDIMM4.187(DQ34) UC1.AA8(DDR1_DQ_37/DDR1_DQ_21)
DDR_B_D38: JDIMM3.170(DQ36) JDIMM4.169(DQ37) UC1.AC8(DDR1_DQ_38/DDR1_DQ_22)
DDR_B_D39: JDIMM3.174(DQ32) JDIMM4.173(DQ33) UC1.AC7(DDR1_DQ_39/DDR1_DQ_23)
DDR_B_D40: JDIMM3.191(DQ44) JDIMM4.190(DQ45) UC1.W8(DDR1_DQ_40/DDR1_DQ_24)
DDR_B_D41: JDIMM3.195(DQ40) JDIMM4.194(DQ41) UC1.W7(DDR1_DQ_41/DDR1_DQ_25)
DDR_B_D42: JDIMM3.203(DQ46) JDIMM4.204(DQ47) UC1.V10(DDR1_DQ_42/DDR1_DQ_26)
DDR_B_D43: JDIMM3.208(DQ43) JDIMM4.207(DQ42) UC1.V11(DDR1_DQ_43/DDR1_DQ_27)
DDR_B_D44: JDIMM3.190(DQ45) JDIMM4.191(DQ44) UC1.W11(DDR1_DQ_44/DDR1_DQ_28)
DDR_B_D45: JDIMM3.194(DQ41) JDIMM4.195(DQ40) UC1.W10(DDR1_DQ_45/DDR1_DQ_29)
DDR_B_D46: JDIMM3.207(DQ42) JDIMM4.208(DQ43) UC1.V7(DDR1_DQ_46/DDR1_DQ_30)
DDR_B_D47: JDIMM3.204(DQ47) JDIMM4.203(DQ46) UC1.V8(DDR1_DQ_47/DDR1_DQ_31)
DDR_B_D48: JDIMM3.211(DQ52) JDIMM4.212(DQ53) UC1.R11(DDR1_DQ_48/DDR1_DQ_48)
DDR_B_D49: JDIMM3.228(DQ50) JDIMM4.229(DQ51) UC1.P11(DDR1_DQ_49/DDR1_DQ_49)
DDR_B_D50: JDIMM3.225(DQ55) JDIMM4.224(DQ54) UC1.P7(DDR1_DQ_50/DDR1_DQ_50)
DDR_B_D51: JDIMM3.212(DQ53) JDIMM4.211(DQ52) UC1.R8(DDR1_DQ_51/DDR1_DQ_51)
DDR_B_D52: JDIMM3.215(DQ49) JDIMM4.216(DQ48) UC1.R10(DDR1_DQ_52/DDR1_DQ_52)
DDR_B_D53: JDIMM3.224(DQ54) JDIMM4.225(DQ55) UC1.P10(DDR1_DQ_53/DDR1_DQ_53)
DDR_B_D54: JDIMM3.216(DQ48) JDIMM4.215(DQ49) UC1.R7(DDR1_DQ_54/DDR1_DQ_54)
DDR_B_D55: JDIMM3.229(DQ51) JDIMM4.228(DQ50) UC1.P8(DDR1_DQ_55/DDR1_DQ_55)
DDR_B_D56: JDIMM3.245(DQ62) JDIMM4.246(DQ63) UC1.L11(DDR1_DQ_56/DDR1_DQ_56)
DDR_B_D57: JDIMM3.233(DQ61) JDIMM4.232(DQ60) UC1.M11(DDR1_DQ_57/DDR1_DQ_57)
DDR_B_D58: JDIMM3.246(DQ63) JDIMM4.245(DQ62) UC1.L7(DDR1_DQ_58/DDR1_DQ_58)
DDR_B_D59: JDIMM3.232(DQ60) JDIMM4.233(DQ61) UC1.M8(DDR1_DQ_59/DDR1_DQ_59)
DDR_B_D60: JDIMM3.249(DQ58) JDIMM4.250(DQ59) UC1.L10(DDR1_DQ_60/DDR1_DQ_60)
DDR_B_D61: JDIMM3.237(DQ56) JDIMM4.236(DQ57) UC1.M10(DDR1_DQ_61/DDR1_DQ_61)
DDR_B_D62: JDIMM3.236(DQ57) JDIMM4.237(DQ56) UC1.M7(DDR1_DQ_62/DDR1_DQ_62)
DDR_B_D63: JDIMM3.250(DQ59) JDIMM4.249(DQ58) UC1.L8(DDR1_DQ_63/DDR1_DQ_63)
DDR_B_DQS0: JDIMM3.13(DQS0_T) JDIMM4.13(DQS0_T) UC1.BP9(DDR1_DQSP_0/DDR0_DQSP_2)
DDR_B_DQS1: JDIMM3.34(DQS1_T) JDIMM4.34(DQS1_T) UC1.BJ9(DDR1_DQSP_1/DDR0_DQSP_3)
DDR_B_DQS2: JDIMM3.55(DQS2_T) JDIMM4.55(DQS2_T) UC1.BF9(DDR1_DQSP_2/DDR0_DQSP_6)
DDR_B_DQS3: JDIMM3.76(DQS3_T) JDIMM4.76(DQS3_T) UC1.BB9(DDR1_DQSP_3/DDR0_DQSP_7)
DDR_B_DQS4: JDIMM3.179(DQS4_T) JDIMM4.179(DQS4_T) UC1.AA9(DDR1_DQSP_4/DDR1_DQSP_2)
DDR_B_DQS5: JDIMM3.200(DQS5_T) JDIMM4.200(DQS5_T) UC1.V9(DDR1_DQSP_5/DDR1_DQSP_3)
DDR_B_DQS6: JDIMM3.221(DQS6_T) JDIMM4.221(DQS6_T) UC1.P9(DDR1_DQSP_6/DDR1_DQSP_6)
DDR_B_DQS7: JDIMM3.242(DQS7_T) JDIMM4.242(DQS7_T) UC1.L9(DDR1_DQSP_7/DDR1_DQSP_7)
DDR_B_DQS8: JDIMM3.97(DQS8_T) JDIMM4.97(DQS8_T) UC1.AW9(DDR1_DQSP_8/DDR1_DQSP_8)
DDR_B_DQS#0: JDIMM3.11(DQS0_C) JDIMM4.11(DQS0_C) UC1.BN9(DDR1_DQSN_0/DDR0_DQSN_2)
DDR_B_DQS#1: JDIMM3.32(DQS1_C) JDIMM4.32(DQS1_C) UC1.BL9(DDR1_DQSN_1/DDR0_DQSN_3)
DDR_B_DQS#2: JDIMM3.53(DQS2_C) JDIMM4.53(DQS2_C) UC1.BG9(DDR1_DQSN_2/DDR0_DQSN_6)
DDR_B_DQS#3: JDIMM3.74(DQS3_C) JDIMM4.74(DQS3_C) UC1.BC9(DDR1_DQSN_3/DDR0_DQSN_7)
DDR_B_DQS#4: JDIMM3.177(DQS4_C) JDIMM4.177(DQS4_C) UC1.AC9(DDR1_DQSN_4/DDR1_DQSN_2)
DDR_B_DQS#5: JDIMM3.198(DQS5_C) JDIMM4.198(DQS5_C) UC1.W9(DDR1_DQSN_5/DDR1_DQSN_3)
DDR_B_DQS#6: JDIMM3.219(DQS6_C) JDIMM4.219(DQS6_C) UC1.R9(DDR1_DQSN_6/DDR1_DQSN_6)
DDR_B_DQS#7: JDIMM3.240(DQS7_C) JDIMM4.240(DQS7_C) UC1.M9(DDR1_DQSN_7/DDR1_DQSN_7)
DDR_B_DQS#8: JDIMM3.95(DQS8_C) JDIMM4.95(DQS8_C) UC1.AY9(DDR1_DQSN_8/DDR1_DQSN_8)
DDR_B_DRAMRST#: CD78.1 CD113.1 JDIMM3.108(RESET_N) JDIMM4.108(RESET_N) RD77.2
DDR_B_MA0: JDIMM3.144(A0) JDIMM4.144(A0) UC1.AJ9(DDR1_CAB_9/DDR1_MA_0)
DDR_B_MA1: JDIMM3.133(A1) JDIMM4.133(A1) UC1.AK6(DDR1_CAB_8/DDR1_MA_1)
DDR_B_MA2: JDIMM3.132(A2) JDIMM4.132(A2) UC1.AK5(DDR1_CAB_5/DDR1_MA_2)
DDR_B_MA3: JDIMM3.131(A3) JDIMM4.131(A3) UC1.AL5(NC/DDR1_MA_3)
DDR_B_MA4: JDIMM3.128(A4) JDIMM4.128(A4) UC1.AL6(NC/DDR1_MA_4)
DDR_B_MA5: JDIMM3.126(A5) JDIMM4.126(A5) UC1.AM6(DDR1_CAA_0/DDR1_MA_5)
DDR_B_MA6: JDIMM3.127(A6) JDIMM4.127(A6) UC1.AN7(DDR1_CAA_2/DDR1_MA_6)
DDR_B_MA7: JDIMM3.122(A7) JDIMM4.122(A7) UC1.AN10(DDR1_CAA_4/DDR1_MA_7)
DDR_B_MA8: JDIMM3.125(A8) JDIMM4.125(A8) UC1.AN8(DDR1_CAA_3/DDR1_MA_8)
DDR_B_MA9: JDIMM3.121(A9) JDIMM4.121(A9) UC1.AR11(DDR1_CAA_1/DDR1_MA_9)
DDR_B_MA10: JDIMM3.146(A10/AP) JDIMM4.146(A10/AP) UC1.AH7(DDR1_CAB_7/DDR1_MA_10)
DDR_B_MA11: JDIMM3.120(A11) JDIMM4.120(A11) UC1.AN11(DDR1_CAA_7/DDR1_MA_11)
DDR_B_MA12: JDIMM3.119(A12) JDIMM4.119(A12) UC1.AR10(DDR1_CAA_6/DDR1_MA_12)
DDR_B_MA13: JDIMM3.158(A13) JDIMM4.158(A13) UC1.AF9(DDR1_CAB_0/DDR1_MA_13)
DDR_B_MA14: JDIMM3.151(WE_N/A14) JDIMM4.151(WE_N/A14) UC1.AH11(DDR1_CAB_2/DDR1_MA_14)
DDR_B_MA15: JDIMM3.156(CAS_N/A15) JDIMM4.156(CAS_N/A15) UC1.AF8(DDR1_CAB_1/DDR1_MA_15)
DDR_B_MA16: JDIMM3.152(RAS_N/A16) JDIMM4.152(RAS_N/A16) UC1.AH10(DDR1_CAB_3/DDR1_MA_16)
DDR_B_ODT0: JDIMM4.155(ODT0) UC1.AF7(DDR1_ODT_0/DDR1_ODT_0)
DDR_B_ODT1: JDIMM4.161(ODT1) UC1.AE8(NC/DDR1_ODT_1)
DDR_B_ODT2: JDIMM3.155(ODT0) UC1.AE9(NC/DDR1_ODT_2)
DDR_B_ODT3: JDIMM3.161(ODT1) UC1.AE11(NC/DDR1_ODT_3)
DDR_B_PARITY: JDIMM3.143(PARITY) JDIMM4.143(PARITY) UC1.AJ7(NC/DDR1_PAR)
DDR_RCOMP0: RC5.2 UC1.G1(DDR_RCOMP_0)
DDR_RCOMP1: RC6.2 UC1.H1(DDR_RCOMP_1)
DDR_RCOMP2: RC7.2 UC1.J2(DDR_RCOMP_2)
DDR_VTT_CTRL: UC1.BT13(DDR_VTT_CNTL) UD1.2(A)
DDR_XDP_WAN_SMBCLK: JDIMM1.253(SCL) JDIMM2.253(SCL) JDIMM3.253(SCL) JDIMM4.253(SCL) JXDP1.53 LGA1.1(SCL/SPC) QH4.1(S) RH333.1
DDR_XDP_WAN_SMBDAT: JDIMM1.254(SDA) JDIMM2.254(SDA) JDIMM3.254(SDA) JDIMM4.254(SDA) JXDP1.51 LGA1.4(SDA/SDI/SDO) QH4.4(S) RH374.1
DEBUG_TX: JDEG1.9 RE30.1 RE74.2
DG_GPIO8: RT503.1 RT553.1 UT1.W6(TMU_CLKIN)
DG_PA_USB2_MXCTL: RT508.1 UT1.R2(PA_USB2_MXCTL)
DG_PB_USB2_MXCTL: RT509.1 UT1.R1(PB_USB2_MXCTL)
DGFF_ALERT#: JDGFF1.A10 QV41.3(S) RV803.2
DGFF_BIA_PWM: JDGFF2.E1 UV65.2(IN A)
DGFF_CLK_REQ#: JDGFF2.C9 QV42.3(S) RV807.2
DGFF_DP_HDMI_HPD: DV32.1 DV33.1 DV43.1 RV905.1 UE1.F5(GPIO214/ADC12)
DGFF_ENVDD: DV3.3 JDGFF2.D1
DGFF_IFP_HPD: DV43.2 JDGFF1.C2
DGFF_OVERT#: JDGFF1.C1 QV40.3(S) RV816.2
DGFF_PANEL_BKEN: DV36.2 JDGFF2.D2
DGFF_PWR_LEVEL: JDGFF2.H10 RV819.2 UV60.4(Y)
DGFF_VGA_DIS#: JDGFF1.D1 UE12.8(GPA6)
DGPU_ALERT#: QV41.1(D) RV904.2 UE12.2(GPA3)
DGPU_HOLD_RST#: RH350.1 RV812.1 UH1.BB20(GPP_D10/ISH_SPI_CLK/GSPI2_CLK) UV63.1(IN1)
DGPU_PEX_RST#: DV34.1 JDGFF1.F2 QV40.2(G) QV41.2(G) RV813.1 UV63.4(O)
DGPU_PEX_RST#_D: CV812.1 DV34.2 RV800.1 RV815.2 UV61.1(IN1) UV62.1(IN1)
DGPU_PWR_EN: UE1.M1(GPIO100/NEC_SCI) UE11.2(A)
DGPU_PWR_EN_R: JDGFF2.F2 UE11.4(Y)
DGPU_PWROK: JDGFF1.F9 QV42.2(G) RV800.2 RV806.2 RV818.1 UE1.M4(GPIO013/SMB07_CLK/TOUT2) UH1.AV16(GPP_D18/DMIC_DATA1/SNDW3_DATA)
DGPU_SELECT#: QV43.2(G) RV901.2 UE12.28(GPC1) UV65.1(\\O\E)
DGPU_TYPE#: JDGFF1.D2 RV742.2
DID2_GPIO1: RV738.2 RV741.2 UE12.27(GPC2)
DID2_GPIO1_HDR: QV44.6(D) RV737.2 RV739.2
DID2_GPIO1_MUX: JEDP1.26 RV737.1 RV738.1
DID2_GPIO1_R: QV44.2(G) QV44.3(D) RV740.2
DID2_GPIO2: JEDP1.27 UE12.26(GPC3)
DIFFOUT_2PH: PR1134.1 PR1136.2 PU1100.35(DIFFOUT_2PH)
DIFFOUT_4PH: PC1114.2 PR1131.2 PU1100.4(DIFFOUT_4PH)
DIMM1_SA0: JDIMM1.256(SA0) RD18.1 RD78.1
DIMM1_SA1: JDIMM1.260(SA1) RD14.2 RD79.2
DIMM1_SA2: JDIMM1.166(SA2) RD15.2 RD80.2
DIMM2_SA0: JDIMM2.256(SA0) RD22.2 RD81.2
DIMM2_SA1: JDIMM2.260(SA1) RD23.2 RD82.2
DIMM2_SA2: JDIMM2.166(SA2) RD24.2 RD83.2
DIMM3_SA0: JDIMM3.256(SA0) RD42.1 RD85.1
DIMM3_SA1: JDIMM3.260(SA1) RD43.1 RD86.1
DIMM3_SA2: JDIMM3.166(SA2) RD40.2 RD87.2
DIMM4_SA0: JDIMM4.256(SA0) RD46.2 RD89.2
DIMM4_SA1: JDIMM4.260(SA1) RD51.1 RD88.1
DIMM4_SA2: JDIMM4.166(SA2) RD48.2 RD90.2
DISP_ON: DV35.1 DV36.1 DV37.1 JEDP1.19 RV836.1
DMI_CRX_PTX_N0: UC1.E8(DMI_RXN_0) UH1.C33(DMI0_TXN)
DMI_CRX_PTX_N1: UC1.F6(DMI_RXN_1) UH1.C32(DMI1_TXN)
DMI_CRX_PTX_N2: UC1.E5(DMI_RXN_2) UH1.C31(DMI2_TXN)
DMI_CRX_PTX_N3: UC1.J9(DMI_RXN_3) UH1.C29(DMI3_TXN)
DMI_CRX_PTX_P0: UC1.D8(DMI_RXP_0) UH1.B33(DMI0_TXP)
DMI_CRX_PTX_P1: UC1.E6(DMI_RXP_1) UH1.B32(DMI1_TXP)
DMI_CRX_PTX_P2: UC1.D5(DMI_RXP_2) UH1.B31(DMI2_TXP)
DMI_CRX_PTX_P3: UC1.J8(DMI_RXP_3) UH1.B29(DMI3_TXP)
DMI_CTX_PRX_N0: UC1.A8(DMI_TXN_0) UH1.K34(DMI0_RXN)
DMI_CTX_PRX_N1: UC1.B6(DMI_TXN_1) UH1.G33(DMI1_RXN)
DMI_CTX_PRX_N2: UC1.A5(DMI_TXN_2) UH1.K32(DMI2_RXN)
DMI_CTX_PRX_N3: UC1.B4(DMI_TXN_3) UH1.G30(DMI3_RXN)
DMI_CTX_PRX_P0: UC1.B8(DMI_TXP_0) UH1.J35(DMI0_RXP)
DMI_CTX_PRX_P1: UC1.C6(DMI_TXP_1) UH1.F34(DMI1_RXP)
DMI_CTX_PRX_P2: UC1.B5(DMI_TXP_2) UH1.J32(DMI2_RXP)
DMI_CTX_PRX_P3: UC1.D4(DMI_TXP_3) UH1.F30(DMI3_RXP)
DMIC0: CV843.1 DV4.2 JEDP1.13 RA52.2 UA1.4(GPIO0/DMIC-DATA12)
DMIC_CLK: CA54.1 CV842.1 DV4.3 JEDP1.11 RA14.1
DMIC_CLK_CODEC: RA14.2 UA1.5(GPIO1/DMIC-CLK)
DP1_GPU_SEL#: UE12.16(GPE0) UV66.9(SW)
DP1_SW1_REXT: RV861.2 UV66.31(REXT)
DP1_SW2_CFG0: RV125.2 UV8.59(CFG0)
DP1_SW2_PC10: RV63.2 RV64.1 UV8.56(PC10)
DP1_SW2_PC11: RV61.2 RV62.1 UV8.55(PC11)
DP1_SW2_PC20: RV59.2 RV60.1 UV8.54(PC20)
DP1_SW2_PC21: RV57.2 RV58.1 UV8.53(PC21)
DP1_SW2_PEQ: RV55.2 RV56.1 UV8.8(PEQ)
DP1_SW2_PI0: RV127.2 UV8.60(PL0/SDA_CTL)
DP1_SW2_PI1: RV65.2 RV66.1 UV8.1(PL1/SCL_CTL)
DP1_SW2_SW: RV126.2 UV8.18(SW)
DP2_GPU_SEL#: UE12.18(GPE3) UV67.9(SW)
DP2_SW1_REXT: RV870.2 UV67.31(REXT)
DPSRC_HPD: RT184.1 UT1.R5(DPSRC_HPD)
DRON: PR1216.1 PR1217.1 PR1218.1 PR1219.1 PR1220.1 PR1221.1 PR1222.1 PR1223.1 PU1100.17(DRON) PU1700.16(DISB#) PU1800.16(DISB#)
EC_FPM_EN: JUSH1.22 RZ1483.2
EDP_AUXN: CV838.1 UC1.B26(EDP_AUXN)
EDP_AUXN_C: CV838.2 UV64.27(IN1_AUXN)
EDP_AUXP: CV837.1 UC1.C26(EDP_AUXP)
EDP_AUXP_C: CV837.2 UV64.28(IN1_AUXP)
EDP_COMP: RC1.1 UC1.D37(DISP_RCOMP)
EDP_IN1_AEQ#: RV824.1 UV64.59(IN1_AEQ#)
EDP_IN1_PEQ: RV826.1 RV833.1 UV64.52(IN1_PEQ/SDA_CTL)
EDP_IN2_AEQ#: RV825.1 UV64.58(IN2_AEQ#)
EDP_IN2_PEQ: RV827.1 RV834.1 UV64.51(IN2_PEQ/SCL_CTL)
EDP_SW1_PC0: RV822.1 RV830.1 UV64.38(PC0)
EDP_SW1_PC1: RV823.1 RV831.1 UV64.55(PC1)
EDP_SW1_PI0: RV828.1 RV829.1 UV64.56(PI0)
EDP_TXN0: CV830.1 UC1.E29(EDP_TXN_0)
EDP_TXN0_C: CV830.2 UV64.2(IN1_D0N)
EDP_TXN1: CV832.1 UC1.E28(EDP_TXN_1)
EDP_TXN1_C: CV832.2 UV64.5(IN1_D1N)
EDP_TXN2: CV834.1 UC1.B29(EDP_TXN_2)
EDP_TXN2_C: CV834.2 UV64.7(IN1_D2N)
EDP_TXN3: CV836.1 UC1.B28(EDP_TXN_3)
EDP_TXN3_C: CV836.2 UV64.10(IN1_D3N)
EDP_TXP0: CV829.1 UC1.D29(EDP_TXP_0)
EDP_TXP0_C: CV829.2 UV64.1(IN1_D0P)
EDP_TXP1: CV831.1 UC1.F28(EDP_TXP_1)
EDP_TXP1_C: CV831.2 UV64.4(IN1_D1P)
EDP_TXP2: CV833.1 UC1.A29(EDP_TXP_2)
EDP_TXP2_C: CV833.2 UV64.6(IN1_D2P)
EDP_TXP3: CV835.1 UC1.C28(EDP_TXP_3)
EDP_TXP3_C: CV835.2 UV64.9(IN1_D3P)
EN_1.8V: PC902.1 PR901.1 PR902.1 PU900.7(EN)
EN_2.5V: PC401.1 PR401.1 PR402.1 PU400.7(EN)
EN_3V_5V: PC129.1 PR113.2 PR115.1 PU100.12(EN1) PU101.12(EN1)
EN_3VR_5VR: PC515.1 PR505.2 PR507.1 PU500.12(EN1) PU501.12(EN1)
EN_+1VSP: PC807.1 PR803.2 PU800.3(EN)
EN_INVPWR: QV2.2(G) RE55.1 UE1.B2(GPIO023/GPTP-IN1)
EN_IO: PC312.1 PR304.2 PR307.1 PU300.5(EN)
EN_SWR: RR231.2 RR232.1 UR1.41(EN_SWR)
ENABLE_DS#: RE549.2 RE550.1 UE1.L2(GPIO067/CLKRUN#)
ENLDO_3V5V: PR108.1 PR109.1 PU100.11(EN2) PU101.11(EN2)
ENLDO_3VR5VR: PR510.1 PR512.1 PU500.11(EN2) PU501.11(EN2)
ENVDD_PCH: DV42.2 UH1.AV44(GPP_F19/EDP_VDDEN)
ESPI_ALERT#: RH340.1 UE1.H7(GPIO063/SER_IRQ/ESPI_ALERT#) UH1.AW35(GPP_A6/SERIRQ/ESPI_CS1#)
ESPI_CLK: RH97.1 UH1.BB36(GPP_A9/CLKOUT_LPC0/ESPI_CLK)
ESPI_CLK_5105: JESPI.10 RE350.1 RH97.2 UE1.G7(GPIO065/PCI_CLK/ESPI_CLK)
ESPI_CS#: JESPI.7 UE1.H6(GPIO066/LFRAME#/ESPI_CS#) UH1.BE38(GPP_A5/LFRAME#/ESPI_CS0#)
ESPI_IO0: JESPI.3 RC366.2 UE1.K5(GPIO070/LAD0/ESPI_IO0)
ESPI_IO0_R: RC366.1 UH1.BB39(GPP_A1/LAD0/ESPI_IO0)
ESPI_IO1: JESPI.4 RC367.2 UE1.L4(GPIO071/LAD1/ESPI_IO1)
ESPI_IO1_R: RC367.1 UH1.AW37(GPP_A2/LAD1/ESPI_IO1)
ESPI_IO2: JESPI.5 RC368.2 UE1.G6(GPIO072/LAD2/ESPI_IO2)
ESPI_IO2_R: RC368.1 UH1.AV37(GPP_A3/LAD2/ESPI_IO2)
ESPI_IO3: JESPI.6 RC369.2 UE1.L5(GPIO073/LAD3/ESPI_IO3)
ESPI_IO3_R: RC369.1 UH1.BA38(GPP_A4/LAD3/ESPI_IO3)
ESPI_RESET#: CH348.1 JESPI.8 RH95.1 RH633.1 UE1.K6(GPIO061/LPCPD#/ESPI_RESET#) UH1.BF38(GPP_A14/SUS_STAT#/ESPI_RESET#)
EXPANDER_ALERT#: RE563.1 UE12.11(ALERT#)
FB_1.2V: PC211.1 PR206.1 PR209.1 PU200.6(FB)
FB_1.8V: PC904.2 PR904.2 PR905.1 PU900.1(VFB)
FB_2.5V: PC402.2 PR404.2 PR405.1 PU400.1(VFB)
FB_2PH: PC1116.2 PC1117.1 PR1136.1 PR1137.1 PU1100.34(FB_2PH)
FB_3VR: PC526.1 PU501.13(FF)
FB_4PH: PC1113.2 PC1115.2 PR1130.1 PR1131.1 PU1100.5(FB_4PH)
FB_5V: PC128.1 PU101.13(FF)
FB_5VR: PC514.1 PU500.13(FF)
FB_+1VSP: PR807.1 PR808.1 PU800.4(VFB)
FFS_INT2: LGA1.11(INT 2) QN1.2(G) RH378.2 UH1.BE14(GPP_D23/ISH_I2C2_SCL/I2C3_SCL)
FFS_INT2_Q: JNGFF4.32(NC9) QN1.3(D) RN1.2
FIVR_EN: RC217.1 RC218.2 RC219.2
FIVR_EN_R: JXDP1.45 RC126.2 RC132.2 RC217.2
FRS_ON1_R: RT570.2 UT9.3(FRS)
FRS_ON2_R: RT574.2 UT11.3(FRS)
FRS_ON_P1: RT570.1 RT617.1 UT5.L7(GPIO_L7)
FRS_ON_P2: RT574.1 RT618.1 UT5.L8(OVP_TRIP_P2 / GPIO_L8)
GC6_THM_ON: RH6.2 UE12.7(GPA4)
GPIO0: RR201.2 UR1.42(GPIO_0)
GPIO_0: RT505.1 UT1.W1(GPIO_0)
GPIO_1: RT506.1 UT1.W2(GPIO_1)
GPIO_3: RT507.1 UT1.Y1(TMU_CLKOUT)
GPP_B23: RH329.1 UH1.BD33(GPP_B23/SML1ALERT#/PCHHOT#)
GPP_C5: RH78.2 UH1.BF24(GPP_C5/SML0ALERT#)
GPP_D12: RH349.1 UH1.AN18(GPP_D12/ISH_SPI_MOSI/GP_BSSB_DI)
GPP_F22: RC444.1 UH1.AT49(GPP_F22/DDPF_CTRLCLK)
GPP_H12: RH615.2 UH1.AB47(GPP_H12/SML2ALERT#)
GPP_H15: RH601.2 UH1.AC47(GPP_H15/SML3ALERT#)
GPP_J1: RH616.2 UH1.AY3(GPP_J1/CPU_C10_GATE#)
GPPJ_RCOMP: RH609.2 UH1.BD1(GPPJ_RCOMP_1P81) UH1.BE1(GPPJ_RCOMP_1P82) UH1.BE2(GPPJ_RCOMP_1P83)
GPS_DISABLE#: DZ6.1 RE12.1 UE1.H5(GPIO060/KBRST/48MHZ_OUT)
GPU_DP1_AUXN: CV946.1 JDGFF1.F5
GPU_DP1_AUXP: CV945.1 JDGFF1.F4
GPU_DP1_C_AUXN: CV946.2 UV66.61(IN1_AUXN)
GPU_DP1_C_AUXP: CV945.2 UV66.62(IN1_AUXP)
GPU_DP1_HPD: DV32.2 RV898.1 UV62.2(IN2) UV66.16(IN1_HPD)
GPU_DP1_HPD_GATE: JDGFF1.C9 UV62.4(O)
GPU_DP1_N0: CV861.2 JDGFF1.F8
GPU_DP1_N0_C: CV861.1 UV66.5(IN1_D0N)
GPU_DP1_N1: CV863.2 JDGFF1.A2
GPU_DP1_N1_C: CV863.1 UV66.8(IN1_D1N)
GPU_DP1_N2: CV865.2 JDGFF1.G3
GPU_DP1_N2_C: CV865.1 UV66.11(IN1_D2N)
GPU_DP1_N3: CV867.2 JDGFF1.G6
GPU_DP1_N3_C: CV867.1 UV66.13(IN1_D3N)
GPU_DP1_P0: CV860.2 JDGFF1.F7
GPU_DP1_P0_C: CV860.1 UV66.4(IN1_D0P)
GPU_DP1_P1: CV862.2 JDGFF1.A1
GPU_DP1_P1_C: CV862.1 UV66.7(IN1_D1P)
GPU_DP1_P2: CV864.2 JDGFF1.G2
GPU_DP1_P2_C: CV864.1 UV66.10(IN1_D2P)
GPU_DP1_P3: CV866.2 JDGFF1.G5
GPU_DP1_P3_C: CV866.1 UV66.12(IN1_D3P)
GPU_DP2_AUXN: CV943.1 JDGFF1.A5
GPU_DP2_AUXP: CV944.1 JDGFF1.A4
GPU_DP2_C_AUXN: CV943.2 UV67.61(IN1_AUXN)
GPU_DP2_C_AUXP: CV944.2 UV67.62(IN1_AUXP)
GPU_DP2_HPD: DV33.2 RV897.1 UV61.2(IN2) UV67.16(IN1_HPD)
GPU_DP2_HPD_GATE: JDGFF1.H10 UV61.4(O)
GPU_DP2_N0: CV884.2 JDGFF1.A8
GPU_DP2_N0_C: CV884.1 UV67.5(IN1_D0N)
GPU_DP2_N1: CV886.2 JDGFF1.H2
GPU_DP2_N1_C: CV886.1 UV67.8(IN1_D1N)
GPU_DP2_N2: CV888.2 JDGFF1.H5
GPU_DP2_N2_C: CV888.1 UV67.11(IN1_D2N)
GPU_DP2_N3: CV890.2 JDGFF1.B6
GPU_DP2_N3_C: CV890.1 UV67.13(IN1_D3N)
GPU_DP2_P0: CV883.2 JDGFF1.A7
GPU_DP2_P0_C: CV883.1 UV67.4(IN1_D0P)
GPU_DP2_P1: CV885.2 JDGFF1.H1
GPU_DP2_P1_C: CV885.1 UV67.7(IN1_D1P)
GPU_DP2_P2: CV887.2 JDGFF1.H4
GPU_DP2_P2_C: CV887.1 UV67.10(IN1_D2P)
GPU_DP2_P3: CV889.2 JDGFF1.B5
GPU_DP2_P3_C: CV889.1 UV67.12(IN1_D3P)
GPU_EDP_AUXN: CV828.1 JDGFF1.B9
GPU_EDP_AUXN_C: CV828.2 UV64.29(IN2_AUXN)
GPU_EDP_AUXP: CV827.1 JDGFF1.B8
GPU_EDP_AUXP_C: CV827.2 UV64.30(IN2_AUXP)
GPU_EDP_HPD: JDGFF1.E1 UV64.13(IN2_HPD)
GPU_EDP_N0: CV820.1 JDGFF1.G9
GPU_EDP_N0_C: CV820.2 UV64.12(IN2_D0N)
GPU_EDP_N1: CV822.1 JDGFF1.B3
GPU_EDP_N1_C: CV822.2 UV64.15(IN2_D1N)
GPU_EDP_N2: CV824.1 JDGFF1.C8
GPU_EDP_N2_C: CV824.2 UV64.17(IN2_D2N)
GPU_EDP_N3: CV826.1 JDGFF1.C5
GPU_EDP_N3_C: CV826.2 UV64.20(IN2_D3N)
GPU_EDP_P0: CV819.1 JDGFF1.G8
GPU_EDP_P0_C: CV819.2 UV64.11(IN2_D0P)
GPU_EDP_P1: CV821.1 JDGFF1.B2
GPU_EDP_P1_C: CV821.2 UV64.14(IN2_D1P)
GPU_EDP_P2: CV823.1 JDGFF1.C7
GPU_EDP_P2_C: CV823.2 UV64.16(IN2_D2P)
GPU_EDP_P3: CV825.1 JDGFF1.C4
GPU_EDP_P3_C: CV825.2 UV64.19(IN2_D3P)
GPU_EVENT#: DV44.1 UH1.BE9(GPP_G1/SD_DATA0)
GPU_GC6_FB_EN: RV485.2 UH1.BF9(GPP_G3/SD_DATA2)
GPU_GC6_FB_EN_R: JDGFF2.F10 RV485.1
GPU_PWR_LEVEL: RE557.1 UE1.E12(GPIO126/PVT_IO3) UV60.2(A)
GPU_SMBCLK_R: JDGFF2.C1 QV30.4(S) RV804.2
GPU_SMBDAT_R: JDGFF2.C2 QV30.1(S) RV805.2
GPU_SMCLK: QV30.3(D) RE730.1 UE1.F7(GPIO142/SMB05_CLK/SPI1_MOSI/UAR)
GPU_SMDAT: QV30.6(D) RE731.1 UE1.B6(GPIO141/SMB05_DATA/SPI1_CLK/UAR)
GT_SW1: PC1709.1 PL1700.1 PU1700.11(SW1) PU1700.12(SW2)
H_CATERR#: RC79.2 UC1.BM30(CATERR#)
H_PECI: RE60.2 RH73.2 UC1.BT34(PECI)
H_PM_DOWN: RC168.1 UH1.AE2(PM_DOWN)
H_PM_DOWN_R: RC168.2 UC1.BP31(PM_DOWN)
H_PM_SYNC: RH156.2 UC1.BM34(PM_SYNC)
H_PM_SYNC_R: RH156.1 UH1.AF3(PM_SYNC)
H_PROCHOT#_R: RC84.2 UC1.BR30(PROCHOT#)
H_PWRGD: CC300.1 UC1.BT31(PROCPWRGD) UH1.AE3(CPUPWRGD)
H_SKTOCC#: RC319.2 UC1.BR33(SKTOCC#)
H_THERMTRIP#: CC323.1 QE4.3(EMITTER) RC80.2 RC169.1 RD7.2 RD21.2 RD29.2 RD45.2 RH75.2
H_THERMTRIP#_R: RC169.2 UC1.J31(THERMTRIP#)
H_VCCST_PWRGD_XDP: CC307.1 JXDP1.39 RC124.2
HDA_BIT_CLK: RH46.2 RH637.2 UH1.BD11(HDA_BCLK/I2S0_SCLK)
HDA_BIT_CLK_R: CH268.2 RA17.1 RH46.1 UA1.14(BCLK)
HDA_RST#: RH50.2 RH636.2 UH1.BE10(HDA_RST#/I2S1_SCLK)
HDA_RST#_R: RA50.1 RH50.1
HDA_SDIN0: CA73.1 RA9.1 UH1.BE11(HDA_SDI0/I2S0_RXD)
HDA_SDIN0_R: RA9.2 UA1.16(SDATA-IN)
HDA_SDOUT: CA76.1 RH45.2 RH328.2 UH1.BF12(HDA_SDO/I2S0_TXD)
HDA_SDOUT_R: RH45.1 UA1.17(SDATA-OUT)
HDA_SYNC: CA74.1 RH48.2 UH1.BG13(HDA_SYNC/I2S0_SFRM)
HDA_SYNC_R: RH48.1 UA1.15(SYNC)
HDD_DET#: JNGFF4.34(NC10) RH324.2 UH1.AK47(GPP_E2/SATAXPCIE2/SATAGP2)
HDD_FALL_INT: LGA1.12(INT 1) RH355.2 UH1.AW26(GPP_B19/GSPI1_CS0#)
HDD_IFDET: JNGFF4.75(GND16) RZ541.1 UZ60.1(IN1)
HOST_DEBUG_TX: JDEG1.8 RE73.2 RE306.2 UE1.G11(GPIO104/UART0_TX)
HOST_SD_WP#: QR1.2(G) RH214.2 UH1.BE8(GPP_G5/SD_CD#)
HP_OUT_L: CA43.2 CA224.1 RA7.2 UA1.27(HPOUT-L)
HP_OUT_R: CA44.2 CA225.1 RA8.2 UA1.26(HPOUT-R)
HW_ACAVIN_NB: PQ2001.2(G1) PQ2007.6(D1) PR2009.2 PR2014.1 PR2037.1 PU1.1(B) UE1.N6(GPIO014/PWM6/GPTP-IN6)
HW_GPS_DISABLE#_R: DZ6.2 JNGFF2.18
I2C1_SCK_TP: RZ21.2 RZ29.1 UH1.BE21(GPP_C19/I2C1_SCL)
I2C1_SCK_TP_R: JKBTP1.19 RZ29.2 RZ117.2 RZ347.2
I2C1_SDA_TP: RZ20.2 RZ26.1 UH1.BF21(GPP_C18/I2C1_SDA)
I2C1_SDA_TP_R: JKBTP1.18(18     18) RZ26.2 RZ116.2 RZ346.2
I2C_ADDR_MUX1: RV849.1 UV66.6(I2C_ADDR)
I2C_ADDR_MUX2: RV862.1 UV67.6(I2C_ADDR)
I_ADP: PR717.1 UE1.B11(VCP)
I_BATT: PR719.1 RE64.2
I_BATT_R: CE3.1 RE64.1 UE1.J4(GPIO200/ADC00)
I_SYS: PR714.1 PR723.1 PR1153.1 PU1100.24(TTSENSE_1PH/PSYS) RE312.2
I_SYS_R: CE4.1 RE312.1 RE313.1 UE1.J5(GPIO201/ADC01)
ILIM_1PH: PC1100.2 PR1116.2 PU1100.49(ILIM_1PH)
ILIM_2PH: PR1139.1 PU1100.32(ILIM_2PH)
ILIM_4PH: PR1138.2 PU1100.7(ILIM_4PH)
ILIM_CHG: PQ704.1(S2) PR720.2 PR726.1 PU700.21(ILIM)
ILIM_SEL1: RI13.1 UI1.4(ILIM_SEL)
ILIM_SEL2: RI67.1 UI2.4(ILIM_SEL)
ILIM_SEL3: RI82.1 UI3.4(ILIM_SEL)
IMON_1PH: PC1106.2 PR1112.2 PU1100.46(IMON_1PH)
IMVP_VR_ON: PR1198.2 RE304.1 UE3.4(OUT) UE4.2(A)
IMVP_VR_ON_EC: RE304.2 RE737.2 UE1.N7(GPIO031/GPTP-OUT1) UE3.1(IN1)
INT_SPK_L+: CA22.1 LA6.1 UA1.42(SPK-OUT-L+)
INT_SPK_L-: CA23.1 LA7.1 UA1.43(SPK-OUT-L-)
INT_SPK_R+: CA19.1 LA8.1 UA1.45(SPK-OUT-R+)
INT_SPK_R-: CA24.1 LA9.1 UA1.44(SPK-OUT-R-)
INT_SPKR_L+: DA6.2 JSPK1.1 LA6.2
INT_SPKR_L-: DA6.3 JSPK1.2 LA7.2
INT_SPKR_R+: DA7.2 JSPK1.3 LA8.2
INT_SPKR_R-: DA7.3 JSPK1.4 LA9.2
IR_CAM_DET#: JIR1.1 RH373.1 UH1.BD16(GPP_D19/DMIC_CLK0/SNDW4_CLK)
ISH_UART0_CTS#: RZ80.2 UH1.BF14(GPP_D16/ISH_UART0_CTS#/CNV_WCEN)
ISH_UART0_RTS#: RZ81.2 UH1.AR18(GPP_D15/ISH_UART0_RTS#/GSPI2_CS)
ISH_UART0_RXD: RZ78.2 UH1.BE17(GPP_D13/ISH_UART0_RXD/I2C2_SDA)
ISH_UART0_TXD: RZ79.2 UH1.BF17(GPP_D14/ISH_UART0_TXD/I2C2_SCL)
IST_TRIG: T3.1 UC1.E3(IST_TRIG)
ITP_PMODE_CPU: RC144.2 UH1.AL3(ITP_PMODE)
JDIMM1_EVENT#: JDIMM1.134(EVENT_N/NF) RD7.1
JDIMM2_EVENT#: JDIMM2.134(EVENT_N/NF) RD21.1
JDIMM3_EVENT#: JDIMM3.134(EVENT_N/NF) RD29.1
JDIMM4_EVENT#: JDIMM4.134(EVENT_N/NF) RD45.1
JTAG_CLK: JDEG1.4 RE740.2 UE1.C8(GPIO147/SMB08_DATA/JTAG_CLK)
JTAG_RST#: CE30.1 JTAG1.1 RE63.1 RE65.1 UE1.G13(JTAG_RST#)
JTAG_TDI: JDEG1.2 RE742.2 UE1.E9(GPIO145/SMB09_DATA/JTAG_TDI)
JTAG_TDO: JDEG1.5 RE739.2 UE1.F6(GPIO146/SMB09_CLK/JTAG_TDO)
JTAG_TMS: JDEG1.3 RE741.2 UE1.C5(GPIO150/SMB08_CLK/JTAG_TMS)
KB_DET#: JKBTP1.1 RC74.2 UH1.AW15(GPP_D17/DMIC_CLK1/SNDW3_CLK)
LAN_ACTLED_YEL#: QL1.1(S) UL1.26(LED0)
LAN_ACTLED_YEL#_Q: QL1.6(D) RL14.1
LAN_DISABLE#_R: RL5.2 RL7.2 RL9.1 UL1.3(LAN_DISABLE_N)
LAN_MDIN0: RL72.1 UL1.14(MDI_MINUS0)
LAN_MDIN0_L: RL72.2 TL1.2(TD1-)
LAN_MDIN1: RL74.1 UL1.18(MDI_MINUS1)
LAN_MDIN1_L: RL74.2 TL1.6(TD2-)
LAN_MDIN2: RL76.1 UL1.21(MDI_MINUS2)
LAN_MDIN2_L: RL76.2 TL1.8(TD3-)
LAN_MDIN3: RL78.1 UL1.24(MDI_MINUS3)
LAN_MDIN3_L: RL78.2 TL1.12(TD4-)
LAN_MDIP0: RL71.1 UL1.13(MDI_PLUS0)
LAN_MDIP0_L: RL71.2 TL1.1(TD1+)
LAN_MDIP1: RL73.1 UL1.17(MDI_PLUS1)
LAN_MDIP1_L: RL73.2 TL1.5(TD2+)
LAN_MDIP2: RL75.1 UL1.20(MDI_PLUS2)
LAN_MDIP2_L: RL75.2 TL1.7(TD3+)
LAN_MDIP3: RL77.1 UL1.23(MDI_PLUS3)
LAN_MDIP3_L: RL77.2 TL1.11(TD4+)
LAN_TEST_EN: RL12.1 UL1.30(TEST_EN)
LAN_WAKE#: RH93.1 RL10.1 UE1.L3(GPIO217/ADC15) UH1.BG44(GPD2/LAN_WAKE#)
LCD_CBL_DET#: JEDP1.20 RC370.1 UH1.AW24(GPP_C14/UART1_RTS#/ISH_UART1_RT)
LCD_TST: JEDP1.24 RE20.1 UE1.M2(GPIO052/FAN_TACH2/LRESET#)
LCD_VCC_TEST_EN: DV3.2 UE1.E1(GPIO226/LED3)
LDO_IN: CT374.1 DT60.1 DT62.1 DT63.1 DT64.1 RT543.1 UT7.1(VCC)
LED_10_GRN#: QL7.3(S) RL30.2 UL1.25(LED2) UL2.2(IN2)
LED_10_GRN#_Q: QL7.1(D) RL19.1
LED_100_ORG#: QL1.4(S) RL29.2 UL1.27(LED1) UL2.1(IN1)
LED_100_ORG#_Q: QL1.3(D) RL20.1
LED_MASK#: QL1.2(G) QL1.5(G) QL7.2(G) RE21.1 UE1.A12(GPIO140/SMB06_CLK/ICT5) UZ10.1(IN1)
LG_1.2V: PQ201.4(G) PU200.15(LGATE)
LG_+1VSP: PQ801.4(G) PU800.6(DRVL)
LGATE_CHG: PQ703.4(G) PU700.23(LODRV)
LID_CL#: JPB1.6 RE26.1 UZ10.2(IN2)
LID_CL#_PCH: T268.1 UH1.AV34(GPP_A23/ISH_GP5)
LID_CL_SIO#: CE8.1 RE25.2 RE26.2 UE1.N11(GPIO115/PS2_DAT0A)
LINE1-L: CA43.1 UA1.36(LINE2-L)
LINE1-R: CA44.1 UA1.35(LINE2-R)
LOM_CABLE_DETECT#: RE505.1 UE1.D2(GPIO211/ADC09) UL2.4(O)
LP#_VCCIO: PR309.2 PU300.6(LP#)
LPS_OFF1: PQ1.6(D1) PQ2110.6(D1) PQ2111.6(D1) PR6.2
LPS_OFF2: PQ4.6(D1) PQ2111.3(D2) PR31.2
LPS_OFF3: PQ7.6(D1) PQ2110.3(D2) PR48.2
LPS_OFF_BATT: PQ2112.3(D2) PQ2112.6(D1) PR734.2
LPS_OFF_BATT_R: PQ705.2(G) PR733.2 PR734.1 QT10.2(G)
LX_1.2V: PC201.1 PL201.2 PQ200.1(S1) PQ200.2(S2) PQ200.3(S3) PQ201.5(D) PR202.1 PU200.16(PHASE)
LX_1.8V: PL900.1 PR903.1 PU900.6(LX)
LX_2.5V: PL400.1 PR403.1 PU400.6(LX)
LX_3V: PC110.2 PL100.1 PR100.1 PU100.6(LX3) PU100.19(LX1) PU100.20(LX2)
LX_3VR: PC531.2 PL501.1 PR511.1 PU501.6(LX3) PU501.19(LX1) PU501.20(LX2)
LX_5V: PC115.2 PL101.1 PR112.1 PU101.6(LX3) PU101.19(LX1) PU101.20(LX2)
LX_5VR: PC501.2 PL500.1 PR502.1 PU500.6(LX3) PU500.19(LX1) PU500.20(LX2)
LX_+1VSP: PC804.1 PL801.1 PQ800.1(S1) PQ800.2(S2) PQ800.3(S3) PQ801.5(D) PR805.1 PU800.8(SW)
LX_CHG: PC708.1 PL701.1 PQ702.1(S1) PQ702.2(S2) PQ702.3(S3) PQ703.5(D) PR722.1 PU700.27(PHASE)
LX_IO: PC305.2 PL300.1 PR301.1 PU300.8(SW)
M2_SLOT3_PEDET: JNGFF3.61(PEDET(NC-PCIE/GND-SATA)) RN200.1 UH1.AJ43(GPP_E1/SATAXPCIE1/SATAGP1)
M2_SLOT4_PEDET: JNGFF4.69(PEDET(NC-PCIE/GND-SATA)) RN203.1 UH1.AM46(GPP_F1/SATAXPCIE4/SATAGP4)
M2_SLOT5_PEDET: JNGFF5.61(PEDET(NC-PCIE/GND-SATA)) RN208.1 UH1.AN47(GPP_F0/SATAXPCIE3/SATAGP_3)
M2_SLOT6_PEDET: JNGFF6.61(PEDET(NC-PCIE/GND-SATA)) RN211.1 UH1.AH41(GPP_E0/SATAXPCIE0/SATAGP0)
M3042_PCIE#_SATA: T309.1 UE1.J12(GPIO043/SB-TSI_CLK)
M_BIST: RZ1415.2 UE1.N8(GPI0040/GPTP-OUT2)
M_BIST_R: CZ218.1 DZ12.2 QZ22.2(BASE) RZ1413.2 RZ1415.1 RZ1482.2
MACO_EN: JDGFF2.F9 UH1.AP29(GPP_B11/I2S_MCLK)
MASK_BASE_LEDS#: QZ7.2(G) UZ10.4(OUT)
MDP_CA_DET: JDGFF4.F2 RV131.2 UV8.33(OUT2_CA_DET)
ME_FWP: RH100.1 SW1.1(A) UE1.G12(GPIO105/UART0_RX)
ME_FWP_PCH: RH100.2 RH328.1 SW1.3(C)
ME_RESET#: RH70.1 UC3.2(IN A)
ME_SUS_PWR_ACK_R: T319.1 UH1.BC37(GPP_A13/SUSWARN#/SUSPWRDNACK)
MEC_XTAL1: CE28.1 UE1.A1(XTAL1) YE1.1
MEC_XTAL2: CE29.1 RE290.2 YE1.2
MEC_XTAL2_R: RE290.1 UE1.A3(XTAL2)
MEDIACARD_IRQ#: RR211.2 UH1.BB26(GPP_B15/GSPI0_CS0#) UR1.48(WAKE#)
MEM_INTERLEAVED: RH371.1 RH372.1 UH1.BA20(GPP_D9/ISH_SPI_CS#/GSPI2_CS0#)
MEM_SMBCLK: CC320.1 QH4.6(D) RH56.2 UH1.BE26(GPP_C0/SMBCLK)
MEM_SMBDATA: QH4.3(D) RH57.2 UH1.BF26(GPP_C1/SMBDATA)
MID1_CA_DET: RV895.1 UV66.52(DP_CADET)
MID2_CA_DET: RV896.2 UV67.52(DP_CADET)
MISO: UR1.14(MISO) UR3.2(DO(IO1))
MOD_ID1: RT534.2 RT536.1 UT5.L10(SCL_3 / VSEL_1_P1 /GPIO_L10)
MOD_ID2: RT535.2 RT537.1 UT5.L4(VSEL_1_P2 / GPIO_L4)
MODE_IO: PR308.1 PU300.7(MODE)
MOSI: UR1.15(MOSI) UR3.5(DI(IO0))
MSCLK: JDEG1.6 RE30.2 RE72.2 UE1.H10(GPIO170/TFDP_CLK/UART1_TX)
MSDATA: JDEG1.7 RE75.2 RE86.1 UE1.G9(GPIO171/TFDP_DATA/UART1_RX)
MUX1_CFG0: RV876.1 RV879.1 UV66.28(CFG0)
MUX1_CFG1: RV856.1 RV878.1 UV66.27(CFG1)
MUX1_CFG2: RV857.1 RV877.1 UV66.26(CFG2)
MUX1_CFG3: RV848.1 RV858.1 UV66.25(CFG3)
MUX1_CFG4: RV891.1 RV892.1 UV66.46(CFG4)
MUX1_IN1_EQ0: RV852.1 RV881.1 UV66.40(IN1_EQ0)
MUX1_IN1_EQ1: RV850.1 RV882.1 UV66.41(IN1_EQ1)
MUX1_IN2_EQ0: RV853.1 RV883.1 UV66.38(IN2_EQ0)
MUX1_IN2_EQ1: RV851.1 RV880.1 UV66.39(IN2_EQ1)
MUX2_CFG0: RV871.1 RV887.1 UV67.28(CFG0)
MUX2_CFG1: RV872.1 RV888.1 UV67.27(CFG1)
MUX2_CFG2: RV873.1 RV886.1 UV67.26(CFG2)
MUX2_CFG3: RV874.1 RV885.1 UV67.25(CFG3)
MUX2_CFG4: RV893.1 RV894.1 UV67.46(CFG4)
MUX2_IN1_EQ0: RV864.1 RV875.1 UV67.40(IN1_EQ0)
MUX2_IN1_EQ1: RV865.1 RV868.1 UV67.41(IN1_EQ1)
MUX2_IN2_EQ0: RV863.1 RV866.1 UV67.38(IN2_EQ0)
