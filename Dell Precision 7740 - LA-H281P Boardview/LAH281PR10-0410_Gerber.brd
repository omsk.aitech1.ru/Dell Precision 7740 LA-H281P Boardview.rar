# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
HOST_SD_WP#: length 128
  TOP w0.102: UH1.BE8 123.82,45.22 123.55,44.96 123.25,44.96 123.07,44.78 122.35,44.78 122.09,45.03
  TOP w0.109: v2(87.83,38.5) 88.15,38.18 88.15,37.48 v1(87.58,36.91) 87.58,36.59 v2(87.83,36.34) ; 122.09,45.03 121.23,45.03 120.85,45.42 120.85,46.05 119.92,46.98 118.74,46.98 v2(118.34,46.58) 118.34,46.58 117.63,46.58 RH214.2
  IN1 w0.102: v2(30.21,24.85) 30.21,25.19 30.6,25.57 31.84,25.57 32.41,26.14 34.26,26.14 34.41,25.99 40.51,25.99 40.65,26.13 43.41,26.13 44.7,27.42 47.62,27.42 50.09,24.96 50.09,24.41 50.38,24.12 52.8,24.12 56.04,27.35 56.35,27.35 58.44,29.44 62.24,29.44 65.22,32.41 65.22,36.73 66.19,37.71 71.95,37.71 72.79,36.87 75.18,36.87 76.42,38.11 87.45,38.11 v2(87.83,38.5) ; v2(101.52,33.19) 101.98,33.19 102.21,33.42 102.21,33.82 101.59,34.44 99.61,34.44 98.48,33.31 97.1,33.31 96.86,33.55 96.86,35.44 96.56,35.74 95.78,36.53 88.02,36.53 v2(87.83,36.34)
  IN2 w0.081: v2(101.52,33.19) 102.05,33.19 103.77,34.91 107.73,34.91 113,40.18 113,40.53 113.69,41.22 113.69,46.85 114.08,47.23 114.59,47.23 115.23,46.59 115.23,46.34 115.61,45.96 115.99,45.96 116.6,46.58 118.34,46.58 v2(118.34,46.58)
  BOTTOM w0.109: QR1.2 30.21,24.48 v2(30.21,24.85)
HP_OUT_L: length 14.9
  TOP w0.203: UA1.27 385.28,21.61 385.54,21.36 v2(385.79,21.36)
  TOP w0.381: v2(388.95,28.29) 388.95,28.35 388.25,29.05 CA43.2 ; RA7.2 386.05,21.1 v2(385.79,21.36)
  IN1 w0.381: v2(388.95,28.29) 389.1,28.29 389.54,27.85 389.54,27.31 389.27,27.04 387.23,27.04 385.14,24.95 385.14,22.01 v2(385.79,21.36)
  BOTTOM w0.109: v2(385.79,21.36) v1(385.27,21.36)
  BOTTOM w0.254: CA224.1 385.9,21.48 v2(385.79,21.36)
HP_OUT_R: length 15.5
  TOP w0.203: UA1.26 385.21,21.21 385.75,20.67 385.75,20.47 385.78,20.45 v2(385.83,20.45)
  TOP w0.381: v2(388.95,27.61) 388.47,27.61 CA44.2 ; v2(385.83,20.45) 385.94,20.33 RA8.2
  IN1 w0.381: v2(388.95,27.61) 386.78,27.61 384.63,25.47 384.63,21.65 v2(385.83,20.45)
  BOTTOM w0.109: v1(385.77,19.51) 385.83,19.57 v2(385.83,20.45)
  BOTTOM w0.254: CA225.1 385.91,20.59 385.83,20.51 v2(385.83,20.45)
HW_ACAVIN_NB: length 163.2
  TOP w0.102: PQ2001.2 59,15.39 58.9,15.29 58.9,14.9 PR2014.1 60.24,13.56 60.24,12.29 v2(60.91,11.62) ; PU1.1 86.18,18.04 v2(86.18,16.63)
  TOP w0.109: UE1.N6 136.37,69.18 136.37,69.08 136.34,69.05 136.34,68.73 v2(136.36,68.71)
  IN1 w0.102: v2(102.14,57.03) 101.78,57.03 96.48,51.74 96.48,46.29 97.08,45.7 97.08,37.89 98.23,36.74 99.24,36.74 99.95,36.03 102.19,36.03 104.11,34.12 104.11,31.95 103.57,31.41 103.57,30.49 102.88,29.81 101.37,29.81 99.22,27.66 99.22,21.47 94.49,16.74 v2(94.49,15.61)
  IN2 w0.081: v2(60.91,11.62) 61.33,12.05 76.84,12.05 81.16,16.37 83.41,16.37 84.48,17.44 85.65,17.44 86.18,16.91 v2(86.18,16.63)
  IN3 w0.081: v2(116.66,68.96) 116.58,68.96 114.79,67.17 114.79,66.17 113.98,65.36 113.66,65.36 112.41,64.11 111.99,64.11 111.31,63.43 111.31,61.3 111.31,61.3 111.31,61.13 110.75,60.56 109.2,60.56 105.57,56.93 102.48,56.93 102.38,57.03 v2(102.14,57.03)
  IN4 w0.102: v2(73.48,25.74) 74.69,24.53 78.05,24.53 80.4,22.18 80.4,20.75 80.74,20.41 82.55,20.41 85.21,17.74 85.21,17.57 86.15,16.63 v2(86.18,16.63) ; v2(136.36,68.71) 136.36,68.03 136.09,67.76 135.82,67.76 135.59,67.53 131.83,67.53 131.18,66.87 130.7,66.87 130.6,66.98 129.01,66.98 128.72,66.69 127.55,66.69 127.26,66.98 123.64,66.98 122.4,68.22 119.82,68.22 119.08,68.96 v2(116.66,68.96)
  BOTTOM w0.109: v2(73.48,25.74) 73.41,25.67 PR2037.1 72.87,26.02 73.05,26.2 73.31,26.2 PR2009.2 73.53,26.49 73.27,26.76 PQ2007.6 ; v2(86.18,16.63) 86.18,16.55 86.56,16.17 v1(87.2,16.17) 89.63,16.17 89.68,16.22 94.13,16.22 94.49,15.87 v2(94.49,15.61)
HW_GPS_DISABLE#_R: length 4.2
  BOTTOM w0.109: DZ6.2 149.17,116.54 v1(150.51,116.54) 151.49,115.56 JNGFF2.18
I2C1_SCK_TP: length 115.5
  TOP w0.102: v2(122.49,38.88) 122.55,38.88 122.59,38.84 123.52,38.84 123.73,38.63 UH1.BE21
  IN2 w0.081: v2(122.49,38.88) 122.49,38.51 122.18,38.2 118.28,38.2 117.71,38.76 112.77,38.76 110.87,36.87 110.87,33.58 110.61,33.31 109.67,33.31 107.33,30.97 105.8,30.97 105.29,31.48 103.55,31.48 102.61,30.54 101.01,30.54 99.83,29.36 98.43,29.36 96.82,27.74 96.82,26.84 95.95,25.97 94.2,25.97 93.34,25.11 89.87,25.11 88.71,23.95 88.72,23.95 88.19,23.42 87.49,23.42 85.96,21.9 84.78,21.9 82.94,20.06 80.01,20.06 76.46,16.51 69.02,16.51 66.73,14.22 60.86,14.22 58.86,16.22 58.13,16.22 56.54,17.81 52.99,17.81 52.3,17.12 48.88,17.12 47.7,18.3 45.67,18.3 44.86,17.5 42.86,17.5 41.52,18.83 40.52,18.83 39.56,17.87 39.05,17.87 35.56,14.38 34.83,14.38 33.86,13.4 33.86,11.32 v2(34.11,11.06)
  BOTTOM w0.109: v2(122.49,38.88) 122.52,38.91 122.81,38.91 123.25,39.34 v1(123.25,39.87) ; v2(34.11,11.06) 33.6,10.56 RZ21.2 32.49,11.39 RZ29.1
I2C1_SCK_TP_R: length 19.3
  TOP w0.109: JKBTP1.19 22.34,3.06 22.34,2.13 22.78,1.7 24.97,1.7 26.57,3.29 v2(26.57,5.25)
  IN2 w0.081: v2(26.57,5.25) 29.31,7.99 29.66,7.99 31.65,9.97 31.65,10.3 31.27,10.68 v2(30.81,10.68)
  BOTTOM w0.109: RZ117.2 31.63,11.37 RZ29.2 30.87,11.42 RZ347.2 30.82,10.7 v2(30.81,10.68) 30.73,10.68 v1(30.33,10.28)
I2C1_SDA_TP: length 115.8
  TOP w0.102: UH1.BF21 123.06,38.6 123.03,38.64 122.81,38.64 122.75,38.61 122.71,38.59 122.58,38.46 122.18,38.46 121.97,38.67 v2(121.97,39.17)
  IN2 w0.081: v2(121.97,39.17) 121.97,39.18 121.97,39.3 121.71,39.55 120.95,39.55 120.84,39.44 118.12,39.44 117.57,39.99 114.44,39.99 113.83,39.37 113.08,39.37 107.99,34.28 104.03,34.28 102.6,32.86 102.6,31.86 102.12,31.38 101.7,31.38 101.28,30.96 101.12,30.96 99.74,29.58 98.33,29.58 96.08,27.33 95.64,27.33 95.35,27.04 95.35,26.6 95.06,26.3 94.21,26.3 94.02,26.11 90.55,26.11 88.09,23.65 86.02,23.65 83.42,21.05 82.44,21.05 81.64,21.85 80.74,21.85 78.81,19.92 78.81,19.22 76.34,16.74 68.93,16.74 66.63,14.45 60.95,14.45 58.95,16.45 58.2,16.45 56.63,18.02 51.93,18.02 51.32,17.42 50.58,17.42 49.41,18.59 45.32,18.59 44.75,18.02 42.63,18.02 41.58,19.06 40.43,19.06 39.46,18.09 38.95,18.09 35.62,14.76 33.85,14.76 32.97,13.88 32.97,10.94 33.98,9.92 v2(34.11,9.92)
  BOTTOM w0.109: v2(34.11,9.92) 33.95,9.76 RZ20.2 32.5,8.93 RZ26.1
I2C1_SDA_TP_R: length 15.7
  TOP w0.109: JKBTP1.18 21.84,4.98 22.49,4.33 24.94,4.33 26.44,5.83 27.53,5.83 29.26,7.56 30.74,7.56 v2(30.94,7.36)
  BOTTOM w0.109: RZ26.2 32.38,8.01 RZ116.2 ; RZ116.2 31.59,8.01 v2(30.94,7.36) 30.63,7.36 v1(30.36,7.09) ; RZ116.2 30.83,8.77 RZ346.2
I2C_ADDR_MUX1: length 3.2
  TOP w0.109: RV849.1 60.45,53.02 v2(60.02,52.59)
  BOTTOM w0.109: UV66.6 59.16,52.12 59.64,52.59 v2(60.02,52.59)
I2C_ADDR_MUX2: length 6.2
  TOP w0.109: RV862.1 72.39,43.74 v1(72.39,44.11) 72.39,45.91 73.87,47.4 UV67.6
I_ADP: length 122.2
  TOP w0.109: UE1.B11 v2(141.21,78.82) ; PR717.1 v2(68.55,29.53)
  IN3 w0.081: v2(141.21,78.82) UE1.B11 138.73,78.45 138.03,77.75 138.03,75.88 137.35,75.2 136.47,75.2 135.86,74.59 134.87,74.59 134.5,74.22 134.5,73.17 134.16,72.83 133.58,72.83 133.22,72.46 128.57,72.46 128.4,72.63 127.43,72.63 126.87,73.19 124.89,73.19 122.58,70.88 121.41,70.88 121.26,70.73 119.91,70.73 117.04,67.86 117.04,67.06 114.77,64.79 114.77,63.89 113.89,63.01 112.92,63.01 112.83,62.92 112.46,62.92 111.99,62.45 111.99,62.27 111.99,60.56 111.52,60.09 111.52,59.8 111.28,59.56 108.79,59.56 103.43,54.2 103.08,54.2 102.08,53.21 100.13,53.21 98.24,51.32 98.24,45.51 97.31,44.58 97.31,36.45 96.66,35.81 96.66,35.01 v2(96.21,34.56)
  IN4 w0.102: v2(96.21,34.56) 95.43,35.34 95.43,38.95 93.88,40.5 90.83,40.5 89.26,38.93 75.68,38.93 74.99,38.24 67.91,38.24 66.55,36.88 66.55,32.41 67.04,31.92 67.04,31.35 68.55,29.83 v2(68.55,29.53)
  BOTTOM w0.109: v2(141.21,78.82) 141.21,78.9 v1(140.88,79.24)
I_BATT: length 96.5
  TOP w0.109: v2(64.89,25.35) 64.89,25.35 PR719.1
  IN2 w0.081: v2(64.89,25.35) 66.2,26.66 66.2,27.36 66.83,27.98 73.18,27.98 73.64,27.52 76.21,27.52 80.43,31.74 84.09,31.74 85.95,33.6 85.95,34.94 86.52,35.51 87.86,35.51 88.7,36.35 90.09,36.35 93.83,40.1 93.83,41.94 97.21,45.32 97.21,50.83 100.31,53.93 102.51,53.93 102.88,54.3 103.97,54.3 107.19,57.52 113.64,57.52 119.67,63.55 124.59,63.55 125.07,64.03 128.68,64.03 129.46,64.81 129.46,65.86 129.76,66.16 129.76,66.49 128.72,67.52 128.72,70.76 128.16,71.31 v2(127.81,71.31)
  BOTTOM w0.109: RE64.2 128.28,71.78 v2(127.81,71.31)
I_BATT_R: length 9
  TOP w0.109: UE1.J4 v2(134.87,72.48)
  BOTTOM w0.109: v2(134.87,72.48) 134.92,72.48 135.27,72.13 135.27,71.47 135.06,71.26 133.91,71.26 133.48,70.84 132.45,70.84 132.04,70.42 131.19,70.42 v1(130.83,70.79) 129.97,71.64 RE64.1 CE3.1
I_SYS: length 348.4
  TOP w0.109: v2(299.11,40.68) 299.29,40.68 299.55,40.95 PU1100.24 ; PR714.1 65.36,24.39 PR723.1 63.1,25.36 63.1,25.76 v2(62.9,25.97)
  IN2 w0.081: v2(127.96,70.45) 127.96,69.71 127.59,69.34 127.59,67.4 128.06,66.92 128.74,66.92 v2(129.22,66.44) 128.4,65.61 127.51,65.61 126.18,64.28 124.99,64.28 124.5,63.78 119.48,63.78 113.37,57.73 107.1,57.73 103.89,54.51 102.8,54.51 102.42,54.14 100.22,54.14 97,50.91 97,45.89 96.77,45.66 96.53,45.42 95.84,45.42 95.56,45.14 95.56,43.97 93.63,42.03 93.63,40.18 90,36.56 88.61,36.56 87.77,35.72 86.44,35.72 85.67,34.95 85.67,33.65 84.15,32.12 80.48,32.12 76.72,28.36 66.37,28.36 65.76,27.75 65.76,27.02 64.71,25.97 v2(62.9,25.97)
  VCC w0.086: v2(299.11,40.68) 299.11,33.95 299.46,33.59 299.46,27.98 298.86,27.38 298.86,18.36 297.82,17.32 296.16,17.32 291.9,13.06 291.9,12.6 291.25,11.96 270,11.96 266.41,15.55 262.11,15.55 260.85,16.81 259.19,16.81 258.43,16.05 245.31,16.05 244.85,16.51 240.56,16.51 240.35,16.73 237,16.73 231.71,11.44 174.73,11.44 174.14,12.04 171.26,12.04 170.66,11.44 165.59,11.44 158.19,18.85 158.19,19.91 162.99,24.72 162.99,27.6 161.85,28.74 161.85,33.74 160.56,35.03 160.56,43.47 v2(158.87,45.15)
  BOTTOM w0.109: v2(127.96,70.45) 128.01,70.45 128.2,70.64 RE312.2 ; v2(299.11,40.68) 299.21,40.58 PR1153.1 ; v2(129.22,66.44) 129.36,66.44 129.44,66.36 135.36,66.36 136.4,65.32 138.04,65.32 138.77,64.59 141.63,64.59 145.26,60.95 145.26,60.75 146.4,59.62 148.77,59.62 150.03,58.36 151.91,58.36 153.36,56.91 154.58,56.91 158.01,53.48 v1(158.01,48.29) 158.01,46.02 v2(158.87,45.15)
I_SYS_R: length 11.3
  TOP w0.109: UE1.J5 v2(135.67,72.48)
  BOTTOM w0.109: RE313.1 CE4.1 RE312.1 130.38,70.64 131.07,69.95 131.43,69.95 131.61,69.77 v1(131.77,69.77) 132.83,69.77 132.92,69.69 133.68,69.69 134.5,70.5 135.02,70.5 135.29,70.78 135.29,71.03 135.57,71.3 135.82,71.3 136.04,71.52 136.04,72.1 v2(135.67,72.48)
ILIM_1PH: length 3.6
  TOP w0.203: PC1100.2 PR1116.2 307.98,44.29 v1(307.46,44.29) 306.92,43.75 PU1100.49
ILIM_2PH: length 3.7
  TOP w0.203: 302.71,37.48 302.75,37.51 PU1100.32
  TOP w0.254: PR1139.1 v1(302.54,36.97) 302.54,37.3 302.71,37.48
ILIM_4PH: length 3
  TOP w0.152: PR1138.2 303.15,47.61 v2(303.15,47.07) PU1100.7
  BOTTOM w0.152: v1(303.67,47.5) 303.24,47.07 v2(303.15,47.07)
ILIM_CHG: length 6.7
  TOP w0.203: PQ704.1 74.4,18.18 PR726.1 74.65,18.9 PR720.2 74.44,19.38 v1(73.68,19.38) 73.53,19.38 73.23,19.69 73.23,20.23 72.74,20.72 71.43,20.72 71.28,20.87 PU700.21
ILIM_SEL1: length 3.9
  TOP w0.109: RI13.1 384.63,56.43 v1(384.63,55.39)
  TOP w0.254: UI1.4 384.39,58.17 384.5,58.05 384.83,58.05 385.14,57.75 385.14,56.99 RI13.1
ILIM_SEL2: length 3.6
  TOP w0.109: v1(378.09,36.77) 378.62,36.24 378.62,35.82 RI67.1
  TOP w0.254: UI2.4 380.34,35.47 380.06,35.19 379.25,35.19 RI67.1
ILIM_SEL3: length 2.8
  TOP w0.203: RI82.1 118.11,148.15 118.15,148.18 v1(118.15,148.18) 118.15,148.61 117.54,149.23 UI3.4
IMON_1PH: length 3.7
  TOP w0.203: PU1100.46 307.43,42.55 v2(307.54,42.44)
  BOTTOM w0.109: v2(307.54,42.44) 307.73,42.44 v1(308.09,42.8)
  BOTTOM w0.203: v2(307.54,42.44) PC1106.2 306.87,43.28 PR1112.2
IMVP_VR_ON: length 227.1
  TOP w0.109: PR1198.2 v2(309.97,41.13)
  IN2 w0.081: v2(156.28,56.28) 156.28,54.56 160.95,49.9 160.95,47.83 165.07,43.71 165.07,42.53 166.34,41.26 166.34,24.48 167.64,23.18 167.64,17.61 172.27,12.97 174.05,12.97 176.17,10.86 213.37,10.86 214.99,12.47 230.54,12.47 230.98,12.03 233.43,12.03 237.75,16.35 241.53,16.35 241.91,16.74 241.91,17.27 243.2,18.56 246.96,18.56 247.93,17.59 255.51,17.59 257.28,15.81 258.03,15.81 259.27,14.57 262.91,14.57 266.31,11.18 290.81,11.18 294.84,15.21 301.97,15.21 311.2,24.43 311.2,35.24 310.97,35.47 310.97,39.89 309.97,40.9 v2(309.97,41.13)
  BOTTOM w0.109: UE4.2 153.75,61.34 UE3.4 154.77,60.33 RE304.1 154.77,59.27 v1(155.5,58.54) 156.28,57.75 v2(156.28,56.28)
IMVP_VR_ON_EC: length 35.4
  TOP w0.109: UE1.N7 137.64,69.13 v2(137.23,68.72) ; v2(148.64,69.13) 151.25,69.13 151.41,68.97 151.41,68.61 153.51,66.51 153.51,62.41 v1(154.24,61.68) 155.29,60.63 v2(155.29,60.61)
  IN1 w0.102: v2(137.23,68.72) 137.07,68.72 136.65,68.3 136.65,67.93 136.95,67.63 137.31,67.63 138.06,66.88 139.34,66.88 139.52,66.7 139.52,65.48 140.03,64.98 142.35,64.98 145.85,68.48 146.8,68.48 147.44,69.13 v2(148.64,69.13)
  BOTTOM w0.109: v2(137.23,68.72) 137.88,68.07 RE737.2 ; RE304.2 155.68,60.22 v2(155.29,60.61) 154.91,60.99 154.91,61.51 155.4,61.99 UE3.1
INT_SPK_L+: length 45.9
  IN4 w1.016: 346.64,20.96 346.64,19.42 349.99,16.07 356.15,16.07 356.71,16.63 370.23,16.63 371.35,15.5 375.32,15.5 378.41,18.59 378.41,21.21 379.28,22.09 382.25,22.09 382.81,22.65 382.81,24.23
  vias: v1(346.52,23.26) v2(346.09,22.58) v2(346.66,22.75) v2(381.89,28.6) v2(381.92,29.2)
INT_SPK_L-: length 46.4
  IN4 w1.016: 380.82,25.41 380.69,25.29 380.69,24.65 380.08,24.04 378.69,24.04 377.26,22.62 377.26,19.06 374.85,16.65 371.83,16.65 370.7,17.77 356.23,17.77 355.67,17.21 351.49,17.21 349.7,19 349.7,21.29 347.18,23.81 345.72,23.81 345.44,23.54
  vias: v1(345.18,23.14) v2(344.83,22.77) v2(345.4,22.58) v2(381.3,28.77) v2(381.31,28.01)
INT_SPK_R+: length 27
  IN2 w1.016: 376.74,26.09 375.07,26.09 374.22,26.94 358.04,26.94 357.97,27.01 352.34,27.01 351.23,25.9 351.23,25.26
  vias: v1(350.38,22.99) v2(350.66,23.42) v2(351,23.9) v2(379.89,27.61) v2(380.34,27.15)
INT_SPK_R-: length 31.4
  IN2 w1.016: 350.07,25.72 350.07,26.36 351.86,28.15 372.72,28.15 373.54,28.97 376.92,28.97 377.07,28.82 379.73,28.82
  vias: v1(348.9,23.12) v2(349.58,23.33) v2(350.01,23.87) v2(380.34,28.04) v2(380.78,27.61)
INT_SPKR_L+: length 13.6
  TOP w0.109: JSPK1.1 342.1,4.66 v4(341.36,3.93)
  IN1 w1.016: 346.02,4.83 346.47,5.27 346.47,15.25 347.1,15.89
  vias: v2(344.52,4.55) v2(345.12,4.6) v2(346.81,17.24) v2(347.39,17.24)
INT_SPKR_L-: length 11
  TOP w0.109: JSPK1.2 v4(341.46,5.91)
  IN1 w1.016: 344.96,16.13 344.96,6.87
  vias: v2(344.4,5.92) v2(344.51,16.93) v2(344.98,17.29) v2(344.98,5.92)
INT_SPKR_R+: length 8.8
  TOP w1.016: 344.89,7.08 345.37,7.08 350.78,12.5 350.78,13.15
  vias: v4(351.36,20.23)
INT_SPKR_R-: length 7.1
  TOP w0.109: v4(347.6,20.37) 347.97,20.37 348.17,20.17
  TOP w1.016: 349.37,13.38 349.37,12.7 345.31,8.64
IR_CAM_DET#: length 114.8
  TOP w0.102: UH1.BD16 124.27,41.54 123.86,41.54 123.74,41.43 123.42,41.43 123.18,41.67 121.42,41.67 120.51,40.76 118.77,40.76 118.67,40.86
  TOP w0.109: JIR1.1 114.55,130.52 113.01,128.98 113.01,128.32 v2(112.47,127.78) ; v2(113.51,40.21) 115.18,40.21 115.33,40.06 116.09,40.06 116.27,40.24 117.16,40.24 RH373.1 117.82,40.9 118.63,40.9 118.67,40.86
  IN1 w0.102: v2(112.47,127.78) 110.28,125.59 110.28,114.5 108.68,112.91 108.68,107.15 110.47,105.36 110.47,96.63 110.75,96.35 111.82,96.35 113.19,94.98 113.19,91.44 115.43,89.21 115.43,85.63 113.76,83.96 113.76,76.75 112.17,75.16 112.17,71.42 111.44,70.69 111.44,68.95 110.35,67.86 110.35,63.09 111.38,62.06 111.38,60.71 111.73,60.35 111.73,52.05 113.16,50.63 113.16,44.63 113.34,44.46 113.34,40.39 v2(113.51,40.21)
  BOTTOM w0.109: v1(113.76,39.56) 113.51,39.81 v2(113.51,40.21)
ISH_UART0_CTS#: length 4.6
  TOP w0.109: RZ80.2 120.56,41.18 120.72,41.34 120.72,42.15 120.78,42.21 121.34,42.21 121.73,42.6 122.45,42.6 122.75,42.3 123.21,42.3 123.23,42.32 UH1.BF14
ISH_UART0_RTS#: length 8.8
  TOP w0.109: v2(129.17,40.53) 129.05,40.41 UH1.AR18
  BOTTOM w0.109: v2(129.17,40.53) 129.02,40.38 v1(128.55,40.38) 128.44,40.38 127.72,41.1 127.07,41.1 126.64,41.53 126.06,41.53 125.36,42.23 125.36,42.85 125.5,42.99 125.5,43.36 125.24,43.61 125.01,43.61 124.9,43.73 RZ81.2
ISH_UART0_RXD: length 5
  TOP w0.109: RZ78.2 119.91,39.51 120.34,39.94 120.34,40.04 121.58,41.28 123.02,41.28 123.26,41.04 123.68,41.04 UH1.BE17
ISH_UART0_TXD: length 4.9
  TOP w0.109: RZ79.2 120.31,39.11 120.31,39.53 120.39,39.61 120.49,39.76 120.6,40.02 121.66,41.08 122.94,41.08 123.18,40.84 123.36,40.84 UH1.BF17
IST_TRIG: length 8.8
  TOP w0.109: T3.1 232.52,72.58 232.52,69.99 231.61,69.08 231.61,67.21 231.7,67.12 231.7,66.46 232.65,65.51 UC1.E3
ITP_PMODE_CPU: length 245.4
  TOP w0.102: UH1.AL3 130.59,47.65 130.59,48.08 130.8,48.29 130.8,50.11 130.4,50.51 129.73,50.51 129.61,50.62 129.61,51.15 130.17,51.7
  TOP w0.109: v2(263.55,6.57) 263.55,7.41 263.46,7.5 262.32,7.5 261.58,8.24 261.58,8.76 255.08,15.27 250.66,15.27 249.54,16.38 249.54,17 247.01,19.54 v1(247.01,21.95) 246.78,22.18 246.31,22.18 245.8,22.68 245.8,23.56 v2(245.72,23.64) ; 130.17,51.7 v2(130.17,52.6)
  IN3 w0.081: v2(263.55,6.57) 263.54,6.57 263.13,6.16 262.86,6.16 261.77,5.07 256.33,5.07 253.8,7.59 247.25,7.59 242.58,2.92 167.5,2.92 166.46,3.96 157.65,3.96 153.97,7.65 148.98,7.65 147.42,9.2 138.41,9.2 137.55,10.06 135.16,10.06 133.6,8.5 132.66,8.5 132.18,8.98 132.18,10.35 131.87,10.66 130.16,10.66 129.12,11.7 128.46,11.7 127.95,12.21 124.3,12.21 122.75,10.66 121.13,10.66 119.73,12.05 119.73,13.3 118.18,14.85 118.18,17.06 117.85,17.4 117.85,20 115.77,22.07 115.77,22.94 116.51,23.68 116.51,25.54 114.58,27.47 114.58,28.14 116.02,29.58 116.25,29.58 117.06,30.38 117.06,30.93 117.5,31.37 117.5,35.78 117.94,36.23 118.43,36.23 118.79,36.59 118.79,37.28 119.12,37.61 119.12,44.75 119.75,45.38 119.75,47.82 123.41,51.48 123.89,51.48 125.6,53.19 127.41,53.19 128,52.6 v2(130.17,52.6)
  BOTTOM w0.109: v2(245.72,23.64) 245.06,23.64 244.23,22.81 RC144.2
JDIMM1_EVENT#: length 31.3
  IN3 w0.081: v2(169,51.65) 169.02,51.63 169.53,51.63 169.89,51.26 169.89,50.29 168.88,49.27 168.88,47.09 169.2,46.76 175.09,46.76 175.23,46.9 181.67,46.9 v2(183.17,48.41)
  BOTTOM w0.109: RD7.1 163.09,57.29 v1(164.01,56.38) 166.97,53.42 166.97,52.4 167.51,51.86 168.79,51.86 v2(169,51.65) ; JDIMM1.134 182.6,48.98 v2(183.17,48.41)
JDIMM2_EVENT#: length 22.4
  TOP w0.109: JDIMM2.134 169.57,48.98 166.95,46.37 163.27,46.37 162.51,47.13 162.51,49.32 v2(163.22,50.03)
  BOTTOM w0.109: v2(163.22,50.03) 163.08,50.17 v1(163.08,55.3) 163.08,56.42 RD21.1
JDIMM3_EVENT#: length 44
  IN3 w0.081: v2(197.27,48.83) 190.72,48.83 190.31,49.24 176.14,49.24 175.85,48.95 173.3,48.95 171.99,47.64 169.74,47.64 v2(169.36,48.02)
  BOTTOM w0.102: v2(197.27,48.83) 197.27,48.86 197.17,48.96 195.61,48.96 JDIMM3.134
  BOTTOM w0.109: v2(169.36,48.02) 167.83,49.56 166.52,49.56 166.09,49.12 162.76,49.12 162.13,49.76 v1(162.13,53.56) RD29.1
JDIMM4_EVENT#: length 33.5
  TOP w0.109: JDIMM4.134 186.52,48.98 186.18,48.63 186.18,48.58 v2(186.03,48.43)
  IN3 w0.081: v2(169.36,47.44) 169.81,46.99 171.8,46.99 172.4,47.59 173.46,48.65 175.87,48.65 176.19,48.96 185.31,48.96 185.84,48.43 v2(186.03,48.43)
  BOTTOM w0.109: v2(169.36,47.44) 168.57,48.23 167.4,48.23 166.75,48.89 162.23,48.89 161.36,49.76 v1(161.36,52.19) RD45.1
JTAG_CLK: length 51.1
  TOP w0.109: UE1.C8 v2(138.81,78.02)
  IN3 w0.081: v2(138.81,78.02) 138.31,77.52 138.31,75.92 137.36,74.97 136.85,74.97 136.03,74.15 136.03,73.94 135.8,73.71 135.59,73.71 135.28,73.4 135.28,73.12 135.07,72.91 134.8,72.91 134.44,72.56 134.44,72.35 134.14,72.04 130.4,72.04 130.16,71.81 127.54,71.81 126.99,72.37 124.42,72.37 122.7,70.65 121.5,70.65 121.35,70.5 119.98,70.5 117.26,67.78 117.26,66.99 114.98,64.7 114.98,63.81 113.97,62.8 113.03,62.8 112.94,62.71 112.55,62.71 112.19,62.36 112.19,60.46 111.85,60.11 111.85,59.83 111.18,59.17 v2(111.16,59.17)
  BOTTOM w0.109: v2(138.81,78.02) 138.33,78.02 v4(138.12,78.23) ; RE740.2 116.53,60.72 116.17,60.36 116.17,59.27 115.54,58.64 114.66,58.64 112.83,56.81 JDEG1.4 111.94,56.81 111.33,57.41 111.33,58.99 v2(111.16,59.17)
JTAG_RST#: length 12.5
  TOP w0.109: UE1.G13 142.61,74.45 143.47,73.59 RE65.1 RE63.1 v1(146.68,73.59) 146.76,73.59 v2(147.25,73.09)
  BOTTOM w0.109: v2(147.25,73.09) 147.32,73.09 148.5,74.27 150.68,74.27 151.79,73.17 JTAG1.1 152.25,74.28 CE30.1
JTAG_TDI: length 44.6
  TOP w0.109: UE1.E9 v2(139.64,76.45)
  IN3 w0.081: v2(139.64,76.45) 139.22,76.03 139.22,75.46 138.99,75.23 138.16,75.23 137.67,74.74 137.23,74.74 136.9,74.41 136.9,69.91 135.95,68.96 135.95,68.5 135.07,67.63 133.12,67.63 132.85,67.35 132.13,67.35 131.27,66.49 130.46,66.49 130.12,66.84 129.05,66.84 128.58,66.37 127.69,66.37 126.93,67.13 122.7,67.13 122.57,67 121.66,67 121.18,66.52 121.18,66.21 119.8,64.83 117.97,64.83 116.85,63.71 116.85,62.68 v2(116.23,62.05)
  BOTTOM w0.109: v2(139.64,76.45) 139.63,76.45 v1(139.2,76.88) ; RE742.2 116.55,62.37 v2(116.23,62.05) 115.27,61.09 112.94,61.09 112.83,60.99 112.83,59.26 113.27,58.83 113.27,58 113.08,57.81 JDEG1.2
JTAG_TDO: length 47.1
  TOP w0.109: UE1.F6 v2(136.47,75.62)
  IN3 w0.081: v2(136.47,75.62) 135.62,74.78 133.5,74.78 132.94,74.23 130.84,74.23 129.7,73.09 127.68,73.09 126.89,73.89 126.12,73.89 125.75,74.25 125.36,74.25 122.22,71.11 121.31,71.11 121.16,70.96 119.84,70.96 116.83,67.95 116.83,67.62 114.15,64.94 113.83,64.94 112.58,63.69 112.17,63.69 111.75,63.27 111.75,60.76 v2(110.95,59.96)
  BOTTOM w0.109: v2(136.47,75.62) 136.47,75.4 v4(136.76,75.1) ; v2(110.95,59.96) 110.75,59.76 110.75,58.99 111,58.75 111,57.25 111.94,56.31 JDEG1.5 112.95,56.31 115.04,58.4 115.64,58.4 116.41,59.17 116.41,59.77 116.53,59.9 RE739.2
JTAG_TMS: length 48.3
  TOP w0.109: UE1.C5 v2(135.66,78.02)
  IN3 w0.081: v2(110.49,61.46) 110.06,61.89 110.06,64.1 110.49,64.54 110.49,65.27 112.15,66.92 113.26,66.92 113.53,67.19 113.64,67.19 115.64,69.2 115.64,69.45 116.32,70.12 117.48,70.12 118.89,71.54 118.89,72.21 122.01,75.33 123.03,75.33 123.73,76.03 126.23,76.03 127.12,76.93 129.94,76.93 130.3,77.28 133.3,77.28 133.65,77.64 135.28,77.64 v2(135.66,78.02)
  BOTTOM w0.109: RE741.2 116.89,61.55 115.94,60.59 115.94,59.37 115.44,58.87 114.56,58.87 113,57.31 JDEG1.3 111.82,57.31 111.57,57.56 111.57,59.35 111.39,59.53 111.39,60.21 110.49,61.11 v2(110.49,61.46)
KB_DET#: length 146.1
  TOP w0.109: UH1.AW15 126.76,40.92 v2(127.05,40.63) ; JKBTP1.1 v2(13.34,1.51)
  IN2 w0.081: v2(20.05,4.19) 20.05,5.06 20.37,5.38 20.37,7.53 20.57,7.74 21,7.74 24.18,10.91 25.45,10.91 26.11,11.57 28.97,11.57 30.55,13.16 30.55,15.53 32.05,17.03 36.08,17.03 37.37,18.32 39.37,18.32 40.34,19.29 41.79,19.29 42.83,18.25 44.69,18.25 45.23,18.8 49.49,18.8 50.66,17.62 51.24,17.62 51.84,18.23 56.71,18.23 58.26,16.68 59.08,16.68 61.08,14.68 66.54,14.68 68.83,16.97 76.24,16.97 78.59,19.31 78.59,20.02 80.64,22.08 81.73,22.08 82.54,21.27 83.32,21.27 85.93,23.88 87.97,23.88 90.43,26.34 93.92,26.34 95.42,27.84 95.87,27.84 98.1,30.07 99.57,30.07 100.93,31.42 101.09,31.42 101.51,31.84 101.99,31.84 102.18,32.03 102.18,33.03 103.86,34.7 107.82,34.7 112.93,39.81 113.67,39.81 114.26,40.4 117.77,40.4 118.1,40.73 120.04,40.73 120.37,40.4 121.33,40.4 121.42,40.32 v2(121.42,40.32)
  IN3 w0.102: v2(13.34,1.51) 13.34,1.98 13.85,2.49 18.69,2.49 19.05,2.84 19.05,3.1 20.05,4.1 v2(20.05,4.19)
  BOTTOM w0.109: v2(13.34,1.51) 13.2,1.37 v1(12.85,1.37) ; v2(127.05,40.63) 126.36,40.63 125.28,41.07 125.08,41.07 124.77,41.39 124.04,41.39 123.73,41.07 121.83,41.07 121.45,40.69 121.45,40.34 v2(121.42,40.32) 121.42,40.32 120.51,41.23 RC74.2
LAN_ACTLED_YEL#: length 20
  TOP w0.109: UL1.26 149.57,141.63 149.43,141.77 149.43,142.48 149.02,142.89 140.22,142.89 v1(138.82,144.29) 136.28,146.83 134.5,146.83 133.82,147.51 QL1.1
LAN_ACTLED_YEL#_Q: length 14.2
  TOP w0.109: QL1.6 133.82,145.73 v2(133.87,145.68)
  BOTTOM w0.109: v2(133.87,145.68) 133.8,145.75 133.8,154.48 v1(135.98,156.66) RL14.1
LAN_DISABLE#_R: length 4.6
  TOP w0.109: v2(157.17,138.25) 156.99,138.43 UL1.3
  BOTTOM w0.109: v2(157.17,138.25) v1(157.63,137.79) RL5.2 158.84,137.01 RL9.1 158.83,136.24 RL7.2
LAN_MDIN0: length 4.5
  TOP w0.109: RL72.1 157.11,145.47 157.11,145.19 156.74,144.82 156.1,144.17 v3(155.75,144.17) 155.36,144.17 154.92,143.73 154.92,143.34 154.98,143.28 UL1.14
LAN_MDIN0_L: length 38.8
  TOP w0.109: RL72.2 157.14,147.1 157.14,147.98 v2(157.04,148.07)
  IN2 w0.081: v2(170.12,171.49) 170.12,171.94 170.23,172.05 170.53,172.05 170.76,171.82 170.76,170.1 170.53,169.86 168.75,169.86 167.18,168.29 167.18,153.61 163.88,150.31 158.49,150.31 157.2,149.02 157.2,148.23 v2(157.04,148.07)
  BOTTOM w0.109: TL1.2 169.02,171.46 169.54,171.99 169.93,171.99 170.12,171.8 v2(170.12,171.49)
LAN_MDIN1: length 3.5
  TOP w0.109: RL74.1 154.61,144.81 154.61,144.67 154.48,144.54 153.8,144.54 153.32,144.06 153.32,143.56 153.38,143.5 UL1.18
LAN_MDIN1_L: length 36.3
  TOP w0.109: v2(154.53,147.39) 154.62,147.29 154.62,146.42 RL74.2
  IN1 w0.102: v2(170.13,166.51) 168.4,166.51 167.99,166.1 167.99,153.22 161.72,146.95 157.84,146.95 156.74,145.86 155.14,145.86 154.61,146.4 154.61,147.31 v2(154.53,147.39)
  BOTTOM w0.109: 168.35,166.38 169.19,166.38 169.39,166.59 170.05,166.59 v2(170.13,166.51)
LAN_MDIN2: length 2.6
  TOP w0.109: UL1.21 152.18,143.5 152.12,143.56 v3(152.12,144.02) 152.12,144.76 RL76.1
LAN_MDIN2_L: length 36.8
  TOP w0.109: RL76.2 152.1,146.44 152.1,147.23 v2(152,147.33)
  IN2 w0.081: v2(170.12,163.9) 170.07,163.95 169.24,163.95 169.16,163.87 169.16,157.6 169.72,157.04 169.72,153.35 163.07,146.7 157.2,146.7 156.52,146.01 152.65,146.01 152.08,146.58 152.08,147.25 v2(152,147.33)
  BOTTOM w0.109: v2(170.12,163.9) 169.97,164.04 169.07,164.04 168.88,163.84 168.35,163.84
LAN_MDIN3: length 3.4
  TOP w0.109: UL1.24 150.98,143.32 150.86,143.44 150.86,143.49 150.76,143.59 150.27,143.59 v3(149.91,143.95) 149.58,144.29 149.58,144.76 RL78.1
LAN_MDIN3_L: length 36
  TOP w0.109: v2(149.49,147.55) 149.49,146.37 RL78.2
  IN1 w0.102: v2(149.49,147.55) 149.49,146.58 151.4,144.67 157.33,144.67 158.44,145.79 162.54,145.79 169.6,152.85 169.6,158.9 169.74,159.04 v2(170.42,159.04)
  BOTTOM w0.109: 168.35,158.76 169.21,158.76 169.49,159.04 v2(170.42,159.04)
LAN_MDIP0: length 4.6
  TOP w0.109: UL1.13 155.38,143.25 155.44,143.31 155.44,143.52 155.58,143.66 156.31,143.66 v3(157.11,144.45) 157.32,144.66 157.63,144.97 157.63,145.41 RL71.1
LAN_MDIP0_L: length 38.7
  TOP w0.109: v2(157.76,148.07) 157.65,147.96 157.65,147.12 RL71.2
  IN2 w0.081: v2(157.76,148.07) 157.74,148.09 157.74,148.8 158.71,149.77 164.1,149.77 167.72,153.39 167.72,168.07 168.98,169.33 170.75,169.33 171.3,169.87 171.3,172.04 170.76,172.59 170.24,172.59 v2(170.12,172.71)
  BOTTOM w0.109: v2(170.12,172.71) 169.91,172.51 169.25,172.51 169.02,172.73 TL1.1
LAN_MDIP1: length 3.5
  TOP w0.109: UL1.17 153.78,143.5 153.84,143.56 153.84,143.85 154.02,144.03 v3(154.33,144.03) 154.69,144.03 155.12,144.45 155.12,144.74 RL73.1
LAN_MDIP1_L: length 36.2
  TOP w0.109: RL73.2 155.13,146.47 155.13,147.28 v2(155.24,147.39)
  IN1 w0.102: v2(170.12,167.56) 170.12,167.25 169.94,167.07 168.17,167.07 167.43,166.33 167.43,153.46 161.49,147.51 157.6,147.51 156.51,146.42 155.37,146.42 155.16,146.63 155.16,147.31 v2(155.24,147.39)
  BOTTOM w0.109: v2(170.12,167.56) 170.12,167.19 170.03,167.1 169.6,167.1 169.05,167.65 TL1.5
LAN_MDIP2: length 2.5
  TOP w0.109: RL75.1 152.64,144.79 152.64,143.56 152.58,143.5 UL1.20
LAN_MDIP2_L: length 36.9
  TOP w0.109: v2(152.72,147.33) 152.62,147.23 152.62,146.44 RL75.2
  IN2 w0.081: v2(152.72,147.33) 152.62,147.23 152.62,146.81 152.87,146.55 156.29,146.55 156.98,147.24 162.84,147.24 169.18,153.58 169.18,156.81 168.62,157.37 168.62,164.09 169.02,164.49 169.93,164.49 170.12,164.68 v2(170.12,165.06)
  BOTTOM w0.109: v2(170.12,165.06) 170.12,164.65 170.03,164.56 169.5,164.56 168.94,165.11 TL1.7
LAN_MDIP3: length 3.3
  TOP w0.109: UL1.23 151.38,143.71 150.98,144.11 150.49,144.11 150.09,144.5 150.09,144.79 RL77.1
LAN_MDIP3_L: length 36
  TOP w0.109: v2(150.21,147.55) 150.01,147.35 150.01,146.52 RL77.2
  IN1 w0.102: v2(170.42,159.94) 170.42,159.68 170.34,159.6 169.51,159.6 169.04,159.13 169.04,153.08 162.3,146.34 158.21,146.34 157.09,145.23 151.63,145.23 150.05,146.81 150.05,147.4 v2(150.21,147.55)
  BOTTOM w0.109: TL1.11 169.37,160.03 169.85,159.56 170.3,159.56 170.42,159.68 v2(170.42,159.94)
LAN_TEST_EN: length 3
  TOP w0.109: v1(147.83,140.78) 147.83,140.59 148.58,139.83 RL12.1 148.88,140.03 UL1.30
LAN_WAKE#: length 243.2
  TOP w0.109: UH1.BG44 122.72,27.33 122.37,26.98 122.37,26.61 121.2,25.44 120.3,25.44 119.88,25.85 115.74,25.85 RH93.1 115.26,25.12 115.09,24.95 113.27,24.95 v2(112.63,25.59) ; v2(161.73,134.83) 161.53,135.03 v1(160.94,135.03) 160,135.03 RL10.1 ; UE1.L3 v2(134.05,70.86)
  IN1 w0.102: v2(161.73,134.83) 158.83,137.73 157.53,137.73 157.02,137.23 150.87,137.23 149.95,138.15 149.95,140.95 149.69,141.22 149.69,144.56 149.05,145.2 146.89,145.2 144.19,147.91 138.26,147.91 131.42,154.75 112.21,154.75 111.33,153.87 111.33,138.53 112.88,136.98 112.88,130 109.83,126.95 109.83,114.69 107.56,112.43 107.56,98.49 110.21,95.85 111.67,95.85 112.74,94.79 112.74,91.26 114.97,89.02 114.97,85.82 113.17,84.01 113.17,76.93 111.5,75.26 v2(111.5,71.98) 110.98,71.46 110.98,69.14 108.68,66.84 108.68,64.31 109.15,63.84 109.15,57.81 110.28,56.68 110.28,51.49 111.74,50.04 111.74,42.03 111.55,41.84 111.55,39.69 111.91,39.33 111.91,34.96 113.45,33.42 113.45,31.54 113.77,31.23 113.77,29.72 113.01,28.96 113.01,27.86 112.59,27.45 112.59,25.63 v2(112.63,25.59)
  IN4 w0.102: v2(134.05,70.86) 132.44,70.86 132.15,70.57 131.67,70.57 130.52,71.72 127.64,71.72 126.82,70.9 126.24,70.9 125.17,71.97 120.63,71.97 120.02,71.36 119.33,71.36 118.79,71.9 117.05,71.9 116.51,71.36 112.11,71.36 v2(111.5,71.98)
LCD_CBL_DET#: length 102
  TOP w0.102: v2(126.9,37.94) 126.9,37.35 UH1.AW24
  TOP w0.109: JEDP1.20 122.7,119.65 122.64,119.71 122.64,121.49 v2(122.64,121.49)
  IN1 w0.102: v2(126.9,37.94) 126.9,38.14 126.59,38.45 126.59,39.94 126.05,40.48 125.55,40.48 124.21,41.82 124.21,43.02 123.82,43.41 123.82,45.66 123.03,46.45 123.03,47.19 123.47,47.63 123.47,52.34 123.31,52.49 123.31,53.66 123.63,53.98 123.63,54.71 122.45,55.89 122.45,60.07 121.74,60.78 121.74,61.48 121.89,61.63 121.89,65.72 120.95,66.66 120.95,68.6 121.23,68.88 121.23,69.73 120.58,70.37 120.58,72.26 119.38,73.47 119.38,76.74 118.84,77.27 118.84,81.18 119.15,81.48 119.15,84.26 117.71,85.69 117.71,97.11 116.56,98.26 115.57,98.26 113.58,100.26 113.58,102.29 114.37,103.09 114.37,105.06 114.87,105.56 114.87,114.3 117.01,116.45 117.01,117.95 117.81,118.75 117.81,120.5 118.94,121.63 122.5,121.63 v2(122.64,121.49)
  BOTTOM w0.109: v2(126.9,37.94) 126.46,38.37 RC370.1 ; v1(122.04,121.63) 122.5,121.63 v2(122.64,121.49)
LCD_TST: length 63.6
  TOP w0.109: JEDP1.24 124.7,117.87 v2(124.65,117.82) ; RE20.1 131.34,66.79 131.34,67.76 131.74,68.16 132.1,68.16 133.25,69.31 v2(133.25,70.06) UE1.M2
  IN1 w0.102: v2(133.25,70.06) 133.25,69.49 132.65,68.89 132.23,68.89 131.91,69.21 131.91,70.33 131.52,70.73 131.52,71.06 131.75,71.29 131.75,72.35 130.62,73.47 130.62,75.76 130.35,76.03 130.35,84 131.7,85.35 131.7,87.04 130.86,87.87 130.86,95.69 130.25,96.3 130.25,97.54 124.23,103.56 124.23,107.49 123.03,108.68 123.03,116.11 124.65,117.73 v2(124.65,117.82)
  BOTTOM w0.109: v2(124.65,117.82) 124.65,118.04 v1(124.94,118.33)
LCD_VCC_TEST_EN: length 98
  TOP w0.109: DV3.2 v1(122.96,143.89) 123.98,143.89 124.79,143.08 128.34,143.08 134.95,136.48 135.77,136.48 136.79,135.46 136.79,133.17 v2(136.34,132.73) ; v2(132.3,76.03) 132.32,76.05 UE1.E1
  IN1 w0.102: v2(136.34,132.73) 132.73,129.11 132.73,119.42 134.21,117.93 134.21,114.91 134.86,114.26 140.92,114.26 141.37,113.81 141.37,111.18 141.88,110.67 141.88,105.53 143.03,104.38 143.03,99.32 140.8,97.09 138.54,97.09 137.72,96.27 137.72,94.5 137.36,94.15 137.36,92.03 133.56,88.22 133.56,81.88 131.96,80.28 131.58,80.28 131.26,79.96 131.26,79.26 132.74,77.79 132.74,76.47 v2(132.3,76.03)
LDO_IN: length 20.7
  TOP w0.381: DT60.1 48.38,25.2 v2(48.38,24.35) 48.38,24.11 48.69,23.81 DT63.1 DT64.1 47.78,23.83 47.78,24.74 47.43,25.08 DT62.1
  TOP w0.508: UT7.1 48.72,16.51 47.89,17.34 47.89,18.88 47.94,18.93 RT543.1 48.35,20 48.35,20.41 CT374.1 49.01,20.59 49.31,20.28 49.31,19.31 v2(49.43,19.19)
  IN3 w0.381: v2(49.43,19.19) 49.27,19.19 47.42,21.05 47.42,23.01 48.38,23.98 v2(48.38,24.35)
  BOTTOM w0.109: v2(49.43,19.19) 49.12,19.19 v1(48.74,19.57)
LED_10_GRN#: length 23.1
  TOP w0.109: 131.5,144.54 132.59,144.54 QL7.3 133.36,142.65 RL30.2 135.47,140.51 144.49,140.51 146.41,142.43 v2(148.63,142.43) ; UL1.25 150.36,142.16 v2(150.36,142.92)
  BOTTOM w0.109: v2(150.36,142.92) v1(149.74,142.92) 149.11,142.92 v2(148.63,142.43)
LED_10_GRN#_Q: length 5.7
  TOP w0.109: v2(135.2,145.3) 135.26,145.24 QL7.1 ; RL19.1 v2(134.82,149.24)
  BOTTOM w0.109: v2(134.82,149.24) 134.82,148.99 135.2,148.6 v1(135.2,147.12) v2(135.2,145.3)
LED_100_ORG#: length 26.1
  TOP w0.109: UL1.27 145.55,141.23 144.59,140.27 134.15,140.27 v1(131.99,142.43) 131.5,142.92 UL2.1 130.9,143.89 130.63,144.16 130.63,145.81 131.21,146.4 RL29.2 131.45,146.69 QL1.4
LED_100_ORG#_Q: length 2.7
  TOP w0.109: QL1.3 132.52,149.1 v1(132.99,149.57) 133.35,149.93 RL20.1
LED_MASK#: length 416.4
  TOP w0.109: v2(388.82,8.37) 389.18,8.37 389.47,8.67 UZ10.1 ; UE1.A12 142.54,80.15 143.82,80.15 v2(144.06,79.92) 144.28,80.14 RE21.1 ; v2(134.38,145.06) QL7.2 133.36,146.19 133.17,146.39 QL1.5 QL1.2
  IN1 w0.102: v2(144.06,79.92) 145.31,79.92 146.38,80.98 146.38,82.82 145.92,83.28 145.92,85.14 147.14,86.36 147.14,99.13 147.98,99.96 147.98,102.52 148.56,103.1 148.56,103.82 144.77,107.62 144.77,110.88 145.65,111.77 145.65,114.06 146.46,114.87 146.46,116.14 145.91,116.69 145.91,117.45 146.46,118 146.46,130.87 144.79,132.54 144.79,136.66 146.27,138.13 146.27,140.1 142.97,143.4 140.15,143.4 138.88,144.67 134.77,144.67 v2(134.38,145.06)
  IN2 w0.081: v2(144.06,79.92) 145.87,78.1 145.87,71.1 146.05,70.92 148.28,70.92 149.05,71.68 151.17,71.68 152.02,72.53 153.49,72.53 154.59,71.43 157.3,71.43 158.39,70.34 158.39,64.72 157.92,64.25 157.92,60.84 158.58,60.19 159.44,60.19 165.05,54.58 v2(165.05,54.19)
  IN3 w0.081: v2(388.82,8.37) 388.82,9.36 388.49,9.69 376.82,9.69 375.61,10.9 375.61,11.42 371.1,15.94 365.44,15.94 365.08,15.58 356.7,15.58 356.55,15.43 349.93,15.43 349.74,15.62 346.8,15.62 346.07,14.9 345.28,14.9 344.11,13.73 342.11,13.73 341.77,14.07 333.2,14.07 331.97,15.31 320.26,15.31 314.83,9.88 301.41,9.88 300.8,9.26 278.08,9.26 277.04,10.3 270.69,10.3 266.27,14.72 258.54,14.72 257.62,15.64 248.25,15.64 248.14,15.53 240.62,15.53 240.55,15.47 234.13,15.47 228.67,10.01 172,10.01 166.06,15.95 166.06,21.65 164.89,22.81 164.89,26.66 165.41,27.17 165.41,30.42 164.75,31.08 164.75,34.05 160.77,38.03 160.77,42.79 161.59,43.61 161.59,51.06 163.39,52.86 164.81,52.86 165.05,53.1 v2(165.05,54.19)
  BOTTOM w0.109: v2(388.82,8.37) v1(388.82,8.99)
LG_1.2V: length 10.3
  BOTTOM w0.762: 124.43,8.22 122.91,9.74 117.5,9.74 116.28,10.96 115.24,10.96
  vias: v1(114.17,11.31) v2(113.87,10.86) v2(114.5,10.89) v2(125.5,8.14) v2(125.52,7.53)
LG_+1VSP:
  vias: v1(108.87,37.73)
LGATE_CHG: length 33.4
  TOP w0.203: PU700.23 72.54,22.43 73.1,21.87 v2(73.1,21.48)
  IN4 w0.508: 97.56,9.03 97.23,8.7 88.38,8.7 81.77,15.31 76.88,15.31 73.1,19.09 v2(73.1,21.48)
  BOTTOM w0.109: v2(73.1,21.48) v1(73.62,21.48)
  vias: v2(98.1,9) v2(98.82,9)
LID_CL#: length 366.1
  TOP w0.109: v2(370.4,53.13) 370.4,53.13 JPB1.6 ; v2(149.81,59.45) 147.62,61.64 RE26.1 ; 388.82,9.14 388.82,9.51 388.41,9.92 387.58,9.92 386.97,10.53 v4(386.97,12.25) 386.97,12.49 v2(386.59,12.87)
  IN1 w0.102: v2(386.59,12.87) 381.83,12.87 380.76,13.94 380.76,17.46 381.66,18.37 381.66,19.34 380.79,20.21 379.29,20.21 378.09,21.42 378.09,23.92 377.01,25 377.01,27.09 376.39,27.7 376.22,27.7 375.98,27.94 375.98,28.56 377.65,30.23 377.65,36.97 376.72,37.9 376.72,46.81 v2(370.4,53.13) 369.79,53.74 343.99,53.74 340.75,56.97 335.49,56.97 333.32,54.8 331.37,54.8 v2(330.71,54.14)
  VCC w0.086: v2(149.81,59.45) 149.15,58.79 149.15,51.91 159.57,41.49 159.57,34.41 160.23,33.74 160.23,23.38 157.2,20.34 157.2,18.44 165.24,10.41 217.37,10.41 218.01,9.77 220.79,9.77 221.43,10.41 232.07,10.41 237.4,15.74 239.94,15.74 240.16,15.53 244.44,15.53 244.91,15.05 258.87,15.05 259.23,14.7 261.56,14.7 261.77,14.49 265.97,14.49 269.49,10.97 292.13,10.97 293.17,12.01 293.17,12.9 296.53,16.26 298.16,16.26 299.85,17.95 299.85,23 313.37,36.52 315.09,36.52 315.49,36.92 318.29,36.92 319.89,38.52 321.16,38.52 321.64,39 321.64,40.1 326.18,44.64 326.18,46.09 330.08,49.99 330.08,52.6 330.71,53.23 v2(330.71,54.14)
LID_CL#_PCH: length 1.4
  TOP w0.109: UH1.AV34 127.95,32.08 v2(128.16,31.86)
  BOTTOM w0.109: v2(128.16,31.86) 127.72,31.86 T268.1
LID_CL_SIO#: length 10.1
  TOP w0.109: UE1.N11 140.84,69.43 141.44,68.82 141.44,68.13 141.84,67.73 141.84,66.16 142.5,65.5 142.5,64.27 RE25.2 v1(143.98,62.78) 144.22,62.55 CE8.1 RE26.2
LINE1-L: length 6.2
  TOP w0.109: v1(386.85,30.32) CA43.1
  TOP w0.203: UA1.36 385.1,25.21 385.37,25.49 385.37,25.91
  TOP w0.381: 385.37,25.91 385.37,27.11 386.22,27.95 386.22,28.4 386.85,29.04 CA43.1
LINE1-R: length 4.2
  TOP w0.203: 385.91,25.77 385.91,25.52 385.2,24.81 UA1.35
  TOP w0.381: 385.91,25.77 v1(385.91,26.6) 385.91,26.88 CA44.1
LOM_CABLE_DETECT#: length 102.2
  TOP w0.109: UE1.D2 133.2,77.29 132.39,77.29 131.9,77.77 131.9,79.58 v2(131.76,79.72) 131.73,79.68 130.55,79.68 RE505.1 ; v2(129.61,144.54) 129.76,144.69 UL2.4
  IN1 w0.102: v2(129.61,144.54) 130.5,143.65 137.87,143.65 139.71,141.81 142.63,141.81 143.96,140.48 143.96,137.17 141.74,134.95 141.74,133.05 141.3,132.6 139.62,132.6 138.71,131.69 136.53,131.69 134.57,129.73 134.57,115.1 135.11,114.56 141,114.56 141.62,113.93 141.62,111.26 142.11,110.78 142.11,105.63 143.26,104.48 143.26,99.23 140.89,96.87 138.63,96.87 137.95,96.18 137.95,94.41 137.59,94.05 137.59,91.93 133.79,88.13 133.79,81.75 131.76,79.73 v2(131.76,79.72)
LP#_VCCIO:
  vias: v2(308.34,60.63)
LPS_OFF1: length 70.1
  TOP w0.109: PQ1.6 91.1,20.52 PR6.2 91.27,20.6 91.64,20.23 91.64,19.73 v2(91.84,19.52)
  IN2 w0.081: v2(35.61,11.03) 36.11,11.03 36.78,11.7 38.73,11.7 40.58,13.54 41.89,13.54 v2(42.68,12.75) 43.06,12.75 43.91,13.6 47.46,13.6 49.09,11.98 53.06,11.98 53.56,11.47 55.12,11.47 55.5,11.09 59.08,11.09 60.26,12.28 76.56,12.28 82.57,18.28 83.15,18.28 83.48,17.96 89.33,17.96 90.89,19.52 v2(91.84,19.52)
  BOTTOM w0.109: v2(42.68,12.75) 42.65,12.78 PQ2111.6 ; PQ2110.6 33.82,13.06 35.02,11.85 35.02,11.52 35.28,11.27 35.49,11.27 35.61,11.15 v2(35.61,11.03) 35.22,10.63 v1(34.53,10.63)
LPS_OFF2: length 33.3
  TOP w0.254: v2(51.84,31.23) PR31.2 51.9,31.93 52.05,31.93 52.65,31.33 PQ4.6
  IN4 w0.102: v2(51.84,31.23) 51.84,30.99 53.87,28.96 53.87,28.35 54.71,27.51 54.71,25.97 53.93,25.19 53.93,24.15 54.44,23.64 54.44,22.94 54.89,22.5 54.89,18.11 54.35,17.57 54.35,15.55 53.79,15 53.79,13.98 52.75,12.94 v2(47.27,12.94)
  BOTTOM w0.109: PQ2111.3 45.2,11.48 45.48,11.76 46.63,11.76 v1(47.04,12.18) 47.27,12.4 v2(47.27,12.94)
LPS_OFF3: length 43.7
  IN1 w0.102: v2(30.25,22.66) 30.25,20.89 31.54,19.6 37.03,19.6 38.68,21.25 39.49,21.25 40.28,20.46 41.17,20.46 42.4,21.69 42.4,22.34 43.95,23.89 45.16,23.89 45.29,24.02 46.02,24.02 46.58,23.46 49.3,23.46 v2(49.5,23.26)
  BOTTOM w0.109: v2(49.5,23.26) 49.53,23.28 49.53,24.04 49.78,24.3 v1(49.78,24.58) 49.78,25.99 PR48.2 50.16,26.36 50.16,26.69 50.43,26.96 50.43,27.08 50.82,27.47 PQ7.6 ; v2(30.25,22.66) 30.25,21.63 31.65,20.23 31.65,15.24 32.05,14.84 32.05,14.42 32.28,14.19 32.92,14.19 33.5,13.6 34.03,13.6 35.05,12.59 35.05,12.18 35.47,11.76 PQ2110.3
LPS_OFF_BATT: length 77.9
  TOP w0.109: v1(93.75,34.53) 93.75,35.16 v2(93.79,35.19) 93.79,35.76 93.3,36.24 PR734.2
  IN1 w0.102: v2(39.32,9.54) 40.69,10.91 40.69,11.93 40.1,12.51 40.1,14.9 40.84,15.64 41.86,15.64 45.11,18.89 45.11,20.46 46.2,21.55 46.2,22.62 46.48,22.9 48.38,22.9 48.64,22.65 48.64,21.86 48.87,21.63 51.28,21.63 51.48,21.43 55.52,21.43 58.75,24.65 64.97,24.65 65.99,25.67 71.89,25.67 72.46,25.1 74.3,25.1 74.8,24.6 77.6,24.6 80.66,27.66 82.39,27.66 84.02,29.29 85.8,29.29 87.77,31.26 87.86,31.26 90,33.4 90,33.88 90.91,34.79 92.45,34.79 92.5,34.74 93.36,34.74 93.79,35.16 v2(93.79,35.19)
  BOTTOM w0.109: PQ2112.3 38.09,11.51 39.11,10.48 39.46,10.48 PQ2112.6 39.73,9.96 v2(39.32,9.54)
LPS_OFF_BATT_R: length 119
  TOP w0.109: QT10.2 53.78,12.56 53.78,11.28 53.69,11.19 53.69,10.48 53.97,10.2 53.97,7.76 56.42,5.31 v2(56.42,2.99) ; PR733.2 PR734.1 92.13,37.16 PQ705.2 91.68,35.92 92.47,35.13 v1(92.57,35.13) 93.02,35.13 v2(93.08,35.18)
  IN4 w0.102: v2(56.42,2.99) 57,2.42 58.56,2.42 61.89,5.75 67.5,5.75 71.66,1.59 100.57,1.59 101.52,2.55 101.52,7.46 100.53,8.45 100.53,11.39 97.28,14.65 93.89,14.65 91.88,16.65 89.65,16.65 89.18,16.18 88.89,16.18 88.57,16.5 88.57,17.33 87.88,18.01 85.99,18.01 84.33,19.68 84.33,23.41 84.05,23.68 84.05,24.06 86.07,26.08 91.95,26.08 93.85,27.98 93.85,28.34 95.24,29.72 95.24,31.57 93.08,33.73 v2(93.08,35.18)
LX_1.2V: length 9
  IN1 w0.762: 115.52,11.14 115.87,11.14 119.94,7.08 119.94,4.21
  vias: v1(132.47,1.74) v2(114.53,11.93) v2(115.11,11.93) v2(119.94,1.4) v2(120.11,3.27) v2(120.74,1.4) v2(120.8,3.27) v2(121.32,1.34) v2(122.5,1.37) v2(130.9,3.16) v2(130.9,2.53) v2(131.53,3.16) v2(131.53,2.53) v2(132.17,3.16) v2(132.17,2.53)
LX_1.8V: length 1.5
  TOP w0.109: PR903.1 103.4,23.48 v1(103.06,23.83)
LX_2.5V: length 3.9
  TOP w0.109: PL400.1 160.02,93.36 161.71,95.05 v1(161.71,95.65)
LX_3V:
  vias: v1(137.6,109.68) v2(136.47,109.11) v2(136.47,108.47) v2(136.47,107.84) v2(136.47,107.2) v2(137.11,109.11) v2(137.11,108.47) v2(137.11,107.84) v2(137.11,107.2) v2(137.74,109.11) v2(137.74,108.47) v2(137.74,107.84) v2(137.74,107.2) v2(138.38,109.11) v2(138.38,108.47) v2(138.38,107.84) v2(138.38,107.2)
LX_3VR: length 2.9
  TOP w0.254: PU501.6 321.6,7.26 321.69,7.16 324,7.16
  vias: v1(325.78,11.29)
LX_5V:
  vias: v1(52.21,12.96) v2(47.75,8.85) v2(47.75,8.24) v2(47.75,7.63) v2(47.78,6.31) v2(47.8,6.97) v2(48.38,6.97) v2(48.41,8.27) v2(48.41,7.58) v2(48.44,6.34) v2(49.12,7.63) v2(49.12,6.97) v2(49.12,6.36) v2(49.22,8.3) v2(49.83,10.66) v2(49.8,9.9) v2(50.53,9.86)
LX_5VR: length 5.3
  TOP w0.109: v1(357.77,49.04) 358.91,47.89 PR502.1
  TOP w0.254: PU500.20 356.44,42.97 354,42.97 353.9,43.07 PU500.6
LX_+1VSP: length 11.4
  TOP w0.254: PU800.8 107.17,31.99 v2(107.24,32.07)
  IN3 w0.762: 106.79,33.36 106.79,33.82 104.83,35.78 104.83,41.27 106.12,42.56
  vias: v2(106.31,43.78) v2(106.31,43.19) v2(106.77,32.42)
LX_CHG: length 30.8
  TOP w0.203: 73.35,24.27 72.97,24.27 72.73,24.03 PU700.27
  TOP w0.381: v2(73.67,23.57) 74.31,24.21 PC708.1 73.35,24.27
  IN4 w0.508: 92.73,12.56 92.73,11.32 92.02,10.61 89.2,10.61 83.67,16.14 83.67,17.96 82.43,19.19 80.62,19.19 78.09,21.72 78.09,22.58 77.09,23.57 v2(73.67,23.57)
  vias: v1(92.06,12.5) v2(92.38,14.06) v2(92.38,13.48)
LX_IO: length 1.3
  TOP w0.109: PC305.2 v1(305.53,52.9)
M2_SLOT3_PEDET: length 234
  TOP w0.109: UH1.AJ43 v2(131.29,28.07)
  IN3 w0.081: v2(308.59,6.26) 308.38,6.06 306.03,6.06 305.84,6.25 301.04,6.25 299.27,4.48 278.51,4.48 275.52,7.47 269.54,7.47 266.51,10.5 257.48,10.5 255.95,12.03 244.92,12.03 244.68,11.79 241.33,11.79 240.75,11.21 239.85,11.21 239.13,10.49 237.01,10.49 236.59,10.91 235.88,10.91 235.46,10.48 235.46,10.28 232.39,7.21 169.25,7.21 163.05,13.41 160.61,13.41 157.14,16.88 153.07,16.88 152.91,16.72 151.7,16.72 150.84,17.58 148.27,17.58 146.63,19.22 145.33,19.22 144.93,19.62 143.06,19.62 142.84,19.84 140.76,19.84 140.1,20.51 136.9,20.51 136.31,19.92 135.76,19.92 133.4,17.55 132.8,17.55 132.48,17.23 131.89,17.23 131.41,17.72 131.41,19.18 130.98,19.6 130.98,21.98 128.99,23.97 128.99,25.83 129.83,26.67 129.83,26.88 131.03,28.07 v2(131.29,28.07)
  BOTTOM w0.109: v2(308.59,6.26) 308.59,7.71 303.76,12.53 303.76,17.2 304.29,17.73 310.31,17.73 310.78,17.26 312.52,17.26 313.08,16.7 315.44,16.7 RN200.1 316,15.75 v1(316.5,15.25) 316.7,15.04 JNGFF3.61
M2_SLOT4_PEDET: length 269.7
  TOP w0.102: v2(130.9,23.89) 131.12,24.11 131.12,24.66 130.38,25.4 130.38,25.7 130.35,25.73 130.35,26.26 UH1.AM46
  TOP w0.109: v2(368.12,13.98) v1(368.12,14.62)
  IN3 w0.081: v2(368.12,13.98) 367.67,13.53 363.75,13.53 362.58,12.36 362.12,12.36 360.87,11.11 359.05,11.11 358.23,11.93 355.29,11.93 353.87,13.35 350.19,13.35 349.09,14.45 347.41,14.45 344.84,11.89 341.46,11.89 340.61,12.74 338.17,12.74 336.99,11.56 334.39,11.56 334.11,11.84 334.11,12.18 333.92,12.37 333.19,12.37 332.77,12.79 326.59,12.79 325.25,14.13 323.1,14.13 317.41,8.44 307.07,8.44 305.55,6.93 302.85,6.93 302.63,7.15 277.02,7.15 276.02,8.15 269.83,8.15 266.83,11.15 257.85,11.15 256.27,12.72 244.64,12.72 244.39,12.48 241.05,12.48 240.46,11.89 238.07,11.89 237.77,11.59 234.69,11.59 231,7.9 169.54,7.9 163.34,14.1 160.95,14.1 157.01,18.04 151.37,18.04 150.95,18.46 148.98,18.46 146.57,20.86 143,20.86 142.6,20.47 141.03,20.47 139.07,22.44 135.16,22.44 134.34,21.62 134.34,21.21 133.89,20.76 132.21,20.76 131.6,21.37 131.6,22.32 131.93,22.64 131.93,23.71 131.74,23.89 v2(130.9,23.89)
  BOTTOM w0.109: v2(368.12,13.98) 368.12,13.32 368.88,12.56 RN203.1 368.53,12.11 367.84,12.11 367.25,11.51 JNGFF4.69
M2_SLOT5_PEDET: length 235.1
  TOP w0.109: v2(129.55,24.55) 129.55,25.74 129.65,25.84 UH1.AN47
  IN3 w0.081: v2(129.55,24.55) 130.49,25.49 132.28,25.49 133.07,24.7 133.07,23.02 132.55,22.5 132.55,21.4 132.86,21.1 133.75,21.1 134,21.35 134,21.76 135.01,22.78 139.21,22.78 140.62,21.37 146.68,21.37 149.14,18.91 151.14,18.91 151.56,18.49 157.2,18.49 161.14,14.56 163.53,14.56 169.73,8.36 230.81,8.36 235.39,12.93 243.38,12.93 243.63,13.18 256.43,13.18 257.37,12.24 265.74,12.24 266.34,11.65 266.98,11.65 270.02,8.61 276.25,8.61 277.25,7.61 302.1,7.61 v2(302.5,8.01)
  BOTTOM w0.109: v2(302.5,8.01) 302.17,8.01 299.1,11.08 299.1,13.9 301.19,16 301.19,23.06 311.63,33.5 311.63,35.1 v1(316.04,39.5) 316.51,39.97 RN208.1 317.52,40.91 318.08,40.36 JNGFF5.61
M2_SLOT6_PEDET: length 151.6
  TOP w0.109: v2(114.56,88.85) 114.56,89.17 113.99,89.74 v1(113.61,89.74) ; v2(133.82,25.08) 133.92,25.18 133.92,26.29 134.19,26.56 134.19,28.05 133.82,28.42 132.4,28.42 132.39,28.43 UH1.AH41
  IN1 w0.102: v2(133.82,25.08) 133.21,24.47 133.21,23.52 132.34,22.65 130.88,22.65 130.73,22.8 129.79,22.8 129.27,22.28 129.27,20.58 129.6,20.25 129.6,16.88 129.34,16.61 121.88,16.61 118.46,20.04 118.46,20.54 117.17,21.84 116.62,21.84 116.33,21.96 115.37,22.91 114.16,22.91 113.17,23.91 112.37,23.91 111.51,24.77 110.94,24.77 110.82,24.89 110.82,26.17 110.39,26.6 110.39,29.08 109.98,29.5 109.98,30.26 110.28,30.56 110.28,31.65 110.46,31.83 110.46,32.9 109.85,33.5 109.85,37.28 107.48,39.65 101.48,39.65 99.13,42 99.13,51.77 101.36,54 106.63,54 108.09,55.46 108.09,62.29 106.53,63.86 106.53,66.19 109.52,69.19 109.52,72.32 110.14,72.94 110.14,75.61 111.03,76.5 111.03,82 110.3,82.73 110.3,83.82 110.63,84.15 112.98,84.15 114.45,85.62 114.45,88.74 v2(114.56,88.85)
  IN2 w0.081: v2(114.56,88.85) 114.56,89.46 114.48,89.55 114.48,93.83 114.25,94.06 114.25,95.07 114.69,95.52 117.49,95.52 120.53,98.57 v2(123.71,98.57)
  BOTTOM w0.109: JNGFF6.61 122.28,96.48 122.41,96.36 122.83,96.36 123.35,96.88 123.35,98.21 v2(123.71,98.57) 124.46,98.57 125.6,99.71 RN211.1
M3042_PCIE#_SATA: length 4.5
  TOP w0.109: UE1.J12 142.01,72.48 144.22,72.48 144.83,71.87 T309.1
M_BIST: length 42.7
  TOP w0.109: UE1.N8 138.44,69.38 v2(138.65,69.17) ; RZ1415.2 104.01,63.34 v1(104.87,62.47) v2(106.06,61.29)
  IN2 w0.081: v2(119.28,67.9) 118.96,68.21 118.04,68.21 115.22,65.39 113.73,65.39 112.45,64.11 110.26,64.11 108.4,62.24 107.01,62.24 v2(106.06,61.29)
  IN4 w0.102: v2(119.28,67.9) 119.95,67.23 122.25,67.23 122.73,66.75 125.79,66.75 126.58,65.95 129.4,65.95 129.78,66.34 131.34,66.34 131.9,66.89 136.88,66.89 137.87,67.89 137.87,68.66 138.38,69.17 v2(138.65,69.17)
M_BIST_R: length 10.7
  TOP w0.109: RZ1415.1 RZ1413.2 100.81,62.51 100.32,62.02 CZ218.1 98.55,62.02 RZ1482.2 97.99,62.26 97.89,62.16 v1(97.33,62.16) 97.11,62.37 97.11,63.17 DZ12.2 97.27,63.9 97.29,63.92 97.29,65.8 97.15,65.94 QZ22.2
MACO_EN: length 200.9
  TOP w0.109: v2(245.94,93.48) 245.94,92.66 246.29,92.32 JDGFF2.F9 ; UH1.AP29 129.15,34.78 v2(129.51,35.14)
  IN1 w0.102: v2(160.22,98.9) 159.33,98.01 159.33,95.65 157.68,93.99 157.68,92.98 156.54,91.84 156.54,82.06 156.84,81.75 156.84,79.94 160.87,75.91 160.87,70.92 162.02,69.77 162.02,67.39 161.63,67 161.63,65.88 161.44,65.69 161.44,61.17 160.96,60.68 160.96,59.12 160.55,58.71 160.55,52.92 158.62,50.99 158.62,47.64 v2(157.22,46.25)
  IN3 w0.081: v2(157.22,46.25) 156.49,45.52 v2(151.74,45.52)
  IN4 w0.102: v2(151.74,45.52) 151.47,45.52 148.33,42.38 147.93,42.38 147.34,41.8 143.76,41.8 143.56,42 142.8,42 142.06,41.26 142.06,40.96 141.73,40.63 141.73,39.23 141.4,38.9 140.51,38.9 139.82,38.22 139.82,37.18 140.05,36.95 140.05,35.02 139.85,34.81 139.37,34.81 139.09,34.53 138.91,34.53 138.71,34.33 138.71,33.72 138.5,33.52 133.4,33.52 132.48,34.43 130.15,34.43 129.51,35.07 v2(129.51,35.14) ; v2(238.61,93.99) 239.22,94.61 245.49,94.61 245.94,94.16 v2(245.94,93.48)
  BOTTOM w0.109: v2(160.22,98.9) 161.13,99.81 164.6,99.81 165.04,100.24 173.15,100.24 173.92,99.47 173.92,99.09 174.56,98.45 176.25,98.45 182.18,92.52 199.56,92.52 200.91,91.17 208.13,91.17 213.3,86.01 223.8,86.01 224.31,86.52 224.31,88.4 223.05,89.66 223.05,92.75 v1(224.32,94.02) 225.13,94.83 237.77,94.83 v2(238.61,93.99)
MASK_BASE_LEDS#: length 10.6
  TOP w0.109: QZ7.2 395.06,11.56 394.82,11.8 393.3,11.8 393.01,11.51 393.01,9.73 392.82,9.54 390.95,9.54 v1(390.56,9.15) 389.33,7.91 388.34,7.91 388.17,7.75 UZ10.4
MDP_CA_DET: length 33.4
  TOP w0.109: v2(275.57,87.69) 275.77,87.69 276.21,88.12 JDGFF4.F2 ; UV8.33 v2(302.17,83.34)
  BOTTOM w0.109: RV131.2 301.88,83.05 v2(302.17,83.34) 302.05,83.45 v1(301.09,83.45) 297.63,83.45 297.07,84.02 294.21,84.02 289.94,88.28 284.71,88.28 282.85,86.43 279.59,86.43 279.35,86.18 277.38,86.18 277.06,86.5 277.06,86.88 276.26,87.69 v2(275.57,87.69)
ME_FWP: length 52.3
  TOP w0.109: UE1.G12 v2(142.01,74.08) ; v2(167.46,96.53) v1(167.46,97.18)
  IN1 w0.102: v2(142.01,74.08) 142.01,74.68 142.44,75.11 142.44,78.56 141.93,79.07 141.93,80.78 143.75,82.6 143.75,85.68 146.41,88.34 146.41,95.23 v2(146.28,95.36)
  IN4 w0.102: v2(167.46,96.53) 158.57,96.53 157.6,97.5 156.59,97.5 155.75,96.66 151.5,96.66 149.85,95.02 148.05,95.02 147.7,95.36 v2(146.28,95.36)
  BOTTOM w0.109: SW1.1 166,97.14 166.61,96.53 v2(167.46,96.53) 167.64,96.36 167.64,95.51 RH100.1
