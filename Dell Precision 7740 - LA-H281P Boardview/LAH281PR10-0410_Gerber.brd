# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_CTX_C_GRX_N8: length 39.5
  TOP w0.102: v2(266.95,93.65) 266.64,93.35 266.48,93.35 266.3,93.17 266.3,91.7 266.12,91.52 265.91,91.52 JDGFF3.C8 ; CC49.2 244.95,78.46 244.95,78.73 245.17,78.95 245.17,79.43 245.43,79.69 245.43,81.59 245.56,81.73 v2(245.82,81.73)
  IN4 w0.102: v2(245.82,81.73) 245.62,81.52 245.49,81.52 245.41,81.6 245.41,82.29 248.83,85.7 248.83,86.12 249.93,87.23 252.52,87.23 253.77,88.47 253.77,91.62 256.76,94.61 266.79,94.61 267.57,93.83 267.57,93.46 267.47,93.36 267.06,93.36 266.95,93.48 v2(266.95,93.65)
PEG_CTX_C_GRX_N9: length 32.1
  TOP w0.102: CC47.2 245.85,76.5 245.85,78.57 246.12,78.85 246.12,79.67 v2(245.92,79.87) ; v2(266.89,89.43) 266.89,89.23 266.79,89.13 266.56,89.13 266.43,89.26 266.43,89.45 266.17,89.72 265.91,89.72 JDGFF3.C5
  IN4 w0.102: v2(266.89,89.43) 266.58,89.13 266.17,89.13 262.55,85.51 255.08,85.51 254.54,84.98 248.85,84.98 246.29,82.41 246.29,80.58 246.05,80.33 246.05,80 v2(245.92,79.87)
PEG_CTX_C_GRX_N10: length 28.7
  TOP w0.102: JDGFF3.B3 267.88,88.51 267.58,88.51 267.37,88.3 267.37,87.89 267.26,87.79 267.19,87.79 v2(266.9,88.08) ; CC45.2 246.94,78.43 246.94,80.09 247.34,80.49 247.34,81.63 v2(247.12,81.85)
  IN4 w0.102: v2(266.9,88.08) 266.61,87.78 266.43,87.78 263.54,84.89 255.6,84.89 255.09,84.38 249.23,84.38 247.21,82.37 247.21,81.94 v2(247.12,81.85)
PEG_CTX_C_GRX_N11: length 35.6
  TOP w0.102: JDGFF3.B6 267.9,90.33 267.69,90.33 v2(267.38,90.64) ; v2(247.86,79.88) 248.08,79.66 248.08,76.5 CC43.2
  IN4 w0.102: v2(267.38,90.64) 267.64,90.39 267.77,90.39 268.03,90.12 268.03,88.81 267.87,88.64 267.87,86.56 265.34,84.03 256.01,84.03 255.58,83.6 249.71,83.6 248.6,82.49 248.6,80.91 249.27,80.24 249.27,79.48 248.9,79.11 248.39,79.11 248.08,79.42 248.08,79.66 v2(247.86,79.88)
PEG_CTX_C_GRX_N12: length 33.4
  TOP w0.102: CC41.2 249.43,78.46 249.43,78.7 249.68,78.95 249.68,81.69 v2(249.88,81.88) ; JDGFF3.B9 267.86,92.09 267.41,92.09 267.28,92.21 v2(267.28,92.39)
  IN4 w0.102: v2(267.28,92.39) 267.58,92.1 267.87,92.1 268.63,91.34 268.63,88.07 268.48,87.92 268.48,86.31 265.58,83.42 258.34,83.42 257.61,82.68 255.42,82.68 255.09,83.01 250.22,83.01 249.73,82.51 249.73,82.03 v2(249.88,81.88)
PEG_CTX_C_GRX_N13: length 31.8
  TOP w0.102: v2(250.45,80.19) 250.71,79.93 250.71,78.86 250.33,78.48 250.33,76.43 CC39.2 ; JDGFF3.A2 269.22,87.91 269.43,87.91 269.9,88.38 270.14,88.38 270.28,88.52 v2(270.28,88.7)
  IN4 w0.102: v2(270.28,88.7) 269.98,88.4 269.65,88.4 268.95,87.7 268.95,86.2 265.75,83.01 258.55,83.01 257.76,82.21 254.09,82.21 253.7,82.6 251,82.6 250.59,82.2 250.59,80.33 v2(250.45,80.19)
PEG_CTX_C_GRX_N14: length 43.9
  TOP w0.102: v2(270.86,91.76) 270.69,91.58 270.55,91.58 270.36,91.77 269.83,91.77 269.59,91.53 269.2,91.53 JDGFF3.A8 ; CC37.2 251.84,78.45 251.84,81.67 v2(252.11,81.94)
  IN4 w0.102: v2(270.86,91.76) 270.86,91.33 270.79,91.25 270.65,91.25 270.01,91.89 270.01,92.07 270.17,92.23 271.13,92.23 271.77,91.58 271.77,90.38 273.16,88.99 273.16,86.05 272.67,85.55 271.04,85.55 270.71,85.22 269.7,85.22 266.29,81.81 259.17,81.81 256.18,78.83 252.55,78.83 251.68,79.7 251.68,81.98 251.81,82.11 251.94,82.11 v2(252.11,81.94)
PEG_CTX_C_GRX_N15: length 32.2
  TOP w0.102: v2(252.5,80.28) 252.83,79.94 252.83,76.49 CC35.2 ; JDGFF3.A5 269.22,89.92 269.34,89.8 270.24,89.8 v2(270.47,90.03)
  IN4 w0.102: v2(252.5,80.28) 252.71,80.06 252.71,79.7 253.11,79.3 256.05,79.3 258.97,82.22 266.11,82.22 269.53,85.64 270.43,85.64 271.18,86.39 271.18,89.31 270.74,89.76 270.74,89.76 v2(270.47,90.03)
PEG_CTX_C_GRX_P0: length 23.8
  TOP w0.102: v2(241.56,90.67) 241.92,91.02 242.2,91.02 242.49,91.31 243,91.31 JDGFF2.H7 ; CC64.2 235.8,78.49 235.8,82.39 v2(235.57,82.62)
  IN4 w0.102: v2(235.57,82.62) 235.79,82.83 235.79,83.67 237.26,85.15 237.26,85.93 238.38,87.05 238.38,90.08 238.92,90.62 238.92,92.11 239.55,92.75 242.01,92.75 242.47,92.29 242.47,91.32 242.11,90.96 241.86,90.96 v2(241.56,90.67)
PEG_CTX_C_GRX_P1: length 20.1
  TOP w0.102: JDGFF2.H4 243.02,89.49 242.96,89.55 242.65,89.55 v2(242.37,89.27) ; v2(237.81,81.02) 237.72,81.02 237.58,80.88 237.58,79.05 237.16,78.63 237.16,76.51 CC62.2
  IN4 w0.102: v2(242.37,89.27) 242.37,89.47 242.28,89.56 241.35,89.56 240.55,90.36 240.05,90.36 239.16,89.47 239.16,86.39 239.5,86.05 239.5,85.04 237.87,83.4 237.87,81.77 237.55,81.45 237.55,81.13 237.66,81.02 v2(237.81,81.02)
PEG_CTX_C_GRX_P2: length 23.3
  TOP w0.102: JDGFF2.G5 244.31,90.12 244.59,90.12 244.83,90.37 244.83,90.56 244.9,90.62 245.05,90.62 245.27,90.41 v2(245.27,90.31) ; CC60.2 238.07,78.41 238.07,79.12 238.61,79.66 238.61,79.96 238.57,80 238.57,80.58 238.61,80.62 238.61,81.2 237.75,82.06 237.75,82.82 238.17,83.24 241.46,83.24 241.82,82.88 241.82,82.48 v2(242.05,82.26)
  IN4 w0.102: v2(245.27,90.31) 245.34,90.38 245.34,90.54 245.23,90.64 244.51,90.64 243.81,89.95 243.81,85.91 241.66,83.75 241.66,82.36 241.77,82.26 v2(242.05,82.26)
PEG_CTX_C_GRX_P3: length 15.8
  TOP w0.102: CC58.2 239.48,76.5 239.48,81.59 239.37,81.7 239.37,82.06 v2(239.6,82.29) ; JDGFF2.H1 242.98,87.73 242.47,87.73 242.13,88.07 241.88,88.07 v2(241.68,87.87)
  IN4 w0.102: v2(239.6,82.29) 239.55,82.23 239.37,82.23 239.29,82.32 239.29,83.74 241.17,85.63 241.17,87.98 241.32,88.13 241.56,88.13 241.68,88.01 v2(241.68,87.87)
PEG_CTX_C_GRX_P4: length 20.9
  TOP w0.102: v2(241.02,81.47) 240.8,81.25 240.8,80.72 240.52,80.44 240.52,78.46 CC56.2 ; v2(245.46,93) 245.26,93.21 245,93.21 244.84,93.05 244.84,92.17 244.58,91.91 244.3,91.91 JDGFF2.G8
  IN4 w0.102: v2(245.46,93) 245.46,93.19 245.39,93.26 244.9,93.26 243.88,92.23 243.88,90.97 243.22,90.31 243.22,86.2 240.43,83.42 240.43,82.19 240.72,81.9 240.72,81.77 v2(241.02,81.47)
PEG_CTX_C_GRX_P5: length 18.4
  TOP w0.102: CC54.2 241.37,76.49 241.37,78.74 241.91,79.28 241.91,79.92 v2(241.76,80.07) ; v2(245.3,87.27) 244.99,87.58 244.82,87.58 244.64,87.75 244.64,88.17 244.48,88.33 244.32,88.33 JDGFF2.G2
  IN4 w0.102: v2(245.3,87.27) 245.3,87.47 245.23,87.55 244.6,87.55 244.41,87.35 244.41,85.52 242.72,83.83 242.72,81.71 241.31,80.3 241.31,79.65 241.61,79.34 241.84,79.34 242.11,79.61 242.11,79.85 242.14,79.87 242.14,80.04 242.06,80.11 241.8,80.11 v2(241.76,80.07)
PEG_CTX_C_GRX_P6: length 15.1
  TOP w0.102: CC52.2 242.71,78.46 242.71,78.62 243.19,79.1 243.19,80.06 243.55,80.42 243.55,81.59 v2(243.74,81.78) ; JDGFF2.F4 246.27,89.54 246.03,89.54 v2(245.74,89.26)
  IN4 w0.102: v2(243.74,81.78) 243.47,82.05 243.47,83.72 245.44,85.69 245.44,86.39 246.01,86.96 246.01,88.26 245.37,88.89 245.37,89.5 245.48,89.61 245.66,89.61 245.74,89.52 v2(245.74,89.26)
PEG_CTX_C_GRX_P7: length 20.6
  TOP w0.102: CC50.2 243.68,76.48 243.68,78.74 244.19,79.25 244.19,79.71 v2(243.89,80.01) ; v2(245.35,91.71) 245.58,91.95 245.65,91.95 245.76,91.84 245.76,91.58 246.01,91.33 246.28,91.33 JDGFF2.F7
  IN4 w0.102: v2(243.89,80.01) 243.98,79.92 244.09,79.92 244.18,80.01 244.18,80.55 244.37,80.74 244.37,83.8 246.78,86.22 246.78,88.57 246.27,89.09 246.27,91.68 245.99,91.95 245.45,91.95 245.35,91.85 v2(245.35,91.71)
PEG_CTX_C_GRX_P8: length 39.5
  TOP w0.102: v2(245.01,81.94) 245.23,81.71 245.23,79.77 244.98,79.51 244.98,79.02 244.76,78.81 244.76,78.46 CC48.2 ; v2(266.97,92.89) 266.96,92.89 266.69,93.16 266.56,93.16 266.49,93.09 266.49,91.62 266.2,91.32 265.91,91.32 JDGFF3.C7
  IN4 w0.102: v2(266.97,92.89) 267.26,93.17 267.54,93.17 267.76,93.38 267.76,93.91 266.87,94.8 256.68,94.8 253.58,91.7 253.58,88.55 252.45,87.41 249.86,87.41 248.64,86.2 248.64,85.78 245.22,82.37 245.22,82.16 v2(245.01,81.94)
PEG_CTX_C_GRX_P9: length 32.1
  TOP w0.102: CC46.2 246.04,76.5 246.04,78.49 246.31,78.77 246.31,79.68 v2(246.5,79.87) ; v2(267.04,88.65) 266.75,88.94 266.48,88.94 266.24,89.18 266.24,89.37 266.09,89.52 265.91,89.52 JDGFF3.C4
  IN4 w0.102: v2(267.04,88.65) 267.04,88.8 266.9,88.94 266.25,88.94 262.63,85.32 255.15,85.32 254.62,84.79 248.93,84.79 246.48,82.34 246.48,80.5 246.24,80.25 246.24,80.14 v2(246.5,79.87)
PEG_CTX_C_GRX_P10: length 28.7
  TOP w0.102: JDGFF3.B2 267.89,88.32 267.66,88.32 267.56,88.22 267.56,87.81 267.34,87.6 267.26,87.6 v2(266.91,87.25) ; CC44.2 247.13,78.49 247.13,80.01 247.53,80.41 247.53,81.67 v2(247.7,81.85)
  IN4 w0.102: v2(266.91,87.25) 266.91,87.53 266.85,87.6 266.5,87.6 263.61,84.7 255.68,84.7 255.17,84.2 249.3,84.2 247.4,82.29 247.4,82.15 v2(247.7,81.85)
PEG_CTX_C_GRX_P11: length 35.7
  TOP w0.102: v2(267.35,89.78) 267.35,89.94 267.55,90.14 267.87,90.14 JDGFF3.B5 ; CC42.2 248.27,76.5 248.27,79.36 v2(248.68,79.77)
  IN4 w0.102: v2(248.68,79.77) 248.55,79.9 248.37,79.9 248.27,79.79 248.27,79.5 248.46,79.3 248.82,79.3 249.08,79.56 249.08,80.16 248.41,80.83 248.41,82.57 249.63,83.79 255.5,83.79 255.93,84.22 265.27,84.22 267.68,86.63 267.68,88.72 267.85,88.89 267.85,90.04 267.69,90.2 267.29,90.2 267.21,90.11 267.21,89.93 v2(267.35,89.78)
PEG_CTX_C_GRX_P12: length 33.4
  TOP w0.102: v2(267.13,91.66) 267.14,91.66 267.38,91.9 267.91,91.9 JDGFF3.B8 ; v2(249.29,81.88) 249.49,81.69 249.49,79.03 249.24,78.78 249.24,78.46 CC40.2
  IN4 w0.102: v2(267.13,91.66) 267.13,91.84 267.2,91.91 267.79,91.91 268.44,91.26 268.44,88.15 268.29,88 268.29,86.39 265.5,83.6 258.26,83.6 257.53,82.87 255.5,82.87 255.17,83.19 250.15,83.19 249.54,82.59 249.54,82.14 v2(249.29,81.88)
PEG_CTX_C_GRX_P13: length 31.8
  TOP w0.102: v2(251.03,80.19) 250.9,80.05 250.9,78.78 250.52,78.4 250.52,76.57 CC38.2 ; v2(270.41,87.91) 270.13,88.19 269.98,88.19 269.51,87.72 269.21,87.72 JDGFF3.A1
  IN4 w0.102: v2(270.41,87.91) 270.41,88.08 270.28,88.22 269.73,88.22 269.14,87.62 269.14,86.13 265.83,82.82 258.63,82.82 257.83,82.02 254.02,82.02 253.63,82.41 251.08,82.41 250.78,82.12 250.78,80.44 v2(251.03,80.19)
PEG_CTX_C_GRX_P14: length 43.8
  TOP w0.102: CC36.2 251.65,78.48 251.65,81.58 251.58,81.65 v2(251.26,81.65) ; JDGFF3.A7 269.23,91.34 269.67,91.34 269.91,91.58 270.28,91.58 270.41,91.45 270.41,91.13 v2(270.25,90.97)
  IN4 w0.102: v2(270.25,90.97) 270.25,91.39 269.82,91.82 269.82,92.14 270.1,92.42 271.2,92.42 271.96,91.66 271.96,90.46 273.35,89.07 273.35,85.97 272.74,85.36 271.12,85.36 270.79,85.03 269.77,85.03 266.37,81.63 259.24,81.63 256.26,78.64 252.47,78.64 251.5,79.62 251.5,81.42 v2(251.26,81.65)
PEG_CTX_C_GRX_P15: length 32.2
  TOP w0.102: v2(270.2,89.29) 270.2,89.53 270.11,89.61 269.39,89.61 269.1,89.32 JDGFF3.A4 ; CC34.2 253.02,76.51 253.02,79.99 v2(253.31,80.28)
  IN4 w0.102: v2(270.2,89.29) 270.2,89.5 270.25,89.55 270.68,89.55 270.99,89.24 270.99,86.47 270.36,85.83 269.45,85.83 266.03,82.41 258.89,82.41 255.98,79.49 253.18,79.49 252.9,79.77 252.9,80.4 252.98,80.48 253.11,80.48 v2(253.31,80.28)
PEG_CTX_GRX_N0: length 12
  TOP w0.076: 237.69,70.31 237.67,70.29 237.67,69.42 236.91,68.65 236.91,67.02 237,66.94 237.15,66.94 237.24,67.02 UC1.B10
  TOP w0.102: CC65.1 236.06,76.95 236.03,76.87 236.15,76.5 236.15,74.29 237.69,72.75 v3(237.69,72.43) 237.69,71.08 237.73,71.04 237.73,70.35 237.69,70.31
PEG_CTX_GRX_N1: length 9.4
  TOP w0.076: 238.39,70.28 238.39,70.26 238.41,70.24 238.41,69.67 237.7,68.96 237.7,68.29 237.54,68.13 237.54,67.62 237.69,67.46 237.87,67.46 UC1.B11
  TOP w0.102: CC63.1 236.97,74.89 236.97,74.33 v3(237.18,74.12) 238.39,72.91 238.39,71.74 238.35,71.71 238.35,71.12 238.39,71.08 238.39,70.28
PEG_CTX_GRX_N2: length 11.9
  TOP w0.076: 239.33,70.1 239.33,70.08 239.31,70.06 239.31,69.6 238.34,68.63 238.34,68.34 238.48,68.19 238.48,67.02 238.56,66.94 238.7,66.94 238.81,67.06 UC1.B12
  TOP w0.102: CC61.1 238.31,76.84 238.31,74.28 v3(238.76,73.83) 239.33,73.26 239.33,72.93 239.37,72.89 239.37,72.3 239.33,72.27 239.33,70.1
PEG_CTX_GRX_N3: length 9
  TOP w0.076: 239.89,69.86 239.89,69.85 239.91,69.83 239.91,69.1 239.13,68.32 239.13,67.57 239.27,67.43 239.48,67.43 UC1.B13
  TOP w0.102: CC59.1 239.29,74.89 239.29,74.14 239.89,73.55 v3(239.89,71.54) 239.89,70.61 239.85,70.58 239.85,69.9 239.89,69.86
PEG_CTX_GRX_N4: length 11.1
  TOP w0.076: 240.71,68.49 240.71,68.47 240.73,68.45 240.73,67.02 240.64,66.94 240.52,66.94 240.39,67.07 UC1.B14
  TOP w0.102: CC57.1 240.33,76.84 240.33,74.79 240.67,74.45 240.67,73.85 240.71,73.82 v3(240.71,72.85) 240.71,68.49
PEG_CTX_GRX_N5: length 8.4
  TOP w0.076: UC1.B15 241.29,67.42 241.46,67.42 241.62,67.59 241.62,68.29 241.56,68.36 241.56,68.86 241.58,68.88 241.58,68.89
  TOP w0.102: 241.58,68.89 v3(241.58,70.42) 241.58,71.36 241.62,71.4 241.62,71.99 241.58,72.02 241.58,74.36 241.57,74.37 241.57,74.89 CC55.1
PEG_CTX_GRX_N6: length 11.1
  TOP w0.076: UC1.B16 241.96,67.04 242.08,66.92 242.2,66.92 242.28,67.01 242.28,69.29 242.26,69.31 242.26,69.33
  TOP w0.102: 242.26,69.33 v3(242.26,72.65) 242.26,73.73 242.22,73.76 242.22,74.35 242.26,74.39 242.26,74.66 242.52,74.91 242.52,76.85 CC53.1
PEG_CTX_GRX_N7: length 8.8
  TOP w0.076: UC1.B17 242.86,67.42 243.04,67.42 243.22,67.59 243.22,68.21 243.13,68.3 243.13,68.79 243.22,68.89 243.22,69.19 243.24,69.21 243.24,69.23
  TOP w0.102: 243.24,69.23 v3(243.24,70.27) 243.24,71.22 243.28,71.26 243.28,71.85 243.24,71.88 243.24,74.01 243.84,74.62 243.84,74.84 CC51.1
PEG_CTX_GRX_N8: length 11.4
  TOP w0.076: UC1.C18 243.66,66.78 243.85,66.78 244.04,66.97 244.04,69.3 244.06,69.32
  TOP w0.102: 244.06,69.32 244.06,72.25 244.1,72.29 244.1,72.87 244.06,72.91 244.06,73.64 v3(244.54,74.11) 244.95,74.52 244.95,76.84 CC49.1
PEG_CTX_GRX_N9: length 8.9
  TOP w0.076: UC1.A19 244.23,67.86 244.23,67.75 244.31,67.67 244.48,67.67 244.64,67.84 244.64,68.91 244.62,68.93
  TOP w0.102: CC47.1 245.85,74.89 245.85,74.68 244.62,73.45 244.62,71.78 244.66,71.74 244.66,71.57 v3(244.62,71.53) 244.62,70.55 244.58,70.51 244.58,69.85 244.62,69.81 244.62,68.93
PEG_CTX_GRX_N10: length 11.8
  TOP w0.076: UC1.C20 244.83,66.94 244.83,67.41 245.05,67.63 245.18,67.63 245.4,67.86 245.4,68.34 245.5,68.44 245.5,68.92 245.48,68.94 245.48,68.96
  TOP w0.102: CC45.1 246.96,76.85 246.96,74.64 246.44,74.12 246.38,74.12 245.95,73.69 245.95,73.63 245.48,73.16 v3(245.48,72.74) 245.48,68.96
PEG_CTX_GRX_N11: length 9.2
  TOP w0.076: UC1.A21 245.9,67.7 245.98,67.62 246.11,67.62 246.19,67.7 246.19,68.33 246.11,68.42 246.11,68.84 246.09,68.86 246.09,68.88
  TOP w0.102: CC43.1 248.08,74.89 248.08,74.17 246.09,72.18 v3(246.09,71.55) 246.09,70.62 246.05,70.58 246.05,69.97 246.09,69.93 246.09,68.88
PEG_CTX_GRX_N12: length 11.9
  TOP w0.076: UC1.C22 246.85,66.82 246.96,66.82 247.15,67.01 247.15,68.07 247.27,68.19 247.27,68.7 247.29,68.72 247.29,68.74
  TOP w0.102: 247.29,68.74 247.29,72.11 v3(248.08,72.89) 248.75,73.57 248.81,73.57 249.25,74.01 249.25,74.06 249.43,74.25 249.43,76.84 CC41.1
PEG_CTX_GRX_N13: length 9.5
  TOP w0.076: 247.81,68.26 247.81,68.25 247.83,68.23 247.83,67.74 247.7,67.61 247.55,67.61 247.47,67.69 UC1.A23
  TOP w0.102: 247.81,68.26 247.81,69.96 247.77,70 247.77,70.61 247.81,70.65 v3(247.81,71.58) 247.81,71.91 250.12,74.22 250.4,74.5 250.4,74.89 CC39.1
PEG_CTX_GRX_N14: length 12.3
  TOP w0.076: 249.01,69.1 248.99,69.09 248.99,68.38 248.76,68.15 248.76,66.96 248.59,66.79 248.4,66.79 UC1.C24
  TOP w0.102: CC37.1 251.83,76.85 251.83,74.59 251.57,74.33 251.57,74.27 251.14,73.84 251.08,73.84 v3(250.38,73.14) 249.01,71.77 249.01,69.1
PEG_CTX_GRX_N15: length 9.9
  TOP w0.076: UC1.A25 249.05,67.67 249.13,67.59 249.3,67.59 249.38,67.67 249.38,68.15 249.32,68.22 249.32,68.82 249.44,68.94 249.44,69.48 249.42,69.5
  TOP w0.102: CC35.1 252.84,74.89 252.84,74.76 252.62,74.54 252.56,74.54 252.08,74.05 252.08,74 v3(249.8,71.72) 249.42,71.34 249.42,69.5
PEG_CTX_GRX_P0: length 12
  TOP w0.076: 237.5,70.3 237.52,70.28 237.52,69.48 236.76,68.72 236.76,66.96 236.94,66.78 237.11,66.78 UC1.C10
  TOP w0.102: CC64.1 235.81,76.8 235.89,76.68 235.96,76.47 235.96,74.21 237.47,72.71 237.47,72.14 237.5,72.1 v3(237.5,70.72) 237.5,70.3
PEG_CTX_GRX_P1: length 9.3
  TOP w0.076: UC1.A11 238.03,67.71 237.93,67.62 237.75,67.62 237.69,67.68 237.69,68.06 237.86,68.23 237.86,68.9 238.56,69.6 238.56,70.24 238.58,70.26 238.58,70.28
  TOP w0.102: 238.58,70.28 v3(238.58,71.41) 238.58,72.99 237.55,74.02 237.55,74.07 237.16,74.46 237.16,74.89 CC62.1
PEG_CTX_GRX_P2: length 11.9
  TOP w0.076: UC1.C12 238.68,66.79 238.49,66.79 238.33,66.95 238.33,68.13 238.18,68.27 238.18,68.69 239.16,69.67 239.16,70.06 239.14,70.08 239.14,70.1
  TOP w0.102: CC60.1 238.12,76.84 238.12,74.2 238.39,73.93 238.39,73.87 238.8,73.46 238.86,73.46 239.14,73.18 v3(239.14,72.6) 239.14,70.1
PEG_CTX_GRX_P3: length 9
  TOP w0.076: UC1.A13 239.6,67.69 239.49,67.58 239.34,67.58 239.28,67.64 239.28,68.25 240.06,69.03 240.06,69.83 240.08,69.85 240.08,69.86
  TOP w0.102: CC58.1 239.48,74.89 239.48,74.22 240.08,73.62 240.08,71.87 240.12,71.83 240.12,71.25 240.08,71.21 v3(240.08,70.26) 240.08,69.86
PEG_CTX_GRX_P4: length 11.2
  TOP w0.076: UC1.C14 240.52,66.79 240.71,66.79 240.88,66.96 240.88,68.45 240.9,68.47 240.9,68.49
  TOP w0.102: 240.9,68.49 240.9,72.52 240.94,72.56 240.94,73.14 240.9,73.18 v3(240.9,74.14) 240.9,74.49 240.52,74.87 240.52,76.84 CC56.1
PEG_CTX_GRX_P5: length 8.4
  TOP w0.076: UC1.A15 241.18,67.69 241.29,67.57 241.39,67.57 241.47,67.65 241.47,68.23 241.41,68.29 241.41,68.87 241.39,68.89 241.39,68.89
  TOP w0.102: 241.39,68.89 241.39,70.1 241.35,70.14 241.35,70.71 241.39,70.74 v3(241.39,71.69) 241.39,74.28 241.38,74.29 241.38,74.89 CC54.1
PEG_CTX_GRX_P6: length 11.1
  TOP w0.076: UC1.C16 242.08,66.77 242.26,66.77 242.43,66.94 242.43,69.24 242.45,69.25 242.45,69.43
  TOP w0.102: 242.45,69.43 242.45,72.32 242.49,72.35 242.49,72.94 242.45,72.98 v3(242.45,74.06) 242.45,74.58 242.71,74.83 242.71,76.84 CC52.1
PEG_CTX_GRX_P7: length 8.8
  TOP w0.076: 243.05,69.23 243.05,69.21 243.07,69.19 243.07,68.95 242.97,68.86 242.97,68.24 243.07,68.15 243.07,67.66 242.98,67.57 242.83,67.57 242.75,67.65 UC1.A17
  TOP w0.102: 243.05,69.23 243.05,69.93 243.01,69.97 243.01,70.6 243.05,70.64 v3(243.05,71.55) 243.09,71.59 243.09,71.77 243.05,71.8 243.05,74.09 243.65,74.69 243.65,74.94 CC50.1
PEG_CTX_GRX_P8: length 11.4
  TOP w0.076: 243.87,69.41 243.89,69.39 243.89,67.03 243.79,66.93 243.66,66.93 243.54,67.05 UC1.B18
  TOP w0.102: 243.87,69.41 v3(243.87,72.58) 243.87,73.72 244.17,74.02 244.17,74.07 244.59,74.48 244.64,74.48 244.76,74.6 244.76,76.84 CC48.1
PEG_CTX_GRX_P9: length 8.8
  TOP w0.076: 244.81,68.93 244.81,68.92 244.79,68.9 244.79,67.77 244.58,67.56 UC1.B19
  TOP w0.102: CC46.1 246.04,74.89 246.04,74.6 244.81,73.37 244.81,71.86 244.85,71.82 244.85,71.24 244.81,71.2 v3(244.81,70.2) 244.81,68.93
PEG_CTX_GRX_P10: length 11.7
  TOP w0.076: 245.67,68.7 245.67,68.4 245.55,68.28 245.55,67.79 245.4,67.64 245.4,67 245.32,66.92 245.18,66.92 245.11,66.99 UC1.B20
  TOP w0.102: 245.67,68.7 245.67,72.4 245.71,72.44 245.71,73.12 v3(246.33,73.75) 247.15,74.56 247.15,76.84 CC44.1
PEG_CTX_GRX_P11: length 9.2
  TOP w0.076: 246.28,68.88 246.28,68.86 246.26,68.84 246.26,68.48 246.34,68.39 246.34,67.64 246.17,67.47 246.06,67.47 UC1.B21
  TOP w0.102: CC42.1 248.27,74.89 248.27,74.09 246.28,72.1 246.28,71.88 246.32,71.85 246.32,71.26 246.28,71.22 v3(246.28,70.27) 246.28,68.88
PEG_CTX_GRX_P12: length 11.9
  TOP w0.076: UC1.B22 246.69,67.04 246.75,66.97 246.9,66.97 247,67.08 247,68.13 247.12,68.25 247.12,68.7 247.1,68.72 247.1,68.74
  TOP w0.102: 247.1,68.74 247.1,72.19 247.71,72.79 247.71,72.85 248.12,73.26 248.17,73.26 v3(248.85,73.93) 249.14,74.23 249.24,74.33 249.24,76.84 CC40.1
PEG_CTX_GRX_P13: length 9.4
  TOP w0.076: 248,68.26 247.98,68.24 247.98,67.68 247.76,67.46 247.63,67.46 UC1.B23
  TOP w0.102: CC38.1 250.59,74.89 250.59,74.42 248.04,71.87 248.04,71.29 248,71.25 v3(248,70.31) 248,68.26
PEG_CTX_GRX_P14: length 12.3
  TOP w0.076: UC1.B24 248.26,67.01 248.33,66.94 248.53,66.94 248.61,67.02 248.61,68.21 248.84,68.45 248.84,69.09 248.82,69.1
  TOP w0.102: CC36.1 251.64,76.83 251.64,74.67 251.54,74.56 v3(251.2,74.23) 250.5,73.52 250.43,73.52 250.01,73.11 250.01,73.04 248.82,71.85 248.82,69.1
PEG_CTX_GRX_P15: length 9.9
  TOP w0.076: 249.61,69.46 249.61,69.44 249.59,69.42 249.59,68.88 249.47,68.75 249.47,68.28 249.54,68.21 249.54,67.61 249.36,67.44 249.18,67.44 UC1.B25
  TOP w0.102: 249.61,69.46 249.61,71.21 250.18,71.77 250.18,71.83 v3(252.49,74.14) 253.03,74.68 253.03,74.89 CC34.1
PG_1.0V: length 5.3
  TOP w0.109: v1(103.01,26.11) 103.72,26.83 103.72,27.54 103.3,27.96 103.3,27.99
  TOP w0.254: PR812.2 103.32,28.01 PR800.1 105.37,28.01 105.63,28.26 PU800.1
PG_1.8V: length 14.6
  TOP w0.254: PR906.2 103.29,26.98 102.86,26.55 98.32,26.55 v1(98.23,26.46) 98.23,24.58 96.63,22.98 96.63,21.5 97.48,20.65 97.48,19.93 PR900.2 97.73,19.68 PU900.2
PG_2.5V: length 2.7
  TOP w0.109: PR400.2 154.61,94.48 v1(154.29,94.8)
  TOP w0.254: PR400.2 155.02,93.83 155.46,93.4 PU400.2
PG_IO: length 4.8
  TOP w0.254: PU300.13 v2(310.43,55.97)
  BOTTOM w0.109: PR300.2 v1(309.28,52.81)
  BOTTOM w0.254: v2(310.43,55.97) 309.98,55.52 309.98,54.09 309.7,53.81 PR300.2
PGOOD_3V: length 3.2
  TOP w0.254: PU100.9 135.36,114.87 v1(135.06,115.17) 134.66,115.57 PR102.1 PR107.2
PGOOD_3VR: length 4.2
  TOP w0.109: v1(319.63,2.59) 319.63,3.2 319.81,3.38 PR508.1 PR515.2 319.81,4.97 320.75,5.9 PU501.9
PGOOD_5V: length 1.2
  BOTTOM w0.109: PR103.1 56.1,5.03 v1(56.58,4.56)
PGOOD_5VR: length 3.5
  TOP w0.109: PU500.9 352.79,41.72 352.37,41.3 v1(352.37,40.91) 352.13,40.67 PR509.1 351.41,39.89 PR500.2
PLTRST_CPU#: length 165.6
  TOP w0.089: UC1.BP35 255.58,28.3 255.58,28.11 255.57,28.11 255.57,27.99 255.24,27.66 254.94,27.66 254.73,27.45 254.73,27.2 254.81,27.12 254.81,27.1 254.84,27.07 254.84,25.65 v2(255.21,25.28)
  TOP w0.109: v2(168.51,40.71) 167.86,41.37 155.29,41.37 v2(151.73,44.93) ; v2(132.16,46.34) 132.16,46.46 132.28,46.59 UH1.AG5
  IN2 w0.081: v2(255.21,25.28) 255.18,25.25 255.18,21.65 254.91,21.39 253.79,21.39 253.06,22.11 247.66,22.11 246.94,21.39 241.91,21.39 239.77,19.26 236.18,19.26 231.93,15 200.78,15 199.01,13.23 196.02,13.23 195.46,12.67 176.48,12.67 172.74,16.41 170.89,16.41 169.64,17.65 169.64,25.77 168.51,26.91 v2(168.51,40.71) ; v2(132.16,46.34) 132.16,46.01 133.86,44.31 133.86,43.49 v2(134.16,43.19)
  BOTTOM w0.109: v2(151.73,44.93) 151.73,44.89 151.27,44.43 146.89,44.43 v4(146.27,43.81) 145.24,42.79 140.44,42.79 139.84,43.39 139.27,43.39 139.17,43.49 136.09,43.49 135.48,42.88 135.11,42.88 134.8,43.19 v2(134.16,43.19)
PLTRST_GPU#: length 231.3
  VCC w0.086: v2(155.84,81.8) 155.84,81.8 156.14,82.1 156.14,86.51 156.45,86.82 156.45,94.05 158.14,95.75 170.81,95.75 171.57,96.51 179.29,96.51 183.83,91.96 221.4,91.96 224.92,88.45 226.23,88.45 226.53,88.15 227.54,88.15 230.47,85.22 233.83,85.22 235.76,83.29 242.71,83.29 243.11,82.89 254.49,82.89 255.56,83.97 271.36,83.97 272.3,83.02 273.4,83.02 273.89,83.51 v2(273.89,83.6)
  IN3 w0.081: v2(155.84,81.8) 154.95,81.8 151.15,78.01 151.15,73.93 151.69,73.4 151.69,72.47 150.74,71.52 150.74,69.54 149.64,68.44 149.64,68.16 148.89,67.41 147.54,67.41 147.26,67.13 147.26,65.31 146.87,64.92 146.08,64.92 144.52,63.37 144.52,62.57 143.2,61.24 142.28,61.24 141.48,60.44 137.83,60.44 137.11,59.72 137.11,58.56 136.26,57.72 133.37,57.72 132.87,57.21 125.22,57.21 124.73,56.72 122.5,56.72 117.83,52.05 117.83,51.39 113.71,47.27 113.71,44.61 114.48,43.85 114.48,39.33 v2(113.23,38.09) ; v2(273.89,83.6) 273.89,83.04 274.44,82.49 279.12,82.49 281.25,84.62 282.71,84.62 v2(283.84,83.49)
  BOTTOM w0.109: v2(283.84,83.49) 283.84,83.15 284.3,82.7 UV63.2 ; v2(273.89,83.6) 273.89,83.78 v1(273.63,84.04) ; v2(113.23,38.09) 113.23,38.08 113.23,37.44 114.75,35.91 RH625.1
PLTRST_LAN#: length 2.7
  TOP w0.109: UL1.36 149.57,137.63 149.44,137.5 149.44,137.03 v1(149.12,136.7) 148.68,136.26 RH624.1
PLTRST_MMI#: length 7.6
  BOTTOM w0.109: RH626.2 25.38,22.9 25.01,22.54 24.28,22.54 v1(23.63,21.89) 23.63,21.39 22.27,20.03 22.27,19.92 21.61,19.26 21.61,18.88 20.96,18.23 UR1.1
PLTRST_TPM#: length 72.4
  IN1 w0.102: v2(129.23,13.55) 119.28,13.55 117.93,14.9 116.15,14.9 115.01,16.04 111.88,16.04 111.53,15.68 111.53,15.31 109.83,13.62 107.11,13.62 105.6,15.13 102.33,15.13 101.67,15.79 101.67,20.93 103.54,22.8 103.54,25.16 102.94,25.76 102.94,28.08 103.39,28.53 v2(103.39,29.16)
  BOTTOM w0.109: v2(129.23,13.55) 131.47,11.32 134.82,11.32 135.01,11.51 RH623.1 v1(135.88,12.72) 136.04,12.88 136.04,15.08 136.5,15.54 UZ12.17 ; RH622.2 113.76,32.37 114.37,31.76 114.37,29.73 113.76,29.12 108.95,29.12 108.54,28.71 107.41,28.71 106.45,29.67 105.62,29.67 105.05,29.1 103.45,29.1 v2(103.39,29.16)
PM_LANPHY_ENABLE: length 178.7
  TOP w0.102: v2(121.47,27.94) 121.47,28.3 122.25,29.07 123.21,29.07 123.33,28.95 UH1.BF41
  IN1 w0.102: v2(142.31,138.87) 137.7,138.87 134.31,142.25 128.85,142.25 124.57,146.53 121.44,146.53 114.88,139.97 114.88,122.71 114.65,122.48 114.65,115.7 113.73,114.78 113.73,107.39 113.39,107.05 112.32,107.05 111.39,106.12 111.39,100.25 113.66,97.98 113.66,96.73 114.67,95.73 115.83,95.73 116.57,94.98 116.57,83.77 115.05,82.25 115.05,78.88 115.77,78.16 115.77,76.28 115.52,76.02 115.52,72.57 115.61,72.48 115.61,72.15 115.52,72.05 115.52,68.84 115.32,68.64 115.32,67.42 115.08,67.18 115.08,66.84 115.53,66.39 115.53,59.05 114.94,58.46 114.94,56.04 115.39,55.59 116.14,55.59 117.82,53.91 117.82,51.2 119.17,49.84 119.17,28.63 119.57,28.23 121.18,28.23 v2(121.47,27.94)
  BOTTOM w0.109: v2(142.31,138.87) 142.91,139.46 144.41,139.46 144.66,139.21 145.74,139.21 147.63,137.32 v1(152.72,137.32) 154.1,137.32 155.27,136.16 157.05,136.16 157.93,135.27 158.95,135.27 159.73,136.05 RL7.1
PME#: length 3.6
  TOP w0.102: UH1.BE36 123.94,31.14 123.7,30.9 122.78,30.9 122.54,31.14 121.98,31.14 121.24,30.41 T178.1
POA_WAKE#_R: length 2.3
  TOP w0.109: RZ364.2 336.69,57.55 JUSH1.23
POWER_SW#_MB: length 515.7
  TOP w0.109: v2(160.88,69.43) 160.88,70.83 159.74,71.97 154.79,71.97 151.88,74.88 151.07,74.88 149.98,73.79 149.98,73.23 149.7,72.94 149.04,72.94 148.17,73.81 148.17,77.7 151.12,80.66 151.12,88.03 147.65,91.51 147.65,92.65 142,98.3 142,99.84 142.38,100.22 142.38,102.82 141.73,103.47 136.13,103.47 135.07,104.52 135.07,106.65 134.44,107.28 131.45,107.28 130.61,108.12 124.88,108.12 123.39,109.61 122.05,109.61 121.58,109.14 118.23,109.14 117.54,109.82 111.27,109.82 110.28,108.83 108.76,108.83 107.53,107.61 107.53,97.63 v2(107.69,97.46) ; RE33.2 CE10.1 123.97,76.99 123.49,76.51 123.49,73.15 122.77,72.43 118.51,72.43 v2(117.15,73.79) ; JPB1.1 372.9,51.61 370.6,53.91 SW3.2 SW3.4 359,53.91 358.39,53.3 CZ541.1 357.32,53.3 357.12,53.1 PWRSW1.1 356.41,53.3 353.82,55.89 343.63,55.89 338.88,60.64 335.18,60.64 332.85,62.97 330.29,62.97 327.79,60.47 319.69,60.47 315.3,64.86 312.63,64.86 v2(311.49,63.72)
  IN2 w0.081: v2(107.93,87.31) 108,87.38 108,88.33 109.59,89.92 110.93,89.92 112.65,91.64 112.65,94.96 111.39,96.22 108.39,96.22 107.9,96.71 107.9,97.26 v2(107.69,97.46)
  VCC w0.086: v2(311.49,63.72) 310.7,62.93 310.7,58.88 311.45,58.13 311.45,53.53 310.75,52.82 310.75,44.26 311.4,43.6 311.4,42.08 311.66,41.82 311.66,40.71 311.25,40.3 311.25,36.72 308.89,34.36 308.89,32.39 299.6,23.1 299.6,18.05 298.06,16.51 296.4,16.51 292.92,13.03 292.92,12.19 291.95,11.22 269.7,11.22 266.18,14.73 261.87,14.73 260.64,15.96 259.39,15.96 258.72,15.3 245.01,15.3 244.54,15.77 240.26,15.77 240.04,15.99 237.3,15.99 231.97,10.66 221.25,10.66 220.62,10.02 218.13,10.02 217.5,10.66 165.34,10.66 157.45,18.55 157.45,20.24 160.48,23.28 160.48,33.84 159.82,34.51 159.82,41.59 149.39,52.01 149.39,56.6 153.41,60.62 154.03,60.62 156.95,63.54 156.95,63.61 160.62,67.29 160.62,69.18 v2(160.88,69.43)
  BOTTOM w0.109: JAPS1.11 111.34,66.02 111.88,66.55 112.81,66.55 113.58,65.78 116.79,65.78 117.78,66.76 119.27,66.76 119.69,67.18 119.69,68.36 119.56,68.49 118.04,68.49 117.15,69.38 v2(117.15,73.79) 116.9,73.79 113.81,76.88 113.81,83.93 113.9,84.03 113.9,86.74 v4(112.15,88.5) 108.46,88.5 107.93,87.97 v2(107.93,87.31)
POWER_SW_IN#: length 58.3
  TOP w0.109: RE33.1 RE31.2 CE12.1 125.88,78.75 126.26,78.37 126.69,78.37 126.95,78.12 127.66,78.12 128.42,77.36 v2(128.89,77.36) ; UE1.D5 v2(135.67,77.22) ; v2(117.93,71.26) 117.67,71.52 112.71,71.52 112.14,70.95 111.04,70.95 110.76,71.23 100.83,71.23 98.79,69.18 96.72,69.18 95.26,67.72 95.26,64.91 95.53,64.64 QZ22.3
  IN3 w0.081: v2(128.89,77.36) 128.67,77.13 127.04,77.13 126.14,76.24 123.64,76.24 122.94,75.54 121.92,75.54 117.93,71.55 v2(117.93,71.26)
  IN3 w0.102: v2(135.67,77.22) 135.67,77.3 136.04,77.68 136.04,78.31 135.93,78.42 133.02,78.42 132.18,77.59 130.12,77.59 129.89,77.36 v2(128.89,77.36)
  BOTTOM w0.109: v2(128.89,77.36) v1(128.27,77.36)
PRIM_PWRGD: length 76.9
  TOP w0.109: UE1.L7 v2(137.27,70.88) ; PR906.1 PR812.1 101.43,28.93 v1(101.43,28.96) 101.43,30.2 100.62,31 99.73,31 99.27,30.55 v2(98.99,30.55)
  IN3 w0.081: v2(98.99,30.55) 99.54,31.1 99.54,31.37 99.85,31.67 99.85,38.79 98.56,40.08 98.56,43.92 99.59,44.95 99.59,50.76 100.72,51.89 107.71,51.89 114.54,58.73 114.54,59.58 118.54,63.58 118.84,63.58 121.39,66.12 121.39,66.43 121.75,66.79 122.69,66.79 122.79,66.9 126.84,66.9 127.59,66.14 128.94,66.14 129.05,66.03 129.46,66.03 129.71,66.27 130.34,66.27 130.35,66.27 131.37,66.27 132.25,67.15 132.92,67.15 133.21,67.44 135.24,67.44 136.14,68.34 136.57,68.34 136.78,68.55 136.78,69.39 137.27,69.87 v2(137.27,70.88)
PROCHOT#: length 443.9
  TOP w0.109: RE288.2 146.1,72.81 146.31,72.6 147.43,72.6 147.5,72.53 v1(150.09,72.53) 150.81,72.53 v2(150.87,72.58) ; v2(251.74,23.32) 252.35,23.32 RC83.2 252.72,22.96 252.72,22 RC84.1 252.83,21.76 252.49,21.41 CC324.1 ; v2(311.67,36.26) 311.45,36.26 PR1103.2 PR1110.2 ; v2(61.91,26.01) 61.09,25.19 PQ2010.1 61.34,23.94 64.82,23.94 64.93,23.83 PR718.1
  IN1 w0.102: v2(311.67,36.26) 311.67,34.12 308.58,31.03 v2(303.58,31.03) 297.47,31.03 296.03,29.6 296.03,27.53 292.52,24.02 290.27,24.02 289.16,22.91 284.3,22.91 283.17,24.04 267.43,24.04 265.63,25.85 259.88,25.85 257.67,23.64 255.7,23.64 255.42,23.92 252.34,23.92 v2(251.74,23.32)
  IN2 w0.081: v2(61.91,26.01) 61.91,26.19 63.1,27.38 63.56,27.38 65.05,28.87 74.65,28.87 75.89,30.11 77.9,30.11 80.34,32.55 84,32.55 85.27,33.81 85.27,35.09 87.12,36.94 89.84,36.94 93.24,40.34 93.24,42.19 95.18,44.13 95.18,45.3 95.68,45.8 96.37,45.8 96.61,46.05 96.61,50.75 96.61,51.07 100.06,54.52 102.26,54.52 102.64,54.9 103.73,54.9 106.94,58.11 111.57,58.11 117.99,64.53 120.15,64.53 120.56,64.93 v2(124.65,64.93) ; v2(280.16,72.47) 283.12,72.47 283.13,72.48 290.18,72.48 292.48,70.18 295.26,70.18 296.84,71.76 298.17,71.76 299.11,72.7 299.11,73.4 299.92,74.21 300.21,74.21 300.5,74.5 301.77,74.5 302.99,73.28 302.99,71.91 304.02,70.88 306.42,70.88 308.1,69.2 309.79,69.2 312.3,66.69 312.3,64.08 311.92,63.7 311.92,61.78 309.93,59.78 309.93,54.49 308.71,53.27 308.71,47.66 305.92,44.86 305.92,31.61 305.55,31.24 303.79,31.24 v2(303.58,31.03) ; v2(167.79,52.8) 167.41,52.8 159.22,60.99 159.22,65.9 158.8,66.31 158.8,70.51 157.47,71.84 154.95,71.84 153.81,72.97 151.25,72.97 v2(150.87,72.58)
  IN3 w0.081: v2(167.79,52.8) 168.47,52.12 168.47,47.22 168.25,47 168.25,45.93 168.98,45.2 168.98,41.08 169.5,40.57 169.5,26.02 170.08,25.44 170.08,17.25 170.99,16.33 172.7,16.33 175.81,13.22 199.08,13.22 200.37,14.51 228.55,14.51 233.87,19.83 237.93,19.83 240.14,22.04 251.42,22.04 251.74,22.35 251.74,23.32 v2(251.74,23.32) ; v2(150.87,72.58) 150.35,72.07 150.35,69.7 149.25,68.6 149.25,68.32 148.73,67.8 147.1,67.8 145.73,66.43 145.73,65.12 143.98,63.37 143.98,62.89 v2(143.08,61.99)
  IN4 w0.102: v2(124.65,64.93) 124.65,64.49 125.8,63.34 132.45,63.34 133.23,62.56 140.83,62.56 141.4,61.99 v2(143.08,61.99)
  BOTTOM w0.109: v2(280.16,72.47) 280.47,72.78 UV69.2
PROCHOT#_R: length 1.6
  TOP w0.109: PU700.10 67.12,23.63 66.92,23.83 PR718.2
PROCHOT#_R1: length 5.4
  TOP w0.109: UE1.H13 142.53,73.74 142.96,73.74 143.89,72.81 RE288.1 144.78,72.81 145.29,72.3 145.86,72.3 146.23,71.94 v1(147.09,71.94)
PS_ID: length 73.5
  TOP w0.109: v2(100.93,33.77) 99.78,33.77 v1(99.76,33.8) 98.99,34.56 PR10.1 PR12.2 ; UE1.J8 v2(138.81,72.48)
  IN3 w0.081: v2(138.81,72.48) 138.74,72.48 138.25,71.98 138.25,69.39 138.19,69.32 138.19,67.59 137.23,66.64 136.09,66.64 135.82,66.37 133.78,66.37 133.6,66.19 133.6,64.98 133.16,64.55 129.99,64.55 129.62,64.18 127.58,64.18 126.38,65.38 123.04,65.38 122.81,65.15 121.6,65.15 119.13,62.69 118.92,62.69 115.44,59.21 115.44,58.36 108.03,50.95 101.13,50.95 100.51,50.33 100.51,44.58 99.45,43.53 99.45,41.7 100.93,40.22 v2(100.93,33.77)
PSID_DISABLE#: length 88.9
  TOP w0.109: PR24.2 96.21,33.03 95.68,33.56 95.68,36 v1(96.09,36.4) 96.09,37.69 95.77,38.01 94.36,38.01 94.04,38.33 94.04,39.45 93.64,39.84 90.61,39.84 88.78,41.67 88.78,42.64 89.75,43.6 89.75,51.85 91.09,53.19 v2(97.36,53.19) ; UE1.D7 v2(137.27,77.22)
  IN3 w0.081: v2(137.27,77.22) 136.87,76.82 136.24,76.82 136.07,76.65 136.07,76.16 135.91,76.01 135.41,76.01 135.25,75.86 135.25,75.35 135.07,75.17 131.14,75.17 129.47,73.5 127.95,73.5 127.11,74.35 126.3,74.35 125.91,74.74 125.2,74.74 122.03,71.57 121.13,71.57 120.97,71.41 119.65,71.41 117.72,69.48 116.56,69.48 116.26,69.19 116.26,68.94 114.58,67.26 114.58,66.25 113.89,65.56 113.57,65.56 113.11,65.1 111.71,65.1 111.1,64.5 111.1,61.21 110.66,60.77 109.11,60.77 105.77,57.43 100.86,57.43 97.36,53.93 v2(97.36,53.19)
PTP_DISABLE#: length 179.8
  TOP w0.109: RE748.1 142.94,64.95 142.74,65.15 142.74,65.6 142.23,66.11 142.23,66.45 v2(142.52,66.74) 142.82,67.05 142.82,67.79 142.54,68.07 142.54,68.64 142.32,68.87 141.79,68.87 141.55,69.1 141.55,69.56 UE1.N12 ; RZ1484.2 28.19,3.88 v1(28.66,4.35) 31.51,7.19 31.51,8.14 30.81,8.84 29.92,8.84 v2(27.63,11.13)
  IN2 w0.081: v2(27.63,11.13) 28.91,11.13 29.35,11.56 31.51,11.56 33.62,9.45 34.6,9.45 34.84,9.69 34.84,11.14 35.95,12.25 35.95,14.05 38.96,17.06 42.47,17.06 43.08,16.44 47.49,16.44 47.7,16.65 51.16,16.65 52.68,15.13 54.2,15.13 55.56,16.49 56.41,16.49 56.92,15.98 56.92,15.56 57.33,15.14 58.98,15.14 60.61,13.51 74.45,13.51 80.31,19.37 84.48,19.37 85.19,20.08 87.67,20.08 88.36,20.77 88.36,22.61 90.17,24.42 93.62,24.42 94.49,25.29 96.27,25.29 97.5,26.52 97.5,27.46 98.71,28.66 100.1,28.66 101.04,29.61 102.32,29.61 v2(102.79,29.14)
  IN3 w0.081: v2(102.79,29.14) 103.34,28.59 106.72,28.59 107.56,29.43 107.56,30.59 108.77,31.8 108.77,33.28 109.2,33.71 109.2,35.76 110.19,36.75 110.19,42.82 111.48,44.11 111.48,53.76 114.04,56.32 116.49,56.32 117.31,57.14 117.31,57.39 123.24,63.31 125.83,63.31 127.66,61.48 130.2,61.48 131.49,62.78 133.73,62.78 134.47,63.51 135.56,63.51 136.15,64.1 138.6,64.1 139.47,64.97 140.74,64.97 v2(142.52,66.74)
PWM1_1PH/ICCMAX1: length 39.8
  TOP w0.203: v2(307.41,41.49) 307.08,41.49 306.83,41.75 PU1100.44
  TOP w0.254: PU1800.1 288.72,65.14 v2(288.9,64.96)
  BOTTOM w0.203: v2(288.9,64.96) 290.22,63.64 291.08,63.64 295.02,59.7 296.45,59.7 297.89,58.26 297.89,56.45 298.87,55.46 299.71,55.46 300.34,54.83 301.72,54.83 302.18,54.37 305.64,54.37 v1(306.28,53.73) 308.56,51.45 308.56,42.64 v2(307.41,41.49) 307.38,41.53 PR1120.1
PWM1_2PH/ICCMAX2: length 42.9
  TOP w0.203: PU1100.23 299.43,41.35 299.23,41.15 298.92,41.15 v2(298.5,40.73)
  TOP w0.254: v2(289.91,13.3) 290,13.39 PU1700.1
  BOTTOM w0.203: PR1152.1 298.52,40.86 298.52,40.76 v2(298.5,40.73)
  BOTTOM w0.254: v2(289.91,13.3) 289.91,13.86 290.19,14.14 294.35,14.14 298.84,18.63 298.84,20.86 297.7,22 v1(297.03,22) 295.84,22 292.94,24.91 292.94,27.95 293.82,28.84 293.82,32.02 297.99,36.18 297.99,40.22 v2(298.5,40.73)
PWM1_4PH/ICCMAX4: length 27.6
  TOP w0.203: PU1100.18 299.07,43.35 298.57,43.85 298.57,44.03 v2(298.32,44.28)
  TOP w0.254: PU1200.1 v2(290.75,55.14)
  BOTTOM w0.203: PR1155.1 298.76,44.72 v2(298.32,44.28)
  BOTTOM w0.254: PR1155.1 299.08,44.82 301.72,47.46 301.72,48.62 v1(302.56,49.46) 302.87,49.76 302.87,52.95 301.37,54.45 300.2,54.45 299.57,55.08 293.77,55.08 293.04,55.82 291.43,55.82 v2(290.75,55.14)
PWM2_2PH/ROSC1: length 2.6
  TOP w0.203: PR1171.1 298.09,41.8 298.21,41.8 298.4,41.61 v1(298.85,41.61) 299.18,41.61 299.32,41.75 PU1100.22
PWM2_4PH/ADDR: length 12.8
  TOP w0.203: v2(298.53,43.16) 298.74,43.16 298.96,42.95 PU1100.19
  TOP w0.254: PU1201.1 290.72,44.39 290.81,44.31 v2(290.84,44.31)
  IN1 w0.254: v2(290.84,44.31) 292.18,44.31 293.7,42.79 297.94,42.79 298.32,43.16 v2(298.53,43.16)
  BOTTOM w0.109: v1(297.96,42.87) 298.25,43.16 v2(298.53,43.16)
  BOTTOM w0.203: PR1156.1 298.62,43.07 v2(298.53,43.16)
PWM3_4PH/VBOOT: length 18.8
  TOP w0.203: PU1100.20 298.84,42.55 298.7,42.69 297.97,42.69 PR1157.1 297.84,43.27 298.02,43.45 v2(298.02,43.58)
  TOP w0.254: v2(290.8,34.51) 290.65,34.66 PU1202.1
  BOTTOM w0.254: v2(298.02,43.58) 297.03,42.59 v1(297.03,41.76) 297.03,36.69 296.24,35.91 291.75,35.91 290.8,34.95 v2(290.8,34.51)
PWM4_4PH/ROSCM: length 25.5
  TOP w0.203: v2(298.46,42.23) 298.54,42.15 PU1100.21
  TOP w0.305: v2(290.52,23.19) 290.4,23.32 290.4,23.38 290.16,23.61 PU1203.1
  BOTTOM w0.203: PR1158.1 299,42.23 v2(298.46,42.23)
  BOTTOM w0.254: v2(290.52,23.19) 290.52,23.5 v1(291.18,24.16) 292.43,25.4 292.43,28.21 293.19,28.97 293.19,32.02 297.53,36.36 297.53,41.3 v2(298.46,42.23)
PWM_FAN1: length 44.9
  TOP w0.109: v2(120.16,77.23) 120.29,77.23 120.78,76.75 121.08,76.75 121.84,75.99 121.84,73.65 v4(121.27,73.08) 121.13,72.94 119.86,72.94 119.25,73.55 RZ505.2 119.25,73.94 118.43,74.77 117.58,74.77 JFAN1.2 ; v2(140.41,70.88) UE1.L10
  IN4 w0.102: v2(140.41,70.88) 140.81,71.27 141.38,71.27 141.58,71.48 141.58,71.86 141.78,72.05 143.04,72.05 143.24,72.25 143.24,73.51 142.04,74.71 138.51,74.71 138.1,75.12 138.1,77.42 137.88,77.64 131.95,77.64 131.82,77.51 130.6,77.51 130.07,78.04 129.05,78.04 128.14,78.96 128.09,78.96 127.99,79.06 125.14,79.06 123.9,77.82 120.88,77.82 120.29,77.23 v2(120.16,77.23)
PWM_FAN2: length 309.6
  TOP w0.109: v2(141.21,70.88) UE1.L11 ; RZ504.2 v2(305.25,67.35) 305.81,67.91 307.19,67.91 308.38,69.1 308.38,69.71 307.95,70.14 307.95,71.24 307.33,71.85 JFAN2.2
  IN2 w0.081: v2(146.25,71.36) 147.42,72.53 149.32,72.53 150.44,73.65 154.56,73.65 154.86,73.95 157.77,73.95 158.07,73.65 160.78,73.65 162.14,72.3 v2(162.14,72.15)
  VCC w0.086: v2(162.14,72.15) 161.31,71.33 161.31,69.26 160.84,68.78 160.84,67.2 157.2,63.56 157.2,61.84 155.09,59.73 154.51,59.73 149.67,54.89 149.67,52.09 160.06,41.69 160.06,34.61 160.73,33.95 160.73,23.17 157.69,20.14 157.69,18.65 165.44,10.9 170.72,10.9 171.43,11.61 173.97,11.61 174.67,10.9 217.64,10.9 218.26,10.28 220.5,10.28 221.12,10.9 231.86,10.9 237.2,16.24 240.14,16.24 240.36,16.02 244.64,16.02 245.11,15.55 258.62,15.55 259.29,16.21 260.74,16.21 261.9,15.06 266.2,15.06 269.8,11.46 291.82,11.46 292.68,12.33 292.68,13.14 296.29,16.75 297.95,16.75 299.35,18.15 299.35,23.2 308.56,32.4 308.56,34.72 309.45,35.61 309.45,45.56 310.5,46.61 310.5,52.92 311.21,53.63 311.21,58.03 310.45,58.78 310.45,64.73 307.83,67.35 v2(305.25,67.35)
  IN4 w0.102: v2(146.25,71.36) 144.37,71.36 143.84,71.89 143.2,71.89 143.12,71.81 142.79,71.81 142.26,71.28 141.76,71.28 141.72,71.24 141.36,70.88 v2(141.21,70.88)
  BOTTOM w0.109: v2(305.25,67.35) v1(305.83,67.35)
REFCLK_CNV: length 110.2
  TOP w0.102: UH1.R6 138.47,45.99 138.61,45.99 138.82,46.21 v2(139.08,46.21)
  IN1 w0.102: v2(126.76,116.98) 126.16,116.38 126.16,108.83 126.66,108.32 130.73,108.32 131.03,108.61 132.16,108.61 132.65,108.12 132.65,103.65 133.04,103.26 133.04,102.43 132.32,101.71 132.32,100.12 135.05,97.39 135.05,96.41 137.07,94.39 137.07,92.06 133.33,88.32 133.33,82.01 132.18,80.86 132.01,80.86 v2(131.98,80.89)
  IN4 w0.102: v2(131.98,80.89) 132.01,80.86 132.77,80.86 133.63,80.01 134.49,80.01 135.52,81.04 139.43,81.04 139.98,80.48 141.93,80.48 142.65,81.2 142.94,81.2 143.33,80.81 144.19,80.81 145.57,79.44 145.57,78.3 148.11,75.76 148.11,73.76 148.66,73.21 148.66,70.58 147.99,69.9 147.99,68.19 149.17,67.01 149.17,64.85 148.16,63.83 145.74,63.83 143.9,61.99 143.9,58.67 141.46,56.24 138.45,56.24 137.32,55.11 137.32,52.05 137.97,51.4 137.97,48.3 138.94,47.34 138.94,46.34 v2(139.08,46.21)
  BOTTOM w0.109: v2(139.08,46.21) 138.8,46.48 RH110.2 ; RZ371.2 126.57,116.79 v2(126.76,116.98) 126.88,117.11 v1(127.42,117.11)
REG_OUT:
  vias: v1(14.55,20.21)
REM_DIODE1_N: length 339.5
  TOP w0.127: v2(310.06,34.75) 310.28,34.53 310.28,34 308.48,32.2 305.99,32.2 305.5,31.7 305.5,30.94 CE339.1 305.25,30.55 QE26.1 305.25,28.04 QE26.2 ; v2(138.22,82.36) 138.07,82.21 138.07,81.97 CE24.1 138,81.33 138,80.88 138.17,80.71 138.17,79.52 UE1.A8
  IN1 w0.127: v2(242.99,59.9) 242.8,60.09 240.82,60.09 240.23,60.68 240.23,61.32 239.87,61.68 239.6,61.68 239.43,61.84 239.03,61.84 238.81,62.06 238.81,62.27 238.71,62.37 238.71,63.17 237.73,64.15 236.82,64.15 236.11,64.86 236.11,68.21 238.14,70.23 238.14,72.34 234.96,75.51 234.96,76.24 v2(234.73,76.47)
  IN3 w0.127: v2(310.06,34.75) 310.28,34.52 310.28,33.9 310.83,33.35 313.58,33.35 316.49,36.26 317.31,36.26 318.8,37.75 318.8,42.47 320.44,44.11 323.13,44.11 324.1,43.14 339.06,43.14 342.2,46.28 342.2,56.22 339.93,58.49 338.57,58.49 337.57,59.48 326.79,59.48 326.08,60.19 322.92,60.19 319.38,63.73 319.38,65.65 314.4,70.63 314.4,74.54 309.55,79.39 306.52,79.39 304.92,80.99 304.92,82.51 304.44,83 303.17,83 302.89,82.72 299.31,82.72 297.94,84.09 297.94,85.79 297.18,86.55 292.91,86.55 290.6,84.24 288,84.24 287.48,84.75 284.18,84.75 283.33,85.61 279.85,85.61 278.71,84.47 272.16,84.47 271.44,83.76 269.48,83.76 268.51,82.79 259.62,82.79 258.66,81.83 253.52,81.83 252.33,83.02 243.16,83.02 242.34,83.83 235.43,83.83 234.62,83.03 234.62,81.98 234.96,81.63 234.96,76.7 v2(234.73,76.47) 235,76.21 235,76.03 234.73,75.76 234.4,75.76 233.73,76.43 233.73,81.24 231.81,83.15 222.64,83.15 222.32,83.47 219.42,83.47 217.58,85.31 195.91,85.31 194.87,86.35 183.29,86.35 182.5,87.14 180.09,87.14 178.59,88.64 175.22,88.64 173.77,87.19 170.17,87.19 167.17,84.19 154.73,84.19 154,83.45 147.24,83.45 146.6,82.82 143.35,82.82 141.95,81.42 140.34,81.42 140.21,81.29 138.25,81.29 137.94,81.6 137.94,82.08 v2(138.22,82.36)
  BOTTOM w0.127: CE35.2 245.03,59.87 QE3.3 242.99,59.87 v2(242.99,59.9)
REM_DIODE1_P: length 339.9
  TOP w0.127: UE1.A7 137.92,79.53 137.92,80.6 137.74,80.78 137.74,81.38 CE24.2 137.69,81.94 137.69,82.19 v2(137.51,82.36) ; QE26.3 305.9,30.43 CE339.2 305.75,30.96 305.75,31.6 306.1,31.94 308.58,31.94 310.53,33.89 310.53,34.51 v2(310.77,34.75)
  IN1 w0.127: v2(242.99,60.48) 242.85,60.34 240.93,60.34 240.48,60.78 240.48,61.42 239.98,61.93 239.7,61.93 239.57,62.06 239.57,62.38 239.35,62.6 239.27,62.6 238.97,62.9 238.97,63.28 237.84,64.4 236.93,64.4 236.37,64.97 236.37,68.1 238.39,70.12 238.39,72.45 235.22,75.62 235.22,76.24 v2(235.45,76.47)
  IN3 w0.127: v2(137.51,82.36) 137.69,82.18 137.69,81.5 138.14,81.04 140.32,81.04 140.44,81.17 142.06,81.17 143.06,82.17 143.46,82.56 146.71,82.56 147.34,83.2 154.1,83.2 154.84,83.93 167.28,83.93 170.28,86.93 173.88,86.93 175.33,88.38 178.48,88.38 179.98,86.88 182.4,86.88 183.18,86.1 194.76,86.1 195.8,85.05 217.48,85.05 219.32,83.22 222.22,83.22 222.53,82.9 231.7,82.9 233.47,81.13 233.47,76.32 234.29,75.5 234.83,75.5 235.25,75.92 235.25,76.28 v2(235.45,76.47) 235.22,76.7 235.22,81.74 234.87,82.08 234.87,82.92 235.53,83.58 242.24,83.58 243.05,82.77 252.22,82.77 253.41,81.57 258.77,81.57 259.73,82.53 268.61,82.53 269.59,83.5 271.55,83.5 272.26,84.22 278.81,84.22 279.96,85.36 283.22,85.36 284.08,84.5 287.38,84.5 287.89,83.99 290.71,83.99 293.02,86.3 297.07,86.3 297.69,85.69 297.69,83.98 299.21,82.46 303,82.46 303.28,82.74 304.34,82.74 304.67,82.41 304.67,80.88 306.42,79.14 309.45,79.14 314.14,74.44 314.14,70.52 319.12,65.54 319.12,63.63 322.82,59.93 325.98,59.93 326.68,59.23 337.46,59.23 338.46,58.23 339.82,58.23 341.94,56.11 341.94,46.38 338.96,43.4 324.2,43.4 323.24,44.36 320.33,44.36 318.55,42.58 318.55,37.86 317.2,36.51 316.39,36.51 313.48,33.6 310.94,33.6 310.54,34.01 310.54,34.52 v2(310.77,34.75)
  BOTTOM w0.127: v2(242.99,60.48) 242.95,60.52 QE3.1 242.11,60.7 242.58,61.17 QE3.2 244.85,61.17 CE35.1
REM_DIODE2_N: length 286.1
  TOP w0.127: UE1.A10 139.66,79.63 139.66,80.28 140.05,80.67 140.05,81.35 140.06,81.36 140.06,81.37 CE26.1 140.03,82.04 140.03,82.1 v2(140.29,82.36)
  IN3 w0.127: v2(140.29,82.36) 140.27,82.36 140.05,82.58 140.05,82.69 140.21,82.86 142.65,82.86 143.25,83.45 143.75,83.45 144.62,84.32 153.04,84.32 153.45,84.72 165.85,84.72 168.85,87.72 173.59,87.72 175.01,89.14 178.8,89.14 180.55,87.39 183.2,87.39 183.76,86.83 195.79,86.83 196.49,86.13 218.02,86.13 219.86,84.29 222.25,84.29 222.77,83.78 231.82,83.78 232.41,84.37 242.74,84.37 243.32,83.78 252.72,83.78 253.99,82.52 257.99,82.52 259,83.53 268.28,83.53 269.16,84.42 271.24,84.42 271.8,84.98 275.89,84.98 276.83,85.92 278.91,85.92 279.19,86.2 283.01,86.2 283.41,86.6 283.41,87.26 284.29,88.14 285.92,88.14 289.17,84.89 290.41,84.89 292.61,87.09 298.09,87.09 299.67,85.5 299.67,84.48 300.23,83.93 301.28,83.93 301.49,84.14 306.24,84.14 314.96,75.43 314.96,71.16 320.55,65.57 320.55,63.5 323.27,60.77 327.33,60.77 328.09,61.53 335.12,61.53 336.54,60.11 339.54,60.11 342.96,56.69 342.96,45.6 339.82,42.46 323.44,42.46 322.65,43.25 320.36,43.25 319.66,42.54 319.66,36.12 318.72,35.18 318.21,35.18 v2(318,35.4)
  BOTTOM w0.127: QE7.1 313.83,35.82 QE7.2 315.4,35.5 CE46.2 316.88,35.17 317.39,35.17 317.62,35.4 v2(318,35.4)
REM_DIODE2_P: length 285
  TOP w0.127: UE1.A9 139.39,79.4 139.39,79.5 139.41,79.52 139.41,80.39 139.8,80.78 139.8,81.36 CE26.2 139.77,82 139.77,82.16 v2(139.57,82.36)
  IN3 w0.127: v2(139.57,82.36) 139.73,82.36 139.79,82.43 139.79,82.8 140.11,83.11 142.55,83.11 143.14,83.71 143.65,83.71 144.51,84.57 152.94,84.57 153.34,84.98 165.75,84.98 168.74,87.98 173.48,87.98 174.9,89.4 178.9,89.4 180.66,87.64 183.31,87.64 183.87,87.09 195.9,87.09 196.6,86.39 218.13,86.39 219.97,84.55 222.36,84.55 222.88,84.03 231.71,84.03 232.31,84.62 242.84,84.62 243.43,84.04 252.83,84.04 254.1,82.77 257.88,82.77 258.9,83.79 268.17,83.79 269.05,84.67 271.14,84.67 271.7,85.23 275.79,85.23 276.73,86.17 278.81,86.17 279.09,86.45 282.9,86.45 283.16,86.71 283.16,87.37 284.18,88.39 286.03,88.39 289.28,85.14 290.3,85.14 292.5,87.34 298.19,87.34 299.93,85.61 299.93,84.59 300.33,84.19 301.17,84.19 301.38,84.39 306.35,84.39 315.21,75.53 315.21,71.26 320.8,65.67 320.8,63.6 323.38,61.03 327.23,61.03 327.99,61.79 335.23,61.79 336.65,60.37 339.65,60.37 343.22,56.79 343.22,45.5 339.93,42.2 323.34,42.2 322.54,43 320.47,43 319.91,42.44 319.91,36.01 318.82,34.93 318.21,34.93 318,34.71 v2(318,34.69)
  BOTTOM w0.127: v2(318,34.69) 317.62,34.69 317.39,34.92 316.88,34.92 CE46.1 316.48,34.52 QE7.3
REM_DIODE3_N: length 113.4
  TOP w0.076: UE1.B9 138.92,78.77 138.92,81 139.01,81.08 139.01,82.82 139.14,82.95
  TOP w0.127: v2(157.95,25.9) 157.95,26.19 158.08,26.32 158.19,26.32 158.38,26.14 158.38,25.1 155.52,22.24 152.79,22.24 147.95,17.4 146.94,17.4 146.86,17.48 146.86,17.61 CE272.2 147.03,18.14 QE104.3 ; v2(139.55,84.43) 139.35,84.23 139.35,83.93 139.05,83.63 139.05,83.49 CE270.1 139.34,83.15 139.14,82.95
  IN1 w0.127: v2(161.43,68.33) 161.18,68.09 161.11,68.09 160.26,68.94 160.26,71.37 159.7,71.93 159.7,73.34 160.12,73.76 160.12,74.51 159.61,75.02 159.61,76.44 157.38,78.67 156.27,78.67 v2(156.02,78.92)
  IN3 w0.127: v2(161.43,68.33) 161.68,68.08 161.85,68.08 162.32,68.55 162.32,69.12 162.98,69.78 164.66,69.78 166.09,68.36 166.09,64.29 164.01,62.21 161.67,62.21 159.7,60.23 159.7,44.65 159.01,43.96 159.01,27.3 157.95,26.24 v2(157.95,25.9)
  BOTTOM w0.127: v2(156.02,78.92) 155.77,78.67 155.57,78.67 154.94,79.3 150.16,79.3 149.6,78.74 146.96,78.74 144.68,81.02 143.66,81.02 141.2,83.49 139.75,83.49 139.29,83.95 139.29,84.17 v2(139.55,84.43)
REM_DIODE3_P: length 117
  TOP w0.076: UE1.B8 138.76,78.77 138.76,81.06 138.85,81.15 138.85,82.78 138.76,82.87
  TOP w0.127: v2(157.44,26.4) 157.81,26.4 157.98,26.58 158.3,26.58 158.63,26.24 158.63,25 155.62,21.99 152.9,21.99 148.06,17.15 146.84,17.15 146.61,17.37 146.61,17.65 CE272.1 146.3,18.3 145.73,18.87 QE104.2 145.73,20.63 QE104.1 ; 138.76,82.87 CE270.2 138.8,83.57 138.8,83.73 139.1,84.03 139.1,84.16 v2(138.83,84.43)
  IN1 w0.127: v2(156.02,78.2) 156.23,78.42 157.27,78.42 159.35,76.33 159.35,74.92 159.87,74.41 159.87,73.87 159.44,73.45 159.44,71.83 160.01,71.26 160.01,68.83 161,67.84 161.21,67.84 v2(161.43,67.62)
  IN3 w0.127: v2(161.43,67.62) 161.64,67.83 161.96,67.83 162.57,68.44 162.57,69.02 163.08,69.53 164.56,69.53 165.83,68.25 165.83,64.39 163.9,62.46 161.56,62.46 159.44,60.34 159.44,44.75 158.76,44.07 158.76,27.41 157.76,26.4 v2(157.44,26.4)
  BOTTOM w0.127: v2(138.83,84.43) 139.04,84.22 139.04,83.84 139.64,83.23 141.1,83.23 143.56,80.77 144.57,80.77 146.86,78.48 149.7,78.48 150.26,79.04 154.84,79.04 155.46,78.42 155.8,78.42 v2(156.02,78.2)
REM_DIODE4_N: length 54.4
  TOP w0.127: v2(145.23,93.87) 144.98,93.61 144.98,90.9 145.56,90.31 148.14,90.31 150.57,87.88 150.57,85.09 148.44,82.96 v3(148.44,82.49) 148.44,81.95 147.17,80.68 143.39,80.68 142.89,81.19 142.89,82.27 142.75,82.41 142.3,82.41 141.93,82.04 141.93,81.92 CE27.1 141.83,81.36 141.83,80.45 141.53,80.15 141.36,80.15 140.71,79.5 140.71,79.38 UE1.A11
  BOTTOM w0.127: v2(145.23,93.87) 145,94.1 145,94.42 145.15,94.57 147.58,94.57 147.97,94.95 149.54,94.95 152.12,97.53 153.6,97.53 153.98,97.14 155.01,97.14 159.27,101.4 162.71,101.4 CE39.2 163.71,102.39 QE6.3
REM_DIODE4_P: length 55.2
  TOP w0.127: UE1.B10 140.46,78.87 140.46,79.61 141.26,80.41 141.42,80.41 141.58,80.56 141.58,81.36 CE27.2 141.31,81.69 141.68,82.06 141.68,82.15 142.2,82.67 142.85,82.67 143.14,82.38 143.14,81.29 143.5,80.94 147.07,80.94 148.18,82.05 148.18,83.06 150.31,85.19 150.31,87.78 148.04,90.06 145.46,90.06 144.73,90.79 144.73,93.66 v2(144.52,93.87)
  BOTTOM w0.127: QE6.2 162.41,103.66 QE6.1 163.06,102.66 CE39.1 162.05,101.65 159.16,101.65 154.91,97.4 154.09,97.4 153.71,97.78 152.02,97.78 149.44,95.2 147.86,95.2 147.48,94.82 145.04,94.82 144.75,94.53 144.75,94.1 v2(144.52,93.87)
RES_BIAS: length 2.4
  TOP w0.109: UL1.12 156.64,142.03 v1(157.27,142.66) 157.49,142.88 RL13.1
RESET_IN#: length 4.5
  TOP w0.109: RE362.1 130.82,80.39 131.02,80.19 132,80.19 132.18,80.01 132.18,78.31 UE1.C1
RF_+1VSP: length 1.9
  TOP w0.254: PU800.5 109.39,28.26 PR804.1
RING2: length 3.9
  IN1 w1.016: 389.63,19.95 389.63,21.94 388.97,22.6 388.72,22.6
  BOTTOM w0.109: v2(389.74,18.68) v1(389.74,19.43)
  vias: v2(387.42,22.82) v2(388.06,22.87) v2(390.32,18.51)
RING2_R: length 14.9
  IN1 w1.016: 395.04,19.53 395.04,21.02 397.06,23.04 401.06,23.04 403.92,25.9 JHP1.3
  vias: v2(392.17,16.77) v2(392.67,17.1) v2(393.25,19.13) v2(393.89,19.13) v4(394.69,18.58)
RJ45_MDIN0: length 42.4
  BOTTOM w0.267: JLOM1.2 143.2,162.49 142.99,162.28 142.78,162.28 142.55,162.05 142.55,161.19 144.3,159.45 144.3,158.15 145.02,157.43 v3(153.54,157.43) 161.13,157.43 162.19,158.49 162.19,171.29 161.11,172.37 160.39,172.37 159.48,171.46 TL1.23
