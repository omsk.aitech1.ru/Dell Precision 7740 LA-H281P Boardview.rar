# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_CHASSIS: length 25
  TOP w0.508: RL18.2 160.07,170.21 160.47,169.8 160.47,169.41 ; RL17.2 159.78,162.59 160.47,161.89 ; 160.47,169.41 160.68,169.2 160.68,168.37 159.79,167.48 159.79,163.79 160.68,162.91 160.68,162.09 160.47,161.89 ; 160.47,169.41 160.01,168.94 RL16.2 ; RL15.2 159.9,161.32 160.47,161.89 ; 160.47,161.89 160.49,161.89 160.94,161.44 160.94,160.72 160.47,160.26 v1(160.47,156.78) 160.47,155.72 v2(161.62,154.57)
  BOTTOM w0.508: v2(161.62,154.57) 162.63,155.59 CL22.2
GNDA: length 128.5
  TOP w0.109: v4(388.47,20.03) 388.47,19.73 v2(387.8,19.06) ; v2(388.44,24.78) 389.37,24.78 v4(389.57,24.58) ; 386.99,15.28 388.26,15.28 v4(388.41,15.13)
  TOP w0.381: CA8.2 383.91,28.4 v2(383.99,28.31) ; CA49.1 CA233.1 v2(387.8,19.06)
  TOP w0.508: v2(384.95,31.64) CA9.2 384.95,29.75 CA51.1 ; RA44.1 385.9,30.62 v2(386.15,30.88) 386.18,30.9 RA222.2 ; CA25.1 388.25,24.3 388.44,24.49 v2(388.44,24.78)
  GND1 w0.203: JHP1.7 403.09,16.91 ; JHP1.7 403.09,18.29 ; JHP1.7 400.81,18.29 ; JHP1.7 400.81,16.91 ; JHP1.7 401.95,16.91 ; JHP1.7 403.09,17.6 ; JHP1.7 401.95,18.29 ; JHP1.7 400.81,17.6 ; 400.81,26.8 JHP1.8 ; JHP1.8 400.81,26.11 ; JHP1.8 401.95,26.11 ; JHP1.8 403.09,26.11 ; JHP1.8 403.09,26.8 ; JHP1.8 401.95,27.49 ; JHP1.8 403.09,27.49 ; JHP1.8 400.81,27.49
  GND2 w0.254: JHP1.8 403.09,26.11 ; JHP1.8 401.95,27.49 ; JHP1.8 401.95,26.11 ; JHP1.8 400.81,26.8 ; JHP1.8 403.09,26.8 ; JHP1.8 403.09,27.49 ; JHP1.8 400.81,27.49 ; JHP1.8 400.81,26.11 ; 400.81,17.6 JHP1.7 ; JHP1.7 400.81,16.91 ; JHP1.7 400.81,18.29 ; JHP1.7 403.09,18.29 ; JHP1.7 401.95,18.29 ; JHP1.7 403.09,17.6 ; JHP1.7 401.95,16.91 ; JHP1.7 403.09,16.91
  GND3 w0.254: JHP1.7 403.09,16.91 ; JHP1.7 403.09,18.29 ; JHP1.7 400.81,16.91 ; JHP1.7 401.95,16.91 ; JHP1.7 403.09,17.6 ; JHP1.7 401.95,18.29 ; JHP1.7 400.81,18.29 ; JHP1.7 400.81,17.6 ; 400.81,26.8 JHP1.8 ; JHP1.8 400.81,26.11 ; JHP1.8 401.95,27.49 ; JHP1.8 403.09,26.11 ; JHP1.8 403.09,27.49 ; JHP1.8 401.95,26.11 ; JHP1.8 400.81,27.49 ; JHP1.8 403.09,26.8
  VCC w0.203: 400.81,26.11 JHP1.8 ; JHP1.8 400.81,26.8 ; JHP1.8 400.81,27.49 ; JHP1.8 403.09,27.49 ; JHP1.8 403.09,26.8 ; JHP1.8 401.95,26.11 ; JHP1.8 401.95,27.49 ; JHP1.8 403.09,26.11 ; JHP1.7 403.09,16.91 ; JHP1.7 403.09,17.6 ; JHP1.7 401.95,16.91 ; JHP1.7 400.81,17.6 ; JHP1.7 401.95,18.29 ; JHP1.7 400.81,16.91 ; JHP1.7 400.81,18.29 ; JHP1.7 403.09,18.29
  GND4 w0.254: 401.95,26.11 JHP1.8 ; JHP1.8 400.81,27.49 ; JHP1.8 401.95,27.49 ; JHP1.8 400.81,26.11 ; JHP1.8 400.81,26.8 ; JHP1.8 403.09,27.49 ; JHP1.8 403.09,26.8 ; JHP1.8 403.09,26.11 ; 401.95,16.91 JHP1.7 ; JHP1.7 400.81,18.29 ; JHP1.7 400.81,17.6 ; JHP1.7 400.81,16.91 ; JHP1.7 401.95,18.29 ; JHP1.7 403.09,16.91 ; JHP1.7 403.09,17.6 ; JHP1.7 403.09,18.29
  GND5 w0.203: JHP1.8 403.09,26.11 ; JHP1.8 403.09,27.49 ; JHP1.8 400.81,26.8 ; JHP1.8 403.09,26.8 ; JHP1.8 401.95,27.49 ; JHP1.8 400.81,26.11 ; JHP1.8 400.81,27.49 ; JHP1.8 401.95,26.11 ; 400.81,16.91 JHP1.7 ; JHP1.7 403.09,17.6 ; JHP1.7 403.09,18.29 ; JHP1.7 401.95,16.91 ; JHP1.7 400.81,17.6 ; JHP1.7 403.09,16.91 ; JHP1.7 400.81,18.29 ; JHP1.7 401.95,18.29
  BOTTOM w0.381: CA35.1 386.27,30.76 v2(386.15,30.88)
  BOTTOM w0.508: v2(384.95,31.64) 384.66,31.93 RA226.2 ; v2(387.8,19.06) 387.37,19.5 CA225.2 CA224.2 387.37,22.11 v2(387.35,22.14) ; CA3.2 394.5,24.78 v2(394.94,24.34) 394.52,23.92 CA2.2 ; v2(383.87,15.25) 383.31,14.7 RA221.2 ; RA223.2 v2(389.01,29.1) ; v2(395.32,15.04) 395.07,14.79 RA227.2
  vias: v2(383.45,18.73) v2(383.87,18.29) v2(384.4,26.46) v2(384.76,16.14) v2(384.71,15.39) v2(384.82,26.88) v2(385.82,16.3)
GNDA_CHG: length 4.7
  TOP w0.254: PR716.2 70.94,28.09 PC709.2 v2(70.19,29.58)
  TOP w0.381: PC718.1 72.7,19.84 v2(72.34,20.21) ; PC720.2 70.24,20.09 v2(70.33,20.18)
  TOP w0.508: PR709.2 v2(69.29,26.42)
  BOTTOM w0.109: v2(67.04,27.53) v1(66.46,27.53)
  vias: v2(66.87,26.93) v2(69.01,24.3) v2(69.01,22.16) v2(70.08,23.23) v2(71.15,24.3) v2(71.15,22.16)
VBUS1_ACOK: length 12.7
  TOP w0.109: PQ2006.6 50.39,20.41 50.57,20.59 50.57,20.88 50.39,21.06 PQ2006.5 49.51,21.06 v2(49.35,21.22)
  BOTTOM w0.109: v2(49.35,21.22) 49.49,21.36 PC2011.1 ; PC2011.1 49.86,20.94 v1(49.86,20.36) 49.86,19.78 PR2024.1 50.65,19.4 50.82,19.57 52.65,19.57 53.03,19.95 54.11,19.95 PR2030.2 ; PC2011.1 51.05,20.59 51.38,20.59 51.47,20.68 PU2001.1
VBUS1_ACOK#: length 8.3
  TOP w0.109: 54.44,21.3 54.87,20.87 v1(54.87,19.52)
  TOP w0.254: PQ2004.5 54.52,21.3 55.04,21.82 55.04,22.63 54.48,23.19 52.37,23.19 PR2025.1 51.92,22.74 PQ2006.3
VBUS1_ECOK: length 122.1
  TOP w0.109: v2(64.77,15.13) 64.77,14.8 v1(64.36,14.38) 63.34,14.38 PR2003.1 62.58,16.1 PQ2002.2 ; UE1.M6 v2(136.47,70.08)
  TOP w0.254: v2(85.53,26.41) 85.99,26.41 86.33,26.07 PR74.1 85.96,25.44 PR17.2
  IN1 w0.109: v2(64.77,15.13) 64.95,15.13 65.94,16.12 65.94,20.33 66.57,20.97 67.98,20.97 68.5,20.44 68.5,19.74 68.75,19.49 74.73,19.49 75.58,20.34 75.58,21.42 75.79,21.63 78.65,21.63 82.15,25.13 84.52,25.13 85.53,26.14 v2(85.53,26.41) 85.8,26.41 86.24,26.85 87.01,26.85 87.9,27.73 93.77,27.73 95.21,29.17 97.66,29.17 98.3,29.81 v2(98.3,30.52)
  IN3 w0.081: v2(136.47,70.08) 136.47,69.91 135.89,69.33 135.46,69.33 135.12,69 135.12,68.57 135.25,68.44 135.25,68.08 134.99,67.82 133.04,67.82 132.77,67.54 132,67.54 131.18,66.72 130.56,66.72 130.21,67.07 128.96,67.07 128.48,66.6 127.78,66.6 127.03,67.35 122.6,67.35 122.5,67.25 121.62,67.25 120.1,65.73 119.58,65.73 118.88,65.03 117.88,65.03 116.64,63.8 116.64,63.12 115.54,62.02 115.54,61.6 113.38,59.44 113.38,57.86 107.64,52.12 100.63,52.12 99.36,50.86 99.36,45.01 98.35,44 98.35,39.99 99.64,38.71 99.64,31.86 v2(98.3,30.52)
VBUS2_ACOK: length 8.7
  BOTTOM w0.254: PU2001.7 52.12,16.56 51.63,16.06 50.82,16.06 50.44,15.68 PR2028.1
  BOTTOM w0.305: PU2001.7 52.12,18.13 52.43,18.43 54.05,18.43 54.19,18.57 PR2031.2
  BOTTOM w0.381: PR2028.1 49.61,15.12 PC2014.1 49.56,15.27 49.87,15.58 49.87,15.59 49.92,15.64 v2(49.92,15.83)
  vias: v1(51.19,14.52)
VBUS2_ACOK#: length 3.7
  TOP w0.109: v1(52.56,19.31) 52.56,18.93 52.96,18.53 PR2029.1 52.86,18.09 PQ2012.3 53.23,17.1 53.7,17.57 PQ2005.5
VBUS2_ECOK: length 121.8
  TOP w0.109: UE1.N3 134.37,69.58 v2(134.37,68.71) ; PQ2004.2 57.13,21.3 PR2010.1 v2(57.86,21.26)
  TOP w0.254: v2(56.69,25.01) 56.55,24.87 PR38.2 PR75.1
  IN1 w0.102: v2(57.86,21.26) 58.07,21.48 60.17,21.48 62.86,24.17 65.22,24.17 66.27,25.21 71.7,25.21 72.27,24.64 74.11,24.64 74.61,24.14 78.08,24.14 81.07,27.14 82.51,27.14 84.19,28.82 86,28.82 87.98,30.8 88.05,30.8 90.46,33.21 90.46,33.69 91.1,34.33 92.26,34.33 92.31,34.28 95.1,34.28 96.52,32.86 98.93,32.86 v2(99.22,33.14)
  IN3 w0.081: v2(134.37,68.71) 133.66,68.71 132.69,67.74 131.87,67.74 131.08,66.95 130.65,66.95 130.31,67.3 128.86,67.3 128.39,66.83 127.94,66.83 127.19,67.57 123.08,67.57 122.43,68.21 121.21,68.21 120.33,67.33 120.33,66.78 118.8,65.24 117.79,65.24 116.43,63.88 116.43,63.2 115.33,62.1 115.33,61.71 113.16,59.54 113.16,57.93 107.58,52.35 100.48,52.35 99.13,51 99.13,45.11 98.14,44.12 98.14,34.21 v2(99.22,33.14)
  BOTTOM w0.109: v2(56.69,25.01) 56.89,24.81 v1(56.89,22.02) 57.65,21.26 v2(57.86,21.26)
VBUS3_ECOK: length 159.7
  TOP w0.109: PQ2005.2 55.9,17.55 PR2018.1 56.84,16.93 v2(56.86,16.9) ; v2(143.17,75.28) 143.14,75.25 UE1.F13
  IN1 w0.102: v2(56.86,16.9) 56.84,16.93 56.84,19.51 58.48,21.15 60.25,21.15 63.04,23.94 65.32,23.94 66.36,24.98 71.6,24.98 72.17,24.41 74.02,24.41 74.52,23.92 78.29,23.92 81.19,26.82 82.52,26.82 84.29,28.59 86.13,28.59 87.5,29.97 v2(87.72,29.97)
  IN3 w0.081: v2(87.72,29.97) 87.72,31.01 88.69,31.97 94.6,31.97 97.53,29.05 101.34,29.05 102.22,28.17 108.3,28.17 108.74,28.61 108.74,31.18 109.33,31.77 110.37,31.77 111.05,32.45 111.05,42.48 112.31,43.74 112.31,53.33 114.41,55.43 116.86,55.43 118.34,56.9 118.34,57.23 121.45,60.34 132.22,60.34 133.51,61.64 134.21,61.64 134.74,62.17 139.01,62.17 139.72,62.88 141.72,62.88 142.4,63.56 142.4,64.86 144.07,66.53 144.07,67.03 145.57,68.53 145.57,72.33 144.77,73.13 144.77,74.07 143.99,74.84 143.94,74.84 143.5,75.28 v2(143.17,75.28)
  IN4 w0.102: v2(56.86,16.9) 56.86,16.91 56.81,16.91 55.34,18.37 55.34,22.69 54.9,23.13 54.9,23.9 54.62,24.18 54.62,25.19 55.17,25.74 55.17,30.05 54.25,30.97 v2(54.25,31.9)
  BOTTOM w0.109: v2(54.25,31.9) 54.62,32.27 PR76.1 54.62,32.53 PR53.2 ; v2(56.86,16.9) v1(56.41,16.44)
VBUS_C_CTRL_P1#: length 94.3
  TOP w0.109: v1(20.77,41.62) 20.03,41.62 19.63,41.23 19.63,40.78 v2(19.12,40.27) ; v2(49.35,32.51) 49.35,32.51 49.35,33.23 49.53,33.4 PD14.3
  TOP w0.254: PQ2006.2 52.42,21.06 52.62,21.27 52.62,22.67 v2(52.66,22.71)
  IN1 w0.102: v2(19.12,40.27) 19.07,40.22 17.24,40.22 16.26,39.24 13.26,39.24 10.61,36.59 10.61,30.26 16.22,24.66 21.27,24.66 22.16,23.76 23.87,23.76 24.68,22.95 26.33,22.95 26.71,23.33 35.41,23.33 35.73,23.01 36.52,23.01 36.78,22.76 36.78,20.72 v2(36.9,20.59) 38.39,22.07 38.39,22.53 38.87,23.01 40.28,23.01 40.66,22.63 42.03,22.63 45.55,26.15 47.27,26.15 47.71,25.71 47.71,24.08 47.88,23.92 49.86,23.92 50.12,23.66 51.7,23.66 v2(52.66,22.71)
  IN4 w0.102: v2(49.35,32.51) 49.35,32.32 53.16,28.51 53.16,23.21 v2(52.66,22.71)
  BOTTOM w0.076: 19.28,35.97 19.28,35.42 UT5.K4
  BOTTOM w0.109: v2(19.12,40.27) 19.55,39.85 19.55,38.54 19.28,38.27 RT521.2 19.19,37.82 19.23,37.77 19.23,36.02 19.28,35.97 ; v2(36.9,20.59) 37.46,20.59 38.17,19.88 PQ2008.2
VBUS_C_CTRL_P2: length 1.6
  BOTTOM w0.109: v1(44.92,20.81) 44.88,20.86 43.94,21.8 43.91,21.8 43.8,21.69 PR2064.2
VBUS_C_CTRL_P2#: length 86.7
  TOP w0.109: PD15.3 47.43,35.18 47.51,35.26 v2(48.02,35.26) ; PQ2012.2 53.35,16.45 53.47,16.33 v2(53.94,16.33)
  IN1 w0.102: v2(40.18,19.75) 40.13,19.8 40.13,20.18 39.72,20.59 39.46,20.59 38.24,19.37 31.26,19.37 29.54,21.1 27,21.1 25.6,22.49 24.23,22.49 23.27,21.53 22.06,21.53 20.9,22.69 20.9,23.98 20.68,24.2 18.97,24.2 17.51,22.75 16.03,22.75 15.75,23.03 15.75,24.02 v2(15.19,24.58)
  IN3 w0.081: v2(40.18,19.75) 40.31,19.75 41.76,21.2 46.25,21.2 46.91,20.54 46.91,18.68 46.4,18.18 46.4,17.01 46.66,16.75 53.04,16.75 53.47,16.33 v2(53.94,16.33)
  IN4 w0.102: v2(48.02,35.26) 48.02,34.42 49.79,32.64 49.79,32.2 53.39,28.6 53.39,24.37 54.09,23.68 54.21,23.55 54.21,22.85 54.66,22.4 54.66,18.21 53.94,17.49 v2(53.94,16.33)
  BOTTOM w0.076: 19.29,30.38 19.29,30.93 UT5.B5
  BOTTOM w0.109: v2(15.19,24.58) 15.87,24.58 16.24,24.95 v1(16.24,25.55) RT522.2 16.81,27 17.28,27 17.47,27.19 17.47,27.87 19.29,29.68 19.29,30.38 ; v2(40.18,19.75) 40.18,19.8 40.59,20.21 42.02,20.21 42.14,20.09 PQ2009.2
VCC_GT_SENSE: length 65.1
  TOP w0.109: UC1.AH38 258.07,47.94 258.58,47.94 258.8,47.72 259.62,47.72 v2(259.86,47.96)
  TOP w0.203: PR1124.1 v2(260.35,41.41) ; PR1126.2 307.54,33.93 307.54,33.28 v2(307.73,33.1)
  IN1 w0.152: v2(307.73,33.1) 307.51,33.32 307.51,34.25 307.1,34.66 303.4,34.66 298.24,39.82 295.21,39.82 292.55,42.48 287.47,42.48 287.32,42.64 277.95,42.64 276.5,41.19 260.57,41.19 v2(260.35,41.41)
  IN4 w0.152: v2(260.35,41.41) 260.35,41.29 260.21,41.15 259.9,41.15 259.78,41.27 259.78,43.17 260.73,44.12 260.73,47.37 260.39,47.71 260.1,47.71 v2(259.86,47.96)
VCC_IO_SENSE: length 80.4
  TOP w0.109: v2(239.99,63.73) 240.37,63.35 UC1.H14
  TOP w0.152: v2(308.96,64.54) 308.73,64.31 308.34,64.31 PR306.2
  IN1 w0.203: v2(239.99,63.73) 240.29,63.44 244.26,63.44 244.59,63.11 249.9,63.11 250.24,62.77 250.24,61.28 250.71,60.81 251.85,60.81 252.38,60.28 252.38,58.7 252.96,58.11 258.47,58.11 258.95,58.6 258.95,61.42 259.62,62.09 260.88,62.09 261.16,61.82 264.45,61.82 265.96,63.32 272.17,63.32 272.79,62.71 273.86,62.71 v2(274.06,62.91)
  IN2 w0.152: v2(274.06,62.91) 274.28,62.69 275.85,62.69 276.43,62.12 278.33,62.12 279.07,62.85 296.24,62.85 297.49,64.1 307.91,64.1 308.12,64.32 308.73,64.32 v2(308.96,64.54)
VCC_SA_SENSE: length 63.9
  TOP w0.109: 258.47,60.72 258.07,60.72 UC1.M38
  TOP w0.152: v2(307.54,51.03) 307.54,51.06 307.74,51.26 307.83,51.26 PR1108.1
  TOP w0.254: 258.47,60.72 258.47,60.72 258.5,60.7 259.56,60.7 v2(259.71,60.85) 260.1,60.47 PR1111.2
  IN1 w0.203: v2(307.54,51.03) 307.73,51.22 308.28,51.22 308.61,51.55 308.61,59.72 307.27,61.05 296.87,61.05 295.81,62.12 285.05,62.12 284.88,62.3 278.51,62.3 277.82,61.61 265.71,61.61 265.15,61.04 261.15,61.04 260.71,60.6 260.01,60.6 259.76,60.85 v2(259.71,60.85)
VCC_SENSE: length 58.1
  TOP w0.203: v2(260.68,48.4) 261.03,48.4 261.36,48.73 PR1119.2 260.8,49.16 260.66,49.02 RC221.2 260.41,49.13 259.84,49.13 259.12,48.41 257.72,48.41 UC1.AG37
  IN1 w0.152: v2(303.41,51.45) 303.41,51.5 303.18,51.73 302.08,51.73 300.41,50.05 295.52,50.05 292.86,52.71 282.05,52.71 280.96,51.63 279.1,51.63 275.74,48.27 270.1,48.27 268.94,49.43 260.88,49.43 260.68,49.23 v2(260.68,48.4)
  BOTTOM w0.203: v2(303.41,51.45) 303.56,51.6 303.86,51.6 303.96,51.5 303.96,50.52 304.89,49.59 v1(305.02,49.59) PR1121.1
VCCDSW_EN: length 102.3
  TOP w0.109: v2(137.11,68.09) 137.36,67.84 137.36,67.72 CE66.1 136.68,67.74 136.68,68.28 136.79,68.4 136.79,69.1 137.28,69.59 137.28,70.09 137.54,70.35 UE1.M7 ; RH445.1 119.61,16.17 v2(118.9,16.17) ; v2(126.67,66.49) v1(126.11,66.49)
  IN1 w0.102: v2(102.07,55.38) 101.42,55.38 97.4,51.36 97.4,46.67 97.99,46.08 97.99,40.69 99.27,39.41 100.11,39.41 105.29,34.23 108.54,34.23 108.71,34.06 108.71,25.05 109.32,24.44 109.32,23.98 111.31,21.99 111.93,21.99 112.15,21.77 114.9,21.77 115.68,20.99 116.04,20.84 116.19,20.69 116.69,20.69 117.22,20.17 117.22,19.66 119.31,17.57 119.31,16.59 v2(118.9,16.17)
  IN2 w0.081: v2(126.67,66.49) 124.21,66.49 123.14,65.42 120.5,65.42 119.99,64.92 117.83,64.92 111.48,58.56 106.83,58.56 106.5,58.23 104.91,58.23 v2(102.07,55.38)
  IN3 w0.081: v2(126.67,66.49) 127.25,65.91 128.85,65.91 128.96,65.8 129.67,65.8 129.91,66.04 130.25,66.04 130.25,66.04 131.46,66.04 132.34,66.92 132.96,66.92 133.29,67.25 135.4,67.25 136.24,68.09 v2(137.11,68.09)
VCCDSW_EN_GPIO: length 7.1
  TOP w0.109: QH6.2 116.52,18.37 117.09,17.79 RH431.1 118.43,17.79 119.2,17.02 RH445.2 120.44,17.02 v1(120.82,16.64) 121.8,15.66 DH1.2
VCCDSW_EN_Q: length 4.3
  TOP w0.109: v1(124.67,15.65) DH1.1 122.87,15.01 DH2.2 123.59,14.12 RH442.1
VCCMPHY_SENSE: length 6
  TOP w0.109: UH1.K47 140.84,25.98 140.84,25.36 140.71,25.23 140.71,24.31 140.09,23.7 139.71,23.7 T76.1 138.88,22.51 PR810.2
VCCST_PWRGD: length 180.2
  IN3 w0.081: v2(274.85,67.4) 274.85,67.44 274.04,68.24 266.74,68.24 266.36,67.86 259.32,67.86 259.05,68.12 258.79,68.12 258.52,68.4 258.1,68.4 257.63,67.93 256.88,67.93 256.43,68.37 256.43,68.63 256.05,69.02 256.05,70.92 255.59,71.38 255.59,73.21 254.62,74.17 237.27,74.17 237.12,74.02 v2(234.51,74.02) 233.6,74.02 232.45,75.17 232.45,80.87 230.91,82.4 222.27,82.4 221.98,82.7 218.49,82.7 217.01,84.18 195.3,84.18 193.89,85.59 183.59,85.59 183.37,85.37 180.85,85.37 180.07,86.15 172.36,86.15 167.98,81.76 167.98,81.02 166.02,79.06 163.73,79.06 160.93,76.27 160.93,74.89 159.57,73.54 159.57,73.22 154.82,68.47 154.38,68.47 152.98,67.07 150.36,67.07 146.56,63.26 v2(146.12,63.26)
  BOTTOM w0.102: CC301.1 221.14,68.38 RC78.1 ; RC71.2 276,67.78 275.6,67.38 274.87,67.38 v2(274.85,67.4) ; 233.69,73.19 v2(234.51,74.02)
  BOTTOM w0.109: UE4.4 149.95,60.69 149.95,60.69 149.44,60.69 149.16,60.97 147.54,60.97 146.12,62.39 v2(146.12,63.26) ; 233.69,73.19 232.49,71.99 v1(222.35,71.99) 222.13,71.99 220.99,70.85 220.99,68.92 221.21,68.69 RC78.1
VCCST_PWRGD_CPU: length 21.5
  TOP w0.109: v2(239.21,63.71) 239.24,63.71 UC1.H13
  BOTTOM w0.109: RC78.2 v4(222.67,67.54) 231.05,67.54 233.11,65.47 233.11,64.93 233.58,64.47 234.31,64.47 235.02,63.77 235.15,63.77 235.66,63.26 237.1,63.26 237.22,63.38 237.22,63.93 237.37,64.09 237.72,64.09 238.18,63.63 239.13,63.63 v2(239.21,63.71)
VCCST_PWRGD_EC: length 26.5
  TOP w0.109: UE1.K10 v2(140.41,71.68) ; v2(149.36,73.41) 148.4,74.37 148.4,77.61 151.58,80.79 RE552.1
  BOTTOM w0.109: v2(149.36,73.41) v1(149.36,72.68) 149.36,72.24 148.82,71.69 147.57,71.69 147.49,71.77 144.54,71.77 143.46,72.85 141.06,72.85 140.84,72.63 140.84,72.1 v2(140.41,71.68)
VCCSTG_EN: length 194.1
  TOP w0.109: UZ19.4 272.7,78.03 273.44,77.3 UZ35.4 272.61,76.98 271.85,76.22 v1(271.85,75.96) v2(271.85,75.15)
  IN1 w0.102: v2(242.02,26.17) 241.91,26.05 240.69,26.05 238.75,24.11 238.75,22.46 239.16,22.04 239.16,21.07 238.7,20.6 238.7,16.22 240.35,14.57 240.35,13.12 239.77,12.55 239.77,10.24 238.18,8.65 183.92,8.65 181.1,11.47 172.68,11.47 168.93,15.22 168.26,15.22 167.13,16.35 167.13,22.01 162.79,26.35 162.79,28.18 161.17,29.8 v2(161.17,30.19)
  IN4 w0.102: v2(271.85,75.15) 271.85,72.16 270.82,71.12 269.96,71.12 266.97,68.13 266.11,68.13 264.11,66.12 264.11,62.75 263.43,62.06 263.43,57.3 261.4,55.27 261.4,47.6 261.06,47.26 261.06,38.99 260.43,38.36 260.43,30.6 259.74,29.91 258.26,29.91 256.66,28.31 250.67,28.31 249.78,29.2 249.78,30.83 249.17,31.43 242.8,31.43 242.02,30.66 v2(242.02,26.17)
  BOTTOM w0.109: RZ120.1 161.39,30.41 v2(161.17,30.19)
VDD12_A: length 14.1
  IN2 w0.508: v2(48.18,41.49) 48.18,42.84 50.75,45.4 50.75,47.89 50.15,48.49 50.15,52.52 v2(48.94,53.73)
  vias: v1(48.31,54.62)
VDD12_B: length 20.6
  TOP w0.203: 71.61,53.98 71.87,53.72 UV67.56
  TOP w0.254: 71.61,53.98 70.89,54.7 69.64,54.7 69.1,55.25 CV921.1
  TOP w0.508: CV921.1 69.07,55.45 CV923.1 70.1,56.28 70.64,55.74 v2(70.64,55.23)
  IN2 w0.508: v2(70.64,55.23) 70.64,54.5 71.56,53.57 81.34,53.57 v2(82.45,54.68)
  vias: v1(84.43,54.61)
VDD33_A: length 27.5
  TOP w0.508: v2(59.22,55.08) 59.22,54.83 58.52,54.12 LV4.1
  IN2 w0.508: v2(59.22,55.08) 59.22,53.57 58.4,52.75 58.4,45.07 55.43,42.09 54.06,42.09 52.8,40.83 52.8,40.16 v2(52.81,40.16)
  BOTTOM w0.203: UV66.29 55.6,44.21 54.24,42.86 54.24,42.41 53.87,42.04 ; UV66.2 58.81,53.72 58.96,53.87
  BOTTOM w0.254: 58.96,53.87 59.22,54.13 v2(59.22,55.08)
  BOTTOM w0.508: v2(52.81,40.16) 52.81,40.17 v1(53.63,41) 53.87,41.24 53.87,42.04
VDD33_B: length 28.2
  TOP w0.203: UV67.2 72.27,47.7 71.83,47.26 70.7,47.26 70.54,47.09 ; v2(82.12,51.07) 81.94,50.89 UV67.29
  TOP w0.508: v2(68.78,46.32) 68.84,46.32 69,46.48 LV9.1 69.92,46.48 70.54,47.09
  IN3 w0.508: v2(68.78,46.32) 68.88,46.32 69.49,45.71 69.49,42.66 69.97,42.18 v2(70.43,42.18)
  BOTTOM w0.508: v2(82.12,51.07) 81.38,50.33 81.38,47.82 79.93,46.37 74.27,46.37 72.26,44.36 72.26,42.99 v1(71.76,42.49) 71.45,42.18 v2(70.43,42.18)
VDD_1.2V: length 12
  TOP w0.203: PU200.11 112.37,10.37 PC209.1
  TOP w0.508: PC209.1 111.8,9.8 PR203.2 110.61,10.45 v2(110.78,10.62) ; v2(115.65,8.16) 115.62,8.19 PR201.1
  IN1 w0.508: v2(115.65,8.16) 115.65,8.49 114.3,9.84 111.56,9.84 v2(110.78,10.62)
  BOTTOM w0.127: v2(110.78,10.62) 110.78,10.93 v1(110.44,11.28)
VDDA12_A: length 2.2
  BOTTOM w0.203: UV66.43 52.65,48.92 52.52,49.04
  BOTTOM w0.254: 52.52,49.04 52.02,49.04 v2(51.38,48.4)
  vias: v1(51.42,46.84)
VDDA12_B: length 13.4
  TOP w0.127: v2(77.48,54.94) 77.48,55.48 v1(77.39,55.56)
  TOP w0.203: v2(77.48,54.94) 77.07,54.54 UV67.43
  BOTTOM w0.508: LV13.1 68.15,54.38 68.43,54.66 CV936.1 69,54.63 CV935.1 70.11,54.61 CV938.1 CV937.1 72.35,54.61 73.33,53.63 76.17,53.63 v2(77.48,54.94)
VDDP_1.2V: length 7
  TOP w0.127: PD200.1 112.64,6.33 v1(113.57,5.4)
  TOP w0.203: PU200.12 112.77,10.63 113.09,10.31 PC206.1
  TOP w0.508: PD200.1 113.13,7.41 PR204.1 113.11,8.48 113.11,9.78 PC206.1
VDDRX12_A: length 17.5
  IN2 w0.508: v2(61.67,41.92) 61.24,41.92 59.31,43.86 59.31,46.12 59.81,46.62 59.81,50.51 61.46,52.16 61.46,54.8 62.35,55.69 63.3,55.69 63.35,55.64 63.42,55.64 v2(63.52,55.54)
  vias: v1(61.92,42.69)
VDDRX12_B: length 21.9
  TOP w0.203: UV67.3 72.67,47.64 71.92,46.88 71.19,46.88 v2(70.94,46.62) ; UV67.24 81.51,48.89 81.71,48.68 81.71,48.58
  TOP w0.381: 81.71,48.58 81.71,47.67
  TOP w0.508: v2(83.03,43.96) 83.03,45.2 82.8,45.43 CV925.1 CV926.1 82.24,47.13 81.71,47.67
  IN1 w0.508: v2(70.94,46.62) 72.13,45.43 81.56,45.43 v2(83.03,43.96)
  vias: v1(71.75,46.94)
VDDTX12_A: length 12.3
  TOP w0.508: v2(51.84,47.87) 52.01,47.69 52.73,47.69 52.74,47.7 CV915.1 52.77,47.74 CV911.1 52.22,48.58 v2(52.12,48.48)
  IN2 w0.508: v2(51.89,53.99) 53.21,52.67 53.21,49.47 52.22,48.48 v2(52.12,48.48)
  BOTTOM w0.203: UV66.55 52.16,53.72 v2(51.89,53.99) ; v2(51.84,47.87) 52.11,47.87 52.75,48.52 UV66.42
  vias: v1(51.31,53.76)
VDDTX12_B: length 27.2
  TOP w0.203: UV67.42 77.47,54.28 77.95,54.75 v2(77.95,55.79) ; 71.54,56.43 v1(71.54,55.95) 71.73,55.76 71.73,54.6 72.27,54.06 UV67.55
  TOP w0.381: 71.54,56.43 LV12.1
  TOP w0.508: CV931.1 78.35,56.47 CV930.1 78.23,56.45 77.95,56.17 v2(77.95,55.79) ; LV12.1 70.77,57.01 68.42,57.01 v2(68.38,57.06)
  IN2 w0.508: v2(77.95,55.79) 77.65,55.79 76.4,57.04 69.32,57.04 69.3,57.06 v2(68.38,57.06)
  BOTTOM w0.356: v2(68.38,57.06) 68.38,57.56 68.07,57.86 CV934.1 67.1,57.36 67.05,57.31 CV932.1
  BOTTOM w0.508: v2(68.38,57.06) 68.85,56.59 CV933.1
VSS_A36: length 14
  TOP w0.109: v2(257.03,68.46) 257.03,68.18 256.81,67.95 UC1.A36
  BOTTOM w0.109: v2(257.03,68.46) 257.99,67.5 258.9,67.5 261.03,69.63 264.85,69.63 v1(265.5,68.98) RC178.1
VSS_A37: length 12.2
  TOP w0.109: UC1.A37 257.45,67.91 v2(258.3,67.91)
  BOTTOM w0.109: v2(258.3,67.91) 258.97,67.91 260.93,69.86 265.2,69.86 265.32,69.99 v1(267.64,69.99) RC179.1
VSS_GT_SENSE: length 65.4
  TOP w0.109: UC1.AH37 257.5,48.03 257.83,47.7 258.48,47.7 258.7,47.48 259.62,47.48 v2(259.86,47.24)
  TOP w0.203: v2(307.01,33.1) 307.21,33.3 307.21,33.86 PR1128.2 ; PR1129.1 260.42,40.62 v2(260.35,40.69)
  IN1 w0.152: v2(307.01,33.1) 307.26,33.34 307.26,34.14 306.99,34.41 303.3,34.41 298.14,39.56 295.11,39.56 292.44,42.23 287.37,42.23 287.21,42.38 278.06,42.38 276.61,40.93 260.59,40.93 v2(260.35,40.69)
  IN4 w0.152: v2(260.35,40.69) 260.14,40.9 259.79,40.9 259.53,41.16 259.53,43.28 260.47,44.23 260.47,47.26 260.28,47.46 260.07,47.46 v2(259.86,47.24)
VSS_IO_SENSE: length 80.6
  TOP w0.109: v2(239.86,62.87) 240.22,62.87 UC1.J14
  TOP w0.152: PR310.2 308.43,64.06 308.73,64.06 v2(308.96,63.83)
  IN1 w0.203: v2(239.86,62.87) 240.13,63.13 244.13,63.13 244.46,62.8 249.77,62.8 249.93,62.64 249.93,61.16 250.58,60.51 251.72,60.51 252.08,60.15 252.08,58.57 252.84,57.81 258.59,57.81 259.26,58.47 259.26,61.3 259.75,61.79 260.75,61.79 261.03,61.51 264.58,61.51 266.09,63.02 272.04,63.02 272.66,62.4 273.86,62.4 v2(274.06,62.19)
  IN2 w0.152: v2(308.96,63.83) 308.73,64.06 308.23,64.06 308.02,63.85 297.59,63.85 296.34,62.6 279.17,62.6 278.44,61.86 276.32,61.86 275.75,62.44 274.31,62.44 v2(274.06,62.19)
VSS_SA_SENSE: length 63.6
  TOP w0.109: 258.3,60.29 257.66,60.29 UC1.M37
  TOP w0.152: v2(307.54,51.74) 307.77,51.52 307.9,51.52 PR1106.1
  TOP w0.254: 258.3,60.29 258.35,60.34 259.48,60.34 259.5,60.31 259.53,60.31 v2(259.71,60.14) 260.17,59.68 PR1100.2
  IN1 w0.203: v2(307.54,51.74) 307.76,51.53 308.15,51.53 308.3,51.68 308.3,59.49 307.05,60.75 296.75,60.75 295.68,61.81 284.93,61.81 284.75,61.99 278.64,61.99 277.95,61.31 265.84,61.31 265.27,60.74 261.28,60.74 260.84,60.3 259.98,60.3 259.82,60.14 v2(259.71,60.14)
VSS_SENSE: length 55.7
  TOP w0.203: UC1.AG38 258.04,48.74 258.99,48.74 260.18,49.94 RC221.1 260.53,49.93 PR1125.2 261.36,50.46 261.14,50.69 v2(260.68,50.69)
  IN1 w0.152: v2(260.68,50.69) 260.68,49.84 260.83,49.68 269.05,49.68 270.2,48.53 275.64,48.53 278.99,51.88 280.86,51.88 281.94,52.97 292.97,52.97 295.63,50.31 300.3,50.31 301.98,51.98 303.23,51.98 v2(303.41,52.16)
  BOTTOM w0.203: PR1122.1 304.56,50.51 304.29,50.78 304.29,51.61 303.97,51.93 303.63,51.93 v2(303.41,52.16)
VSSMPHY_SENSE: length 5.8
  TOP w0.109: PR811.2 140.7,21.62 140.15,22.16 T77.1 140.15,23.26 140.92,24.02 140.92,25.11 141.1,25.29 141.1,25.8 141.21,25.91 141.21,26.31 141,26.51 UH1.K46
32KHZ_OUT: length 5.9
  TOP w0.109: CE54.1 131.16,78.67 v2(131.46,78.37) ; UE1.F3 v2(134.07,75.62)
  BOTTOM w0.109: v2(131.46,78.37) 132.3,78.37 v1(132.42,78.26) 132.93,77.75 132.93,77.39 133.68,76.63 133.68,76.12 134.07,75.73 v2(134.07,75.62)
81215_ALERT: length 2.1
  TOP w0.109: PU1100.41 306.61,40.55 PR1115.1
81215_SCLK: length 5.2
  TOP w0.109: v1(310.5,41.02) 310.5,40.85 310.32,40.66 308.81,40.66 PR1117.1 307.46,40.2 306.72,40.95 PU1100.42
81215_SDIO: length 4.8
  TOP w0.109: v1(309.55,38.68) 309.27,38.96 308.16,38.96 PR1113.1 307.26,38.93 307.26,39.52 306.64,40.15 PU1100.40
81215_VR_HOT: length 4.1
  TOP w0.203: PU1100.39 305.55,39.13 305.62,39.05 305.62,38.92 306.19,38.35 v1(306.76,38.35) 307.9,37.21 PR1110.1
+BL_PWR_SRC: length 39.1
  IN1 w0.508: v2(134.14,121.1) 134.14,129.91 136.35,132.12 138.53,132.12 139.08,132.67 v2(139.08,134.89)
  IN3 w2.032: 113.43,119.57 113.43,121.19 114.31,122.06 117.87,122.06 118.67,122.86 124.25,122.86 124.64,123.24 127.8,123.24 130.12,120.92
  BOTTOM w0.109: v2(113.15,117.85) v4(112.44,117.85)
  BOTTOM w0.508: v2(139.08,134.89) 138.26,134.89 RV907.1
  vias: v2(113.15,117.26) v2(113.74,117.85) v2(113.74,117.26) v2(133.42,120.5) v2(133.53,121.1) v2(134.01,120.5)
+BL_PWR_SRC_F:
  vias: v1(143.72,131.21) v2(136.09,125.17) v2(136.09,124.59) v2(136.73,125.17) v2(136.73,124.59) v2(142.56,130.91) v2(142.56,130.33) v2(143.14,130.91) v2(143.14,130.33)
+CAMERA_VDD: length 28.9
  IN2 w0.508: v2(130.27,129.81) 130.27,127.95 125.4,123.08 118.95,123.08 117.42,121.55 117.42,115.71 v2(116.53,114.82)
  BOTTOM w0.109: v4(129.45,129.81) v2(130.27,129.81)
  BOTTOM w0.508: v2(130.27,129.81) 130.27,130.24 132.53,132.5 RZ550.2
+CAMERA_VDD_F: length 1.3
  BOTTOM w0.109: 133.69,131.29 132.45,131.29 v1(132.4,131.24)
+COINCELL: length 12
  BOTTOM w0.109: v1(294.09,24.67) 293.65,25.11 JRTC1.1
  BOTTOM w0.508: JRTC1.1 293.65,27.91 294.71,28.97 294.71,29.99 295.98,31.26 298.52,31.26 299.15,30.63 PR61.1
+DCIN: length 6.5
  TOP w0.203: PU700.28 72.49,24.43 72.83,24.77
  TOP w0.508: PR705.2 76.85,25.73 76.2,26.38 75.21,26.38 74.3,25.48 PC707.1 73.92,25.09 v1(73.25,25.09) 73.16,25.09 72.83,24.77
+DDR_VREF_B_DQ: length 148.5
  TOP w0.254: UC1.BR13 239.37,27.86 239.78,27.46 239.78,26.73 239.87,26.64
  TOP w0.508: v2(205.81,57.88) 205.81,22.11 208.24,19.67 208.24,12.14 207.41,11.32 182.85,11.32 v2(180.38,13.79) ; 239.87,26.64 239.87,25.4 238.33,23.86 238.33,21.5 237.65,20.82 v2(237.25,20.82)
  BOTTOM w0.508: v2(237.25,20.82) 236.61,20.82 229.43,13.64 v1(220.6,13.64) 215.25,13.64 212.89,11.27 182.89,11.27 v2(180.38,13.79) ; RD31.1 206.09,57.05 CD87.1 205.97,57.3 205.97,57.72 v2(205.81,57.88)
+DDR_VREF_CA: length 113.9
  TOP w0.254: UC1.BN13 239.31,29.28 v2(238.98,29.6)
  IN2 w0.508: v2(171.71,56.28) 171.71,56.15 172.85,55.01 174.19,55.01 174.95,54.24 174.95,51.96 174.5,51.5 174.5,45.12 173.78,44.41 173.78,21.49 175.43,19.85 179.1,19.85 179.91,19.04 186.54,19.04 186.8,18.78 189.58,18.78 190.13,18.23 195.18,18.23 196.4,17.01 198.75,17.01 200.68,18.94 218.64,18.94 222.83,23.13 233.53,23.13 234.13,23.74 234.13,24.83 235.18,25.87 235.18,26.35 236.24,27.42 237.72,27.42 238.98,28.68 v2(238.98,29.6)
  BOTTOM w0.508: 169.64,56.31 169.85,56.11 171.54,56.11 v2(171.71,56.28)
  vias: v1(168.37,56.54)
+DGFF_PWR:
  vias: v1(130.13,92.53)
+DGFF_PWR_SRC: length 0.6
  BOTTOM w0.102: v2(132.22,102.9) v4(132.22,102.3)
+DGFF_SRC_EN#: length 6.8
  TOP w0.109: QZ19.4 127.33,88.58 127.58,88.33 128.62,88.33 RZ512.2 129.44,87.52 CZ526.2 ; RZ514.1 129.99,86.19 CZ526.2 ; CZ526.2 129.99,88.43 v1(130.13,88.57)
+DIMM_DQ_R_VREF_B:
  vias: v1(204.44,54.07)
+EC_DEBUG_VCC: length 10.1
  BOTTOM w0.109: RE71.2 113.04,63.2 111.87,62.02 v4(111.87,59.62) 111.87,59.3 111.81,59.24 111.81,58.4 111.9,58.31 JDEG1.1
+EDP_VDD:
  vias: v1(109.29,144.92) v1(111.17,144.67) v2(107.83,145.63) v2(107.83,145.05) v2(108.21,144.39) v2(108.52,145.63) v2(108.52,145.05)
+IR_F:
  vias: v1(109.98,141.4)
+LCDVDD: length 67
  TOP w0.508: RV7.1 v2(123.9,134.25)
  IN2 w0.508: v2(107.77,147.17) 109.33,147.17 110.88,145.62 110.88,138.06 114.69,134.25 v2(123.9,134.25) 123.9,135.02 126.63,137.75 127.46,137.75 129.04,136.16 v2(131.96,136.16)
  IN4 w2.032: 109.58,146.54 111.07,145.05 111.07,134.76 115.93,129.9 115.93,122
  BOTTOM w0.508: v2(131.96,136.16) 132.53,136.73 RV910.1
  vias: v2(107.77,148.95) v2(107.77,148.36) v2(107.77,147.78) v2(115.11,120.53) v2(115.13,119.93) v2(115.78,120.56) v2(115.79,119.92) v2(116.38,120.28) v4(116.02,122.21)
+MIC2-VREFO-L: length 3.5
  TOP w0.109: RA5.1 386.84,21.91 387.04,21.71 387.51,21.71 v1(387.86,22.05)
  TOP w0.203: 386.13,21.84 386.13,21.83 385.57,21.83 385.39,22.01 UA1.28
  TOP w0.381: RA5.1 386.28,21.91 386.21,21.84 386.13,21.84
+MIC2-VREFO-R: length 2.9
  TOP w0.203: UA1.29 385.64,22.41 v2(385.76,22.29)
  BOTTOM w0.109: v2(385.76,22.29) 386.22,22.29 v1(386.42,22.49)
  BOTTOM w0.381: RA6.1 385.67,22.38 v2(385.76,22.29)
+PECI_VREF: length 6.9
  TOP w0.381: v2(141.21,72.48) UE1.J11
  BOTTOM w0.109: RE59.2 144.64,69.56 v1(145.13,69.06)
  BOTTOM w0.356: CE25.1 144.7,71.15 143.38,72.48 v2(141.21,72.48)
  BOTTOM w0.381: CE25.1 144.7,70.17 RE59.2
+PWR_SRC_R: length 5.1
  TOP w0.109: RZ85.2 337.46,59.81 338.42,58.84 v4(339.75,58.84)
  TOP w0.254: RZ85.2 336.67,59.05 JUSH1.26
+REGCTL_PNP10:
  vias: v1(157.85,139.89)
+RSVD_VCC3P3_2: length 6.7
  TOP w0.203: UL1.1 156.75,137.63 156.88,137.5 156.88,137.34
  TOP w0.254: RL6.2 v1(159.07,134.1) 158.21,134.1 156.88,135.44 156.88,137.34
+RTC_CELL: length 406.6
  TOP w0.254: QE15.3 144.8,87.24 145.97,87.24 v2(146.25,86.96) 146.68,87.39 RE551.2 ; RE31.1 123.35,80.02 v2(123.35,80.22) ; RA213.2 387.83,24.91 388.59,25.67 v2(388.82,25.67) ; v2(135.93,82.29) 136.36,81.86 RE507.2
  IN2 w0.254: v2(299.41,72.4) 300.45,72.4 302.46,70.4 306.22,70.4 309.13,67.49 310.82,67.49 311.82,66.49 311.82,65.2 310.83,64.21 310.83,61.37 308.68,59.22 308.68,54.81 301.23,47.36 301.23,45.72 300.47,44.97 300.47,37.61 300.8,37.29 300.8,35.29 300.3,34.79 300.3,32.15 303.16,29.29 v2(303.16,28.82)
  VCC w0.203: 232.93,94.37 233.2,94.64 262.16,94.64 262.4,94.4
  VCC w0.254: v2(167.55,105.86) 168.55,105.86 170.72,103.69 175.76,103.69 184.86,94.59 230.84,94.59 231.51,93.92 232.48,93.92 232.93,94.37 ; v2(272.37,93.09) 271.65,92.37 269.75,92.37 269.06,93.06 269.06,93.64 268.41,94.29 266.53,94.29 266.24,94 266.24,93.47 265.62,92.85 262.86,92.85 262.61,93.11 262.61,94.19 262.4,94.4
  IN3 w0.254: v2(388.82,25.67) 384.3,25.67 384.12,25.49 379.45,25.49 379.17,25.21 378.37,25.21 378.08,25.49 374.67,25.49 373.2,26.96 369.26,26.96 369.01,26.71 364.54,26.71 363.04,25.21 363.04,23 359.99,19.95 354.07,19.95 353.08,20.94 348.55,20.94 345.91,18.3 344.66,18.3 343.49,17.13 343,17.13 341.43,18.71 340.79,18.71 340.13,19.37 340.13,20.67 339.15,21.64 320.97,21.64 313.67,14.34 303.98,14.34 302.82,15.51 302.82,28.06 303.16,28.4 v2(303.16,28.82)
  IN4 w0.254: v2(135.93,82.29) 135.93,82.15 135.7,81.92 133.81,81.92 131.99,83.75 128.15,83.75 127.12,82.72 125.97,82.72 123.47,80.22 v2(123.35,80.22)
  BOTTOM w0.254: RE32.2 135.46,81.82 v2(135.93,82.29) 136.26,81.96 RE508.2 ; v2(272.37,93.09) 273.07,92.39 273.07,88.76 273.45,88.38 273.45,87.7 275.4,85.75 275.7,85.75 276.78,84.67 278.98,84.67 279.95,85.64 285.68,85.64 286.24,86.2 287.42,86.2 288.49,85.13 291.03,85.13 293.25,82.92 294.62,82.92 295.17,82.36 300,82.36 300.47,81.89 300.47,75.49 299.41,74.44 299.41,73.8 299.29,73.67 299.29,72.53 v2(299.41,72.4) ; v2(303.16,28.82) PD8.1 302.26,29.05 PC24.1 ; RE508.2 137.03,81.65 RE750.2 ; RE508.2 136.72,82.26 137.2,82.74 137.2,84.11 138.36,85.28 141.85,85.28 141.9,85.32 144.61,85.32 v4(144.99,85.7) v2(146.25,86.96) 148.04,86.96 149.98,88.9 149.98,94.53 152.19,96.74 153.54,96.74 153.79,96.48 155.2,96.48 159.54,100.82 163.79,100.82 164.4,101.43 164.4,103.23 165.2,104.03 167.23,104.03 167.55,104.35 v2(167.55,105.86)
+RTC_CELL_PCH: length 128.2
  TOP w0.254: v2(111.21,83.75) 111.4,83.94 116.75,83.94 118.21,82.48 123.72,82.48 v2(125.08,83.84) ; v2(140.56,84.39) 140.56,85.11 141.25,85.79 141.25,88.07 141.99,88.81 QE15.1 144.65,88.81 145.06,89.23 CE63.1 RE551.1 RE546.1
  TOP w0.381: RH200.1 RH201.1 121.26,20.56 121.08,20.39 v2(121.08,20.13)
  IN1 w0.254: v2(111.21,83.75) 111.72,83.24 111.72,75.91 110.68,74.87 110.68,69.27 108.38,66.97 108.38,64.18 108.85,63.71 108.85,57.68 109.4,57.14 109.4,56.88 109.4,51.62 111.2,49.81 111.2,44.21 111.02,44.03 111.02,39.38 111.38,39.03 111.38,31.46 111.2,31.28 111.2,30.28 111.69,29.79 111.69,29.43 111.01,28.75 111.01,26.81 111.99,25.83 111.99,25.38 112.34,25.03 113.12,25.03 114.37,23.78 115.21,23.78 115.52,23.47 115.74,23.38 116.51,23.38 116.71,23.57 117.8,23.57 118.56,22.81 118.56,21.52 119.95,20.13 v2(121.08,20.13)
  IN4 w0.254: v2(125.08,83.84) 125.13,83.9 125.13,84.7 125.56,85.13 132.41,85.13 132.97,84.57 137.97,84.57 138.94,83.61 139.78,83.61 v2(140.56,84.39)
  BOTTOM w0.254: RH198.1 RH297.1 125.76,23.81 125.27,23.33 125.27,22.82 v1(125.61,22.49) 125.61,21.08 125.24,20.72 121.51,20.72 121.08,20.29 v2(121.08,20.13)
+RTC_CELL_VBAT: length 3.7
  TOP w0.254: v2(133.88,80.46) 133.88,79.49 UE1.A2
  BOTTOM w0.127: v1(133.39,80.91) 133.84,80.46 v2(133.88,80.46)
  BOTTOM w0.254: RE32.1 135.43,80.77 CE11.1 134.42,80.46 v2(133.88,80.46)
+SIM_PWR: length 89.5
  IN3 w0.508: v2(122.87,161.6) 123.82,161.6 124.29,162.07 126.83,162.07 128.01,163.25 130.29,163.25 131.35,162.18 131.35,156.16 130.1,154.9 130.1,145.84 130.3,145.63 130.3,144.09 133.06,141.33 138.77,141.33 143.46,136.63 144.07,136.63 145.46,135.24 146.53,135.24 150.82,130.95 156.66,130.95 158.06,129.55 158.06,125.62 158.7,124.98 160.6,124.98 v2(160.86,125.24)
  BOTTOM w0.127: v1(125.08,162.16) 124.52,161.6 v2(122.87,161.6)
  BOTTOM w0.305: JNGFF2.28 153.99,115.47 153.88,115.57 153.88,116.28 154.1,116.5
  BOTTOM w0.508: 154.1,116.5 154.65,117.05 156.6,117.05 157.12,117.56 157.12,121.06 160.86,124.8 v2(160.86,125.24) ; v2(122.87,161.6) 122.35,161.08 CZ37.1 122.35,160.16 122.1,159.91 JSIM1.8
+TBT_SVR_IND:
  vias: v1(35.75,55.08)
+TRM_CT1: length 3.8
  TOP w0.109: v1(167.8,171.49) CL16.1
  TOP w0.381: v2(166.82,170.19) 167.79,170.19 CL16.1
  BOTTOM w0.381: TL1.3 v2(166.82,170.19)
+TRM_CT2: length 3.8
  TOP w0.109: v1(167.8,167.53) CL17.1
  TOP w0.381: v2(166.82,168.92) 166.94,168.81 CL17.1
  BOTTOM w0.381: v2(166.82,168.92) TL1.4
+TRM_CT3: length 4
  TOP w0.109: CL20.1 v1(167.78,163.84)
  TOP w0.381: v2(166.7,162.57) CL20.1
  BOTTOM w0.381: TL1.9 v2(166.7,162.57)
+TRM_CT4: length 4
  TOP w0.109: CL21.1 v1(167.78,160.07)
  TOP w0.381: v2(166.7,161.3) CL21.1
  BOTTOM w0.381: TL1.10 v2(166.7,161.3)
+USB2_REPEATER_VDD: length 14.7
  BOTTOM w0.254: CI60.1 378.81,58.09 379.23,57.67 379.23,57.51 379.72,57.02 UI4.1 ; UI4.13 382.22,52.08 382.49,51.81 CI61.1
  BOTTOM w0.381: CI60.1 378.09,58.24 v2(378.08,58.26) ; RI65.1 RI64.1 v2(379.32,48.93) ; RI66.1 v2(381.61,48.93) ; RI63.1 RI62.1 v2(380.84,48.93)
  BOTTOM w0.508: RI73.1 RI72.1 380.46,59.94 v2(380.44,59.96) ; CI61.1 382.69,50.52 v2(383.23,51.07) ; v2(385.52,58.69) 385.35,58.85 383.32,58.85 383.02,59.16 RI74.1 ; RI69.1 v2(381.22,59.94)
  vias: v1(375.96,56.62) v2(377.44,58.98) v2(377.46,57.6)
+USB3_REPEATER_VDD: length 15.1
  BOTTOM w0.254: UI5.13 385.78,41.58 386.97,40.38 CI68.1 ; UI5.1 383.28,46.79 CI69.1
  BOTTOM w0.508: RI86.1 v2(385.17,49.21) ; v2(381.87,38.73) 382.45,39.32 RI83.1 RI80.1 ; RI81.1 384.27,38.9 384.12,38.75 v2(384.12,38.5) ; CI68.1 387.39,40.24 v2(387.8,40.65) ; v2(384.88,38.62) 385.16,38.9 RI78.1 ; RI85.1 386.13,38.75 386.65,38.23 v1(387.14,38.23) 387.72,38.23 v2(388,38.51) ; RI90.1 v2(387.01,49.21) ; CI69.1 v2(381.45,47.58) ; v2(384.24,49.2) RI88.1 RI89.1
  vias: v2(379.29,46.45) v2(379.9,46.48)
+UZ12_TPM: length 2.3
  BOTTOM w0.109: v1(141.6,13.4) 141.6,13.8 142.07,14.27 142.07,15.2 142.1,15.23 UZ12.8
+UZ12_VHIO: length 24.1
  IN1 w0.508: v2(136.04,18.47) 136.04,18.27 137.72,16.6 138.2,16.6 138.88,15.92 138.88,14.01 138.81,13.93 v2(138.81,12.99)
  IN3 w0.508: v2(146.62,16.79) 146.62,17.01 146.24,17.39 144.87,17.39 144.09,18.18 137.42,18.18 137.14,18.47 v2(136.04,18.47)
  BOTTOM w0.254: UZ12.22 136.47,18.04 v2(136.04,18.47) ; v2(138.81,12.99) 138.81,13.48 138.8,13.49 UZ12.14
  BOTTOM w0.508: v2(146.62,16.79) 146.94,17.11 v1(147.15,17.11) 148.15,17.11 148.62,17.58 RZ366.1
+V_DDR_REF: length 1.7
  TOP w0.203: PC208.1 112.63,15.77 112.63,15.48 112.77,15.33 PU200.4
+V_DDR_REFCA_A: length 25
  TOP w0.305: JDIMM2.164 171.7,58.48 171.49,58.7 170.4,58.7
  TOP w0.508: v2(167.69,59.5) 168.49,58.7 170.4,58.7
  IN3 w0.508: v2(167.69,59.5) 168.2,58.99 171.55,58.99 172.16,58.38 179.98,58.38 v2(180.54,58.94)
  BOTTOM w0.305: v2(180.54,58.94) 181,58.48 JDIMM1.164 183.54,58.48 183.79,58.24 CD28.1
  BOTTOM w0.508: CD29.1 184.7,57.86 CD28.1
  vias: v1(165.22,59.84)
+V_DDR_REFCA_B: length 57.7
  TOP w0.305: JDIMM4.164 185.86,58.48 185.19,59.15 CD125.1 184.59,59.16 v2(184.59,59.83) 184.61,59.85 184.61,60.67 CD126.1
  IN3 w0.508: v2(184.59,59.83) 184.59,59.4 185.16,58.83 204.05,58.83 v2(205.61,60.39)
  IN4 w0.508: v2(168.45,59.68) 168.61,59.68 169.55,58.74 179.54,58.74 180.04,58.24 183.83,58.24 184.59,59.01 v2(184.59,59.83)
  BOTTOM w0.127: v2(205.61,60.39) v1(205.61,61.03)
  BOTTOM w0.305: 197.82,58.48 195.59,58.48 JDIMM3.164
  BOTTOM w0.508: v2(205.61,60.39) 205.22,60.39 204.77,59.94 RD36.1 CD97.1 RD84.1 CD94.1 CD95.1 200.79,59.41 199.86,58.48 197.82,58.48 ; RD9.2 168.58,59.55 v2(168.45,59.68)
+VR_CAP: length 15.7
  TOP w0.254: UE1.J1 132.52,72.85 v2(132.33,73.04) ; UE1.C10 v2(140.41,78.02)
  IN2 w0.381: v2(140.41,78.02) 139.87,78.56 138.57,78.56 138.12,78.12 138.12,75.45 137.49,74.82 133.45,74.82 132.79,74.16 132.79,73.43 132.39,73.04 v2(132.33,73.04)
  BOTTOM w0.109: v1(131.42,72.89) 131.95,72.89 132.1,73.04 v2(132.33,73.04)
  BOTTOM w0.381: v2(140.41,78.02) 140.41,78.08 CE31.1
+VSYS: length 7.3
  BOTTOM w0.109: v1(20.25,24.59) 20.19,24.65 RT569.1
  BOTTOM w0.254: CT349.1 19.37,27.95 19.37,29.33 19.58,29.55 19.58,30.63 UT5.A5
  BOTTOM w0.356: CT349.1 CT347.1 19.24,25.97 RT512.1
  BOTTOM w0.508: RT512.1 RT569.1
A_CHIP_ID0: length 3.4
  BOTTOM w0.109: RE566.2 RE568.1 v1(160.27,70.84) 159.78,71.32 UE12.10
A_CHIP_ID1: length 3.9
  BOTTOM w0.109: UE12.23 158.43,77.24 158.32,77.36 RE565.2 ; v1(157.3,78.3) RE565.2 ; RE565.2 RE567.1
AC_DIS: length 226.1
  TOP w0.109: UE1.H12 v2(142.01,73.28) ; v2(50.68,35.25) 50.68,35.79 PR2163.2 50.21,35.85 50.21,34.93 PD14.2 49.97,34.68 PD15.2 ; RE83.1 146.24,65.61 v2(146.25,65.6) ; PQ1.2 v2(89.57,19.87)
  IN2 w0.081: v2(146.22,24.84) 145.88,25.19 145.36,25.19 144.95,24.78 137.79,24.78 136.62,25.95 132.48,25.95 131.9,26.53 131.9,28.34 132.13,28.57 132.13,29.59 132.56,30.01 132.56,33.03 132.05,33.54 131.24,33.54 130.92,33.22 130.92,32.74 130.63,32.45 125.07,32.45 124.38,31.76 121.56,31.76 120.32,30.52 119.62,30.52 118.68,29.58 118.68,29.07 118.46,28.86 117.13,28.86 116.91,29.07 115.18,29.07 114.49,28.39 114.49,27.21 113.74,26.45 112.24,26.45 111.99,26.21 111.15,26.21 109.66,27.7 100.76,27.7 100.25,27.19 100.25,27.08 100.02,26.85 99.79,26.85 95.92,22.98 92.25,22.98 89.57,20.3 v2(89.57,19.87) 89.57,18.79 89.16,18.38 83.65,18.38 83.32,18.7 82.37,18.7 76.38,12.71 60.08,12.71 58.9,11.53 55.65,11.53 55.47,11.71 55.47,12.23 56.02,12.78 56.02,13.73 55.76,13.98 55.76,15.4 v2(56,15.64) ; v2(142.01,73.28) 141.74,73.28 141.36,72.9 141.04,72.9 140.79,72.65 140.79,70.62 140.92,70.5 141.42,70.5 141.62,70.29 141.62,69.11 142.11,68.62 142.29,68.62 142.54,68.37 142.54,68.06 142.82,67.78 144.27,67.78 146.25,65.8 v2(146.25,65.6) 146.25,65.51 146.78,64.98 148.1,64.98 150.01,63.06 151.83,63.06 152.85,62.04 153.1,62.04 155.01,60.12 156.14,60.12 157.45,58.82 158.83,58.82 162.77,54.87 162.77,53.28 163.86,52.19 165.63,52.19 166.24,51.58 167.15,51.58 v2(167.17,51.6)
  IN4 w0.102: v2(56,15.64) 56,17.39 55.12,18.27 55.12,22.59 54.67,23.04 54.67,23.74 54.16,24.25 54.16,25.1 54.94,25.87 54.94,29.96 52.84,32.05 52.84,33.03 52.21,33.67 52.21,34.88 51.84,35.25 v2(50.68,35.25) ; v2(167.17,51.6) 167.04,51.47 167.04,50.39 168.04,49.39 168.04,47.59 166.95,46.5 166.95,44.08 166.02,43.15 166.02,39 161.99,34.97 159.14,34.97 151.66,27.49 148.86,27.49 v2(146.22,24.84)
  BOTTOM w0.109: v2(167.17,51.6) v1(166.61,51.6)
AC_DISC#: length 166.7
  TOP w0.109: UE1.E13 v2(142.81,76.42) ; v2(63.2,18.77) 62.62,18.77 61.96,18.1 PQ2002.6 61.78,18.2 PQ2003.6 61.78,19.44 61.58,19.63 61.23,19.63 61.13,19.53 PQ2003.5 61.13,18.87 60.9,18.64 60.39,18.64 59.97,19.05 PR2005.1 58.78,19.05 v2(58.74,19.09) ; v2(53.29,19.09) 53.22,19.15 PC2003.2 54.15,20.79 PQ2004.6 54.29,19.43 54.86,18.86 54.86,17.38 54.41,16.92 PQ2005.6 ; v2(82.77,17.88) 82.53,17.88 82.26,17.61 PQ2.5 ; PQ5.2 v2(63.32,28.21)
  IN2 w0.081: v2(104.26,27.07) 103.6,27.07 103.16,26.62 100.44,26.62 100.21,26.39 99.98,26.39 94.5,20.91 94.5,19.55 93.52,18.57 90.42,18.57 89.6,17.75 82.9,17.75 v2(82.77,17.88)
  IN3 w0.081: v2(104.26,27.07) 104.77,26.56 105.79,26.56 106.68,27.45 107.87,27.45 108.95,28.53 108.95,31.1 109.41,31.56 110.46,31.56 111.26,32.37 111.26,42.04 112.52,43.3 112.52,49.52 113.35,50.34 113.35,53.06 113.35,53.71 114.6,54.97 116.7,54.97 118.12,56.39 119.95,56.39 122.61,59.04 129.13,59.04 129.88,59.79 131.99,59.79 133.61,61.41 134.3,61.41 134.83,61.94 139.11,61.94 139.82,62.65 141.79,62.65 142.61,63.47 142.61,63.94 144.36,65.69 144.36,67 145.79,68.43 145.79,72.43 145.08,73.15 145.08,76.13 144.75,76.46 143.75,76.46 143.59,76.3 142.94,76.3 v2(142.81,76.42)
  BOTTOM w0.109: v2(82.77,17.88) 80.64,20 77.78,20 76.54,18.77 69.14,18.77 68.53,19.37 63.81,19.37 v2(63.2,18.77) ; v2(63.32,28.21) 63.07,27.95 PQ8.2 63.07,26.94 62.81,26.68 61.32,26.68 v1(60.88,26.25) 58.62,23.99 58.62,21.95 59.41,21.16 59.41,19.83 58.74,19.16 v2(58.74,19.09) 58.71,19.05 57.34,19.05 56.75,19.64 53.84,19.64 v2(53.29,19.09)
AC_PRESENT: length 92.8
  TOP w0.102: 121.39,27.35 121.85,27.35 122.48,27.98 122.69,27.98 122.9,28.18 UH1.BG42
  TOP w0.109: 121.39,27.35 120.95,26.91 120.95,26.2 v2(121.16,26) 120.55,26 120.49,26.05 118.13,26.05 RH243.1 ; UE1.K8 v2(138.81,71.68)
  IN1 w0.102: v2(112.76,68.76) 112.76,68.74 113.63,67.87 113.63,67.35 112.92,66.64 112.92,65.64 112.51,65.22 112.51,64.15 111.81,63.45 111.81,63.24 112.23,62.82 113.06,62.82 113.85,62.02 113.85,60.94 112.98,60.06 112.98,52.43 114.3,51.1 114.3,48.53 116.86,45.98 116.86,37.81 117.47,37.2 117.47,29.12 117.83,28.76 117.83,26.81 118.64,26 v2(121.16,26)
  IN4 w0.102: v2(138.81,71.68) 138.63,71.68 138.23,72.07 133.89,72.07 133.52,72.44 128.51,72.44 127.48,73.47 126.45,73.47 125.49,72.51 117.34,72.51 116.42,71.59 113.59,71.59 112.52,72.66 111.26,72.66 111.05,72.44 111.05,69.71 112,68.76 v2(112.76,68.76)
ACAV_IN: length 327.9
  TOP w0.109: v2(119.28,80.12) 119.28,81.05 118.4,81.93 117.98,81.93 116.52,83.39 113.63,83.39 113.29,83.05 111.67,83.05 108.13,79.51 v2(108.13,79.24) ; UE1.C7 v2(137.27,78.02) ; v2(101.04,63.39) 100.98,63.32 DZ12.1 ; PR713.1 72.43,27.65 72.43,29.32 72.2,29.56 v2(72.03,29.56)
  IN1 w0.102: v2(108.13,79.24) 108.13,77.3 107.47,76.64 107.47,70.08 106.21,68.82 104.19,68.82 101.04,65.67 v2(101.04,63.39) 101.04,59.83 90.6,49.39 90.6,39.7 88,37.1 87.26,37.1 86.97,36.81 86.97,36.26 87.32,35.9 87.32,34.56 87.15,34.39 86.58,34.39 86.22,34.75 86.22,35.57 84.6,37.19 76.54,37.19 75.48,36.13 72.89,36.13 72.21,35.46 72.21,29.73 v2(72.03,29.56)
  VCC w0.086: v2(159.92,62.22) 162.63,62.22 164.84,64.43 164.84,66.27 166.98,68.4 166.98,77.59 168.07,78.68 168.07,81.43 167.64,81.85 167.64,84.48 169.21,86.05 178.99,86.05 180.6,84.43 182.66,84.43 183.46,85.23 195.35,85.23 196.52,84.06 212.18,84.06 223.27,72.97 231.64,72.97 233.67,75 238.06,75 238.76,74.29 254.92,74.29 256.48,75.86 257.65,75.86 261.65,71.86 266.62,71.86 270.98,76.22 276.52,76.22 v2(277.56,77.26)
  IN4 w0.102: v2(137.93,83.9) 132.66,83.9 132.27,84.29 130.78,84.29 130.4,84.67 128.46,84.67 126.81,83.02 125.83,83.02 124.18,81.38 123.39,81.38 121.69,79.68 119.72,79.68 v2(119.28,80.12) ; v2(159.92,62.22) 159.92,62.28 160.38,62.75 160.38,65.38 159.72,66.04 159.72,66.56 160.73,67.57 160.73,68.02 160.35,68.4 160.35,69.52 161.14,70.3 161.14,75.86 160.75,76.24 160.75,78.98 161.36,79.59 161.36,80.48 161.25,80.6 158.48,80.6 157.8,81.28 157.8,82.14 v2(157.68,82.26)
  BOTTOM w0.109: UV68.1 277.77,77.47 v2(277.56,77.26) ; v2(157.68,82.26) 156.93,82.26 156.66,81.99 156.66,81.17 156.03,80.53 154.52,80.53 153.82,79.83 149.92,79.83 149.39,79.3 149.01,79.3 145.62,82.69 142.89,82.69 140.61,84.97 138.49,84.97 137.93,84.4 v2(137.93,83.9) 137.93,83.52 v4(138.78,82.67) 139.01,82.44 139.01,81.43 136.66,79.08 136.66,78.56 137.2,78.02 v2(137.27,78.02)
ACDET_CHG: length 3.9
  TOP w0.109: PU700.6 69.28,25.63 70.2,26.56 PR709.1 70.2,27.91 PC709.1 69.37,27.93 PR706.1
ACOK_CHG: length 5.9
  TOP w0.109: v1(71.49,29.96) 71.59,29.86 71.59,29.26 PR712.2 PR716.1 71.82,27.94 71.75,27.94 71.24,27.43 71.24,27.37 PR713.2 70.67,26.8 70.67,26.67 69.68,25.68 PU700.5
ALW_PWRGD_3V_5V: length 261.7
  TOP w0.109: PR102.2 132.92,115.57 v2(132.48,115.13) ; v2(45.54,20.08) 45.63,20.17 45.63,20.76 45.69,20.83 QT1.2 ; DH2.1 v2(121.17,14.95) ; v2(41.22,16.44) 41.43,16.65 43.52,16.65 RT550.1
  IN1 w0.102: v2(113.37,88.83) 113.03,88.49 110.94,88.49 109.36,86.91 109.36,85.1 109.84,84.62 109.84,82.54 110.58,81.81 110.58,76.69 109.07,75.18 109.07,69.38 106.07,66.38 106.07,63.67 107.63,62.11 107.63,58.07 104.26,54.7 101.09,54.7 98.22,51.83 98.22,40.79 99.37,39.64 100.2,39.64 105.38,34.46 108.64,34.46 108.94,34.16 108.94,26.26 109.82,25.38 109.82,23.8 111.38,22.24 112,22.24 112.25,22 115,22 115.81,21.18 116.17,21.03 116.28,20.92 116.79,20.92 117.45,20.26 117.45,19.76 121.17,16.04 v2(121.17,14.95) ; v2(57.02,4.96) 56.2,4.96 55.75,4.51 54.43,4.51 53.97,4.97 53.97,9.44 50.23,13.18 50.23,14.3 48.16,16.37 46.43,16.37 46.12,16.68 46.12,17.64 45.54,18.23 v2(45.54,20.08)
  IN2 w0.081: v2(121.17,14.95) 120.46,15.66 118.03,15.66 117.21,14.84 114.88,14.84 114.31,14.27 113,14.27 110.46,11.72 107.38,11.72 105.79,13.31 v2(104.91,13.31) 104.5,13.72 96.49,13.72 95.25,14.96 93.59,14.96 92.03,16.52 89.98,16.52 89.65,16.19 88.63,16.19 83.22,10.78 79.73,10.78 77.48,8.54 70.65,8.54 69.75,7.63 66.34,7.63 64.26,5.55 57.62,5.55 v2(57.02,4.96)
  IN3 w0.081: v2(45.54,20.08) 43.38,17.92 42.73,17.92 41.25,16.44 v2(41.22,16.44) ; v2(131.99,103.51) 131.02,104.47 125.59,104.47 125.47,104.59 125.47,106.97 125.07,107.38 124.58,107.38 124.16,106.95 122.23,106.95 119.25,103.98 119.25,97.45 117.36,95.56 117.36,91.2 115.9,89.74 114.27,89.74 113.57,89.04 113.57,89.03 v2(113.37,88.83)
  BOTTOM w0.109: v2(104.91,13.31) 104.91,13.48 104.57,13.82 UZ6.2 ; v2(132.48,115.13) v1(132.48,114.62) 132.48,113.54 131.64,112.7 131.64,110.51 135.46,106.69 135.46,103.58 134.88,103.01 133.39,103.01 132.89,103.51 v2(131.99,103.51) ; PR103.2 v2(57.02,4.96)
ALW_PWRGD_3VR_5VR: length 72.5
  TOP w0.109: PR508.2 318.89,3.32 319.13,3.08 v2(319.19,3.08) ; PR509.2 349.97,40.67 v2(349.83,40.53) 349.83,40.5 349.55,40.22 349.55,39.82 349.18,39.45 v1(349.18,39.28)
  BOTTOM w0.109: v2(349.83,40.53) 350.24,40.53 350.62,40.15 351.94,40.15 354.58,37.5 354.58,19.5 351.03,15.94 342.87,15.94 336.84,9.91 325.54,9.91 324.14,8.51 324.14,4.23 323.38,3.47 322.02,3.47 321.1,4.38 320.49,4.38 v2(319.19,3.08)
ALWON: length 508.1
  TOP w0.109: v2(351.01,38.48) 351.41,38.09 PR505.1 ; v2(163.27,47.68) 164.47,48.88 v1(164.47,49.58) 164.47,51.37 164.85,51.75 164.85,53.76 v2(164.36,54.24) ; UE1.A5 v2(136.04,79.86)
  IN1 w0.102: v2(147.57,30.34) 148.02,30.79 152.6,30.79 153.76,29.63 155.7,29.63 156.14,29.19 158.46,29.19 163.01,33.75 163.01,47.42 v2(163.27,47.68)
  IN2 w0.081: v2(164.36,54.24) 164.36,54.94 159.35,59.96 158.48,59.96 157.31,61.13 157.31,66.07 154.43,68.95 154.43,70.55 152.96,72.02 152.3,72.02 151.41,71.13 149.15,71.13 147.77,69.76 146.35,69.76 145.39,70.73 145.39,76.97 144.3,78.06 142.93,78.06 142.34,78.65 142.34,79.34 141.91,79.77 140.98,79.77 140.62,79.41 137.03,79.41 137,79.38 136.51,79.38 v2(136.04,79.86) ; v2(351.01,38.48) 352.19,39.66 352.19,54.35 349.15,57.39 346.38,57.39 345.23,58.54 340.89,58.54 339.25,60.19 337.39,60.19 336.39,61.19 330.66,61.19 330.37,60.9 311.78,60.9 311.08,60.2 311.08,55.07 309.12,53.1 309.12,47.49 306.32,44.69 306.32,19.87 301.88,15.42 294.75,15.42 290.73,11.4 266.4,11.4 263.01,14.8 259.93,14.8 256.91,17.82 248.01,17.82 247.05,18.78 243.09,18.78 241.65,17.33 240.57,17.33 239.81,16.58 237.4,16.58 233.1,12.27 231.52,12.27 231.1,12.7 214.73,12.7 213.11,11.08 176.24,11.08 174.14,13.18 172.37,13.18 167.84,17.71 167.84,23.27 166.76,24.35 166.76,41.16 165.3,42.62 165.3,45.64 v2(163.27,47.68)
  IN2 w0.102: v2(147.57,30.34) 146.81,29.58 146.81,28.58 148.58,26.81 148.58,22.53 148.35,22.3 148.35,21 149.87,19.47 149.87,15.25 149.61,14.99 146.43,14.99 145.98,15.43 v2(145.98,15.51)
  IN4 w0.102: v2(55.29,2.78) 55.88,2.19 58.66,2.19 61.99,5.52 67.41,5.52 71.57,1.36 100.66,1.36 102.89,3.59 102.89,8.34 106.54,11.99 106.55,11.99 106.55,12.89 108,14.34 108,15.42 108.46,15.88 112.46,15.88 112.86,16.28 115.56,16.28 118.39,13.45 121.92,13.45 122.54,12.83 127.89,12.83 128.75,11.97 132.55,11.97 133.35,12.77 136.78,12.77 137.88,13.86 140.94,13.86 142.2,12.6 144.87,12.6 145.59,13.32 145.59,15.12 v2(145.98,15.51)
  BOTTOM w0.109: v2(55.29,2.78) 55.32,2.81 PR113.1
AR_DET#: length 9.8
  TOP w0.109: UH1.BB16 125.41,41.36 v2(125.28,41.49)
  BOTTOM w0.109: RH400.1 119.37,41.89 RH401.1 120.8,42.43 v1(121.08,42.15) 121.79,42.15 122.56,41.39 123.76,41.39 123.96,41.59 125.19,41.59 v2(125.28,41.49)
AUD_AZACPU_SCLK: length 166.6
  TOP w0.109: UC1.G27 250.74,64.05 v2(251.06,63.73) ; RH38.1 v1(128.72,53.66) 128.72,53.86 v2(128.39,54.19)
  IN2 w0.081: v2(128.39,54.19) 128.39,54.09 129.39,53.09 130.25,53.09 131.1,52.24 131.65,52.24 132.08,51.8 132.08,50.2 132.42,49.86 132.74,49.86 133.3,49.3 134.07,49.3 135.9,51.14 135.9,52.37 136.45,52.91 138.31,52.91 138.65,53.25 141.38,53.25 143.12,54.99 144.98,54.99 145.63,54.35 148.46,54.35 150.06,52.75 v2(150.63,52.75)
  VCC w0.086: v2(229.58,70.22) 229.51,70.28 221.74,70.28 212,80.02 204.33,80.02 203.19,81.17 189.18,81.17 188.35,81.99 177.1,81.99 175.66,83.44 172.46,83.44 171.01,81.99 171.01,75.38 170.61,74.98 170.61,73.02 169.48,71.89 168.87,71.89 168.52,71.54 168.52,64.61 165.06,61.15 165.06,59.16 156.53,50.62 152.76,50.62 v2(150.63,52.75)
  IN3 w0.081: v2(229.58,70.22) 229.58,68.29 233.58,64.29 234.38,64.29 234.99,63.68 235.35,63.68 235.74,63.3 240.44,63.3 240.76,62.98 250.3,62.98 v2(251.06,63.73)
AUD_AZACPU_SCLK_R: length 7.6
  TOP w0.089: UH1.AM3 129.74,47.92 129.74,48.83 129.52,49.05 129.52,49.8 129.27,50.04
  TOP w0.109: 129.27,50.04 128.79,50.52 128.79,51.69 RH38.2 128.72,51.93 127.61,53.05 127.61,53.96 v1(127.51,54.06)
AUD_AZACPU_SDI: length 13.4
  TOP w0.109: UC1.G29 252.52,64.38 v2(252.59,64.38) ; RC66.1 262.92,66.75 261.77,65.6 v2(261.58,65.6)
  BOTTOM w0.109: v2(261.58,65.6) 261.29,65.6 260.45,64.76 v1(259.87,64.76) 257.59,64.76 256.6,63.77 254.19,63.77 253.83,63.42 253.11,63.42 252.97,63.56 252.97,64 v2(252.59,64.38)
