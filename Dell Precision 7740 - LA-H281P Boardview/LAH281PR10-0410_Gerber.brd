# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Nets (continued)
N26927630: RC114.1 UC1.BT25(CFG_RCOMP)
N26949736: PR710.2 PU700.11(SDA)
N26949739: PR711.2 PU700.12(SCL)
N27025928: T18.1 UC1.B30(RSVD7)
N27025929: T19.1 UC1.C30(RSVD21)
N27025930: T21.1 UC1.G3(RSVD26)
N27025931: T20.1 UC1.J3(RSVD29)
N27025932: T24.1 UC1.BR31(RSVD18)
N27025933: T22.1 UC1.BH30(RSVD9)
N27025934: T23.1 UC1.BR35(RSVD19)
N27025935: T1.1 UC1.D1(RSVD_TP3)
N27025936: T2.1 UC1.E1(RSVD_TP4)
N27025938: T4.1 UC1.E2(RSVD_TP5)
N27025939: T5.1 UC1.BR1(RSVD_TP1)
N27025940: T6.1 UC1.BT2(RSVD_TP2)
N27025941: T7.1 UC1.BN35(RSVD15)
N27025942: T8.1 UC1.BL34(RSVD13)
N27025943: T11.1 UC1.BN33(RSVD14)
N27025944: T9.1 UC1.J24(RSVD28)
N27025945: T10.1 UC1.H24(RSVD27)
N27025946: T12.1 UC1.AA14(RSVD1)
N27025947: T15.1 UC1.AE29(RSVD2)
N27025948: T14.1 UC1.N29(RSVD30)
N27025949: T13.1 UC1.R14(RSVD31)
N27025953: T28.1 UC1.AP29(RSVD5)
N27025954: T27.1 UC1.AP14(RSVD4)
N27025955: T29.1 UC1.BK28(RSVD11)
N27025956: T30.1 UC1.BJ28(RSVD10)
N27028301: RZ120.2 UZ26.4(ON) UZ34.4(OUT)
N27099309: T26.1 UC1.AT13(ZVM#)
N27099311: T25.1 UC1.AW13(MSM#)
N27099349: T31.1 UC1.AU13(RSVD1)
N27099351: T32.1 UC1.AY13(RSVD2)
N27121902: RV832.1 UV64.48(CA_DET)
N27182711: PC1119.1 PR1137.2
N27232717: T60.1 UH1.R15(RSVD2)
N27232718: T61.1 UH1.R13(RSVD1)
N27232720: T62.1 UH1.AN35(TP)
N27232721: T63.1 UH1.AL37(VSS)
N27232838: CH321.1 RH28.2
N27232839: CH322.1 RH29.2
N27234698: RH101.2 SW1.2(B)
N27267303: T34.1 UH1.Y35(RSVD2)
N27267305: T33.1 UH1.Y36(RSVD3)
N27267307: T36.1 UH1.BC1(RSVD1)
N27267309: T35.1 UH1.AL35(TP)
N27271302: T40.1 UH1.U13(RSVD_1)
N28152235: PC1111.2 PC1112.2 PR1127.2 PR1128.1
N28152401: PC1128.2 PR1150.2 PU1100.15(VRMP)
N28152437: PC1118.2 PR1132.2 PU1100.3(IMON_4PH)
N28152465: PC1120.1 PR1135.1 PU1100.36(IMON_2PH)
N28152580: PC1103.2 PC1140.1 PR1106.2 PR1107.1
N28152729: PC1103.1 PC1105.1 PR1108.2 PR1109.1
N28152784: PC1130.1 PR1151.2 PU1100.16(VCC)
N28152844: PH1104.1 PR1166.2 PR1168.1
N28152958: PH1102.2 PR1141.2 PR1144.1
N28153073: PH1100.2 PR1101.1
N28153459: PH1103.1 PR1165.2 PR1167.1
N28153589: PR1198.1 PU1100.43(EN)
N28153954: PC1115.1 PR1133.2
N28154016: PC1109.1 PC1110.1 PR1122.2 PR1123.1
N28154283: PH1101.2 PR1140.2 PR1142.1
N28180064: PC1107.1 PR1118.2
N28185893: PC1116.1 PR1134.2
N28185971: PC1114.1 PR1130.2
N31547518: QV43.1(D) RV900.2 UV64.54(SW)
N42077965: PC1214.2 PU1200.7(PHASE)
N42077969: PR1201.1 PU1200.5(BOOT)
N42077993: PC1213.2 PR1200.2 PU1200.3(VCC)
N42078041: PC1224.2 PU1201.7(PHASE)
N42078055: PR1204.1 PU1201.5(BOOT)
N42078421: PC1214.1 PR1201.2
N42078543: PC1216.2 PR1202.1
N42078657: PC1224.1 PR1204.2
N42078671: PC1223.2 PR1205.2 PU1201.3(VCC)
N42078715: PC1226.2 PR1206.1
N43928883: PQ704.6(D2) PR721.2
N50023717: T199.1 UC1.BP13(DDR0_VREF_DQ)
N50024616: T194.1 UC1.A33(EDP_DISP_UTIL)
N50626069: PQ2102.6(D1) PR2134.2
N50626073: PQ2101.2(G) PR2100.2 PR2134.1
N50626131: PC2100.2 PQ2100.4(G) PQ2101.1(D) PR2101.2 PR2108.1
N50626325: PQ2106.6(D1) PR2142.2
N50626329: PQ2105.2(G) PR2104.2 PR2142.1
N50626379: PC2102.2 PQ2104.4(G) PQ2105.1(D) PR2105.2 PR2109.1
N50640713: PQ2109.6(D1) PR21.1 PR2161.2
N50640786: PL4.1 PQ2108.3(S) PR2143.1 PR2145.1 PR2162.1
N50645864: PC2104.1 PQ2109.3(D2) PR2144.1 PR2145.2 PR2148.1 PU2004.3(+)
N50646290: PC2105.1 PR2146.1 PR2147.2 PU2004.2(-)
N50692210: PR714.2 PU700.9(PMON)
N50714647: PQ2102.2(G1) PR2150.2
N50715082: PQ2106.2(G1) PR2106.2
N51087553: PC533.1 PU501.16(NC2) PU501.17(LDO)
N51087711: PC526.2 PR513.1
N51088117: PC531.1 PR514.2
N51093717: PC119.1 PU101.16(NC1) PU101.17(VCC)
N51093758: PC128.2 PR114.1
N51093811: PC115.1 PR111.2
N51093813: PC113.1 PR104.1 PR105.1 PU100.16(NC2) PU100.17(LDO)
N51093882: PC112.2 PR106.1
N51093922: PC110.1 PR101.2
N51431640: PQ700.4(G) PQ705.1(D) PR731.2 PR732.1
N51464097: PQ2110.2(G1) PR2152.2
N51464100: PQ2110.5(G2) PR2153.2
N51464118: PQ2112.2(G1) PR2154.2
N51464121: PQ2112.5(G2) PR2157.2
N51464131: PQ2111.5(G2) PR2156.2
N51464171: PQ2111.2(G1) PR2155.2
N51851482: T297.1 UC1.BL31(RSVD12)
N51851500: T298.1 UC1.AJ8(RSVD3)
N51851520: T299.1 UC1.G13(RSVD25)
N51851540: T300.1 UC1.C38(RSVD22)
N51851560: T301.1 UC1.C1(RSVD20)
N51851580: T302.1 UC1.BR2(RSVD17)
N51851600: T303.1 UC1.BP1(RSVD16)
N51851620: T304.1 UC1.B38(RSVD8)
N51851640: T305.1 UC1.B2(RSVD6)
N52218840: PR1170.2 PU1100.27(CSP2_2PH)
N52320463: DV44.2 JDGFF2.E2
N54556025: PD11.2 PR8.2
N54556028: PD11.1(3) PQ3.6(D1)
N54556584: PD12.2 PR33.2
N54556800: PD12.1(3) PQ6.6(D1)
N54556836: PD13.2 PR51.2
N61680769: PD13.1(3) PQ9.6(D1)
N61687377: PC405.1 PR403.2
N61688443: PR807.2 PR809.2 PR810.1
N61688512: PC804.2 PR802.2
N61690744: PC903.1 PR903.2
N61692023: PC1243.2 PU1203.7(PHASE)
N61692025: PR1211.1 PU1203.5(BOOT)
N61692045: PC1244.2 PR1212.2 PU1203.3(VCC)
N61692067: PL1205.3 PR1215.1
N61692081: PC1243.1 PR1211.2
N61692131: PC1246.2 PR1213.1
N61692583: PL1204.3 PR1214.1
N61692600: PR1209.1 PU1202.5(BOOT)
N61692604: PC1233.2 PU1202.7(PHASE)
N61692626: PC1233.1 PR1209.2
N61692634: PC1234.2 PR1208.2 PU1202.3(VCC)
N61692676: PC1236.2 PR1210.1
N61733264: PD14.1(3) PQ4.2(G1)
N61733291: PD15.1(3) PQ7.2(G1)
N61859075: PR724.2 PU700.15(BATPRES#)
N63151956: T307.1 UH1.BC22(GPP_C17/I2C0_SCL)
N63151958: T306.1 UH1.BF23(GPP_C16/I2C0_SDA)
N63155819: T288.1 UH1.Y14(RSVD7)
N63155821: T289.1 UH1.Y15(RSVD8)
N63155823: T290.1 UH1.U37(RSVD6)
N63155825: T291.1 UH1.U35(RSVD5)
N63155827: T294.1 UH1.AH15(RSVD2)
N63155829: T295.1 UH1.AH14(RSVD1)
N63156852: QH6.1(D) RH433.2
N63173356: JDIMM2.165(C1, CS3_N,NC) T49.1
N63173755: JDIMM2.162(C0/CS2_N/NC) T48.1
N63181367: JDIMM3.162(C0/CS2_N/NC) T50.1
N63181369: JDIMM3.165(C1, CS3_N,NC) T51.1
N63187763: JDIMM4.162(C0/CS2_N/NC) T52.1
N63187777: JDIMM4.165(C1, CS3_N,NC) T53.1
N63193970: RI92.2 UI5.7(REXT)
N63193981: RI93.2 UI5.24(I2C_EN)
N63195390: RI71.2 UI2.16(ILIM_HI)
N63195630: RI79.2 UI3.16(ILIM_HI)
N63195786: RI14.2 UI1.16(ILIM_HI)
N63195930: RI76.2 UI4.7(REXT)
N63195950: RI77.2 UI4.24(I2C_EN)
N63205753: RR237.1 UR3.3(WP#)
N63206214: CR256.2 RR227.1 UR4.6(VOUT)
N63206790: RR238.1 UR3.7(HOLD#)
N63210465: RZ62.1 UZ12.27(SERIRQ)
N63261697: QE12.1(D) RE94.1
N63261780: RE703.2 UE1.M12(GPIO120)
N63261795: RE548.2 UE1.G4(GPIO106/PWROK)
N63261829: CE57.1 RE350.2
N63264088: RE57.1 RE58.1 UE1.B1(SYSPWR_PRES)
N63264181: RE318.2 UE1.G2(GPIO203/ADC03)
N63264846: QE17.1(D) RE546.2
N63272832: QE11.3(S) RE70.1 RE90.1
N63272852: QE4.2(BASE) RE70.2
N63274676: CE342.1 UE12.4(VCORE)
N63282244: RA213.1 RA214.1 UA1.33(5VSTB/AUX_MODE)
N63282319: CA25.2 UA1.32(MIC2-CAP)
N63282335: CA29.1 CA232.1 UA1.24(CBN)
N63282517: CA35.2 UA1.38(VREF)
N63282540: CA51.2 RA44.2 UA1.39(LDO1-CAP)
N63282645: DA2.2 JHP1.5 RA219.2
N63282767: CA52.2 UA1.21(LDO2-CAP)
N63282827: CA29.2 CA232.2 UA1.23(CBP)
N63282834: CA53.2 UA1.19(LDO3-CAP)
N63282842: CA33.1 RA17.2
N63302772: CZ130.1 UZ23.6(CT)
N63303945: JNGFF3.10(DAS/DSS#) RN217.1
N63303993: JNGFF4.10(DAS/DSS#) RN218.1
N63304099: UZ23.3(ON) UZ60.4(O)
N63307260: JNGFF5.10(DAS/DSS#) RN216.1
N63307264: JNGFF6.10(DAS/DSS#) RN474.1
N63309556: C193.2 UZ44.12(CT1)
N63309591: C195.1 UZ7.6(CT)
N63309639: C192.2 UZ44.10(CT2)
N63309692: C202.2 UZ9.12(CT1)
N63309706: C201.2 UZ9.10(CT2)
N63309775: C207.1 UZ58.6(CT)
N63309827: C209.1 UZ59.6(CT)
N63354804: CT21.1 RT394.2 YT1.1(IN)
N63359901: CT375.1 QT2.2(G) RT545.1 RT546.1
N63359905: QT4.6(D) RT546.2
N63359909: CT375.2 QT2.3(S) QT3.3(S) RT545.2 RT547.1 RT548.2
N63359919: CT376.1 QT4.5(G) RT550.2
N63359925: QT3.2(G) QT4.2(G) RT548.1 RT549.1
N63359927: QT4.3(D) RT549.2
N63361205: CT372.1 RT542.1 UT7.5(VOUT)
N63361207: CT373.1 QT1.1(D) RT543.2 RT544.1 UT7.4(EN)
N63361304: DT64.2 QT10.1(D)
N63372869: DV3.1 DV42.1 RV3.1 UV24.4(EN)
N63372900: RV843.2 UV24.3(/OC)
N63373086: JEDP1.18 LV1.1
N63496140: CZ121.1 UZ45.6(CT)
N63496197: CZ521.2 UZ42.6(CT)
N63496456: RZ548.2 RZ549.2 UZ41.3(ON1)
N63496796: RZ509.2 UZ42.3(ON)
N63496843: CZ523.2 UZ40.12(CT1)
N63496855: CZ522.2 UZ40.10(CT2)
N63496880: QZ20.1(D) RZ514.2
N63496917: CZ515.2 UZ43.6(CT)
N63496989: CZ517.2 UZ41.12(CT1)
N63496991: CZ516.2 UZ41.10(CT2)
N63894512: CA49.2 CA233.2 UA1.25(CPVEE)
N64705983: RH6.1 UH1.AU47(GPP_F13/SATA_SDATAOUT0)
N64891293: RE745.2 UE1.K12(GPIO111/PS2_DAT2)
N64891506: RE746.1 UE1.M11(GPIO027/TIN2)
N64891509: RE743.1 UE1.H9(GPIO030/TIN3)
N64894761: RT445.2 RT456.2 UT32.1(NO)
N64894763: RT448.2 UT32.3(NC)
N64894971: RT500.2 UT34.2(IN2)
N64983618: RV50.1 UV8.20(REXT)
N64983738: CV75.1 UV8.17(CEXT)
N64988392: T315.1 UV66.37(RSV0)
N64988396: T316.1 UV67.37(RSV0)
N65041103: CZ56.1 RZ63.1
N65096928: JNGFF3.8(NC3) RN219.1
N65096993: JNGFF4.8(NC2) RN220.1
N65097064: JNGFF5.8(NC3) RN475.1
N65097129: JNGFF6.8(NC3) RN476.1
N65689457: RL10.2 UL1.2(LANWAKE_N)
N65690245: JLOM1.B1(GREEN_LED-) RL19.2
N65690269: JLOM1.B3(ORANGE_LED-) RL20.2
N65690285: JLOM1.A2(AMBER_LED-) RL14.2
N65693167: RT608.2 UT5.K11(LSTX_P2/GPIO_K11)
N65693169: RT609.2 UT5.L11(LSRX_P2/GPIO_L11)
N65693231: RT606.1 UT5.A10(LSTX_P1/GPIO_A10)
N65693249: RT607.1 UT5.A11(LSRX_P1/GPIO_A11)
N65693414: RT589.1 UT5.B8(VCON_OCP_TRIP_P1 / GPIO_B8)
N65693416: RT590.1 UT5.B9(VCON_OCP_TRIP_P2 / GPIO_B9)
N65693455: UT9.2(EN) UT10.4(Y)
N65693509: CT377.1 UT9.5(VREG)
N65693585: QT9.1(D) RT588.2
N65693599: QT8.1(D) RT586.2
N65693710: RT571.2 UT9.12(VLIM)
N65693770: CT378.2 UT9.10(DV/DT)
N65693929: RT573.2 UT9.9(IMON)
N65694167: QT6.1(D) RT565.2
N65694171: QT7.1(D) RT566.2
N65694331: RT580.1 UT5.A8(UART_TX_P1/GPIO_A8)
N65694363: RT579.1 UT5.A9(UART_RX_P1/GPIO_A9)
N65694436: UT11.2(EN) UT12.4(Y)
N65694446: CT379.1 UT11.5(VREG)
N65694464: RT575.2 UT11.12(VLIM)
N65694480: CT380.2 UT11.10(DV/DT)
N65694514: RT577.2 UT11.9(IMON)
N65695146: RT581.2 UT5.J11(UART_RX_P2/GPIO_J11)
N65695150: RT582.2 UT5.H11(UART_TX_P2/GPIO_H11)
N65695262: CT348.2 UT5.B10(VCCD)
N65698424: JKBTP1.11 RZ1484.1
N65699658: JNGFF1.56 RZ371.1
N65899662: QZ3.1(C) RZ25.1
N66179590: PR1216.2 PU1200.17(THWN)
N66179919: PR1217.2 PU1200.16(DISB#)
N66180146: PR1219.2 PU1201.16(DISB#)
N66180155: PR1218.2 PU1201.17(THWN)
N66180292: PR1221.2 PU1202.16(DISB#)
N66180301: PR1220.2 PU1202.17(THWN)
N66180583: PR1223.2 PU1203.16(DISB#)
N66180592: PR1222.2 PU1203.17(THWN)
N66458439: QV23.2(G) RV907.2 RV908.1
N66458510: QV23.5(G) QV23.6(D) RV909.2
N66496263: CV954.1 QZ1.2(G) RZ545.2
N66582754: QV2.1(D) RV5.2
N67018687: JDIMM1.162(C0/CS2_N/NC) T46.1
N67018696: JDIMM1.165(C1, CS3_N,NC) T47.1
N67019568: CD25.2 RD12.1
N67027606: RD34.2 RD36.2 RD37.1
N67027671: CD87.2 RD33.1
N67554963: QN1.5(G) QN1.6(D) RN2.2
N67733464: RV821.2 UV60.1(B) UV68.4(OUT Y)
N67733473: RV820.2 UV68.2(IN A) UV69.4(Y)
N67734272: DV39.2 UV65.4(OUT Y)
N67938551: QZ18.5(G) QZ18.6(D) RZ381.2
N67938583: QZ17.5(G) QZ17.6(D) RZ377.2
N69335317: CH340.1 QH7.2(G) RH432.2 RH433.1
N69765028: QV44.1(S) RV742.1
N69765114: QV44.5(G) RV741.1
N70483327: RT499.2 UT34.1(IN1)

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; FD5 1; FD6 1; JAPS1 16 17 18; JDGFF1 C10 F10; JDGFF2 A10 C10; JDGFF4 C1 C6 G2 G3 G5 G6 G8 G9 H1 H2 H4 H5 H7 H8 H10; JEDP1 5; JIR1 4; JKBTP1 4; JLED1 5 6; JNGFF1 6 8 9 11 12 13 14 17 18 19 20 23 24 26 50 52 54 58 60 62; JNGFF2 10 12 14 16 17 20 30 32 34 36 38 40 48 50 51 53 55 57 59; JNGFF3 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 59; JNGFF4 6 20 22 24 26 28 30 36 48 56 58 67; JNGFF5 6 20 22 24 26 28 30 32 34 36 38 40 42 44 46 48 56 58 59; JNGFF6 6 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 59; JSIM1 1 5; JUSH1 2 25; PBATT1 11 12; PD10 3; PJPDC1 1; PQ704 3 4 5; PQ2002 3 4 5; PQ2102 3 4 5; PQ2106 3 4 5; PU100 10 15; PU101 10; PU400 5; PU500 10; PU501 10 15; PU700 4; PU900 5; PU1200 6 13 19; PU1201 6 13 19; PU1202 6 13 19; PU1203 6 13 19; PU1700 6 13 17 19; PU1800 6 13 17 19; RE749 2; RH99 2; RZ78 1; RZ79 1; RZ80 1; RZ81 1; RZ114 1; RZ364 1; RZ525 2; RZ526 2; RZ527 2; RZ528 2; RZ529 2; RZ530 2; RZ531 1; RZ532 1; RZ533 1; RZ534 1; RZ535 1; RZ536 1; RZ1483 1; UA1 1 6 7 8 9 10 11 12 13 47; UC1 BM31 BT30; UD1 1; UE1 J7 K1 K7; UE4 1; UE11 1; UE12 1 3 6 9 17 20; UH1 A25 AA1 AA45 AB2 AB3 AB48 AC6 AC7 AC39 AC43 AC44 AD47 AD48 AE9 AE11 AE39 AE44 AE48 AF47 AG45 AH40 AH46 AH47 AH48 AJ46 AJ47 AL15 AM7 AM45 AN4 AN29 AN37 AN40 AN46 AP2 AP3 AP21 AP41 AP47 AP48 AR13 AR48 AT10 AU46 AV7 AV18 AV21 AW3 AW18 AW21 B15 B25 B26 B27 BA33 BA36 BC17 BC33 BD8 BD12 BD17 BD21 BD30 BD34 BD38 BE12 BE19 BE23 BE29 BE33 BE34 BF10 BF33 BF36 C15 C16 C17 C26 C27 D29 E28 F14 F26 G1 G2 G14 G26 J13 K13 K29 L3 L4 L26 L46 L47 L48 M6 M26 M29 M45 N2 N3 N8 N32 N47 N48 P24 P47 P48 R24 R32 R46 R47 T1 T2 T45 T46 T48 U47 U48 V2 V3 V47 V48 W46 W47 Y2 Y46 Y47 Y48; UI1 9 15; UI2 9 15; UI3 9 15; UT1 AB3 AB5 AB15 AB17 AB19 AB21 AB23 AC3 AC5 AC15 AC17 AC19 AC21 B23 H5 J9 J11 N4 N5 V8; UT5 B3 B6 B7 F10 G8 G10 H4 H5 H8 J1 K5 K8 L2; UT7 3; UT9 6 7 14; UT11 6 7 14; UV8 2 4 14 58; UV64 22 23 24 25 50 53; UV66 30 33 34 35 36 63 64 65 66; UV67 30 33 34 35 36 63 64 65 66; UV69 1; UZ12 2 4 5 6 7 10 11 12 15 25 26 28 30 31; UZ61 1

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 1131 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 9085 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 196 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 159 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.6V_DDR_VTT_ON: length 64.3
  TOP w0.109: PR210.1 108.8,14.54 108.23,14.54 107.99,14.3 107.99,12.74 v2(107.75,12.51)
  IN2 w0.081: v2(149.99,12.23) 148.88,13.34 146.01,13.34 145.02,12.35 134.84,12.35 133.7,13.49 133.7,15.82 132.9,16.61 130.5,16.61 129.83,17.28 129.83,19.55 129.38,20 126.94,20 125.19,21.75 123.55,21.75 122.52,20.72 120.93,20.72 118.16,17.95 118.16,17.06 116.24,15.14 114.83,15.14 114.19,14.5 112.9,14.5 110.36,11.95 108.31,11.95 v2(107.75,12.51)
  BOTTOM w0.109: UD1.4 150.43,16.87 150.34,16.96 149.99,16.96 149.26,16.23 149.26,16.02 149.53,15.75 149.78,15.75 149.99,15.54 v1(149.99,12.96) v2(149.99,12.23)
1.2V_SUS_PWRGD: length 3.9
  TOP w0.109: v1(109.41,9.74) 110.06,10.39 PR205.2
  TOP w0.203: PR205.2 110.25,11.03 110.62,11.39 110.62,11.77 111.25,12.4 PU200.10
3.3V_CAM_EN#: length 141.9
  TOP w0.109: UH1.BE18 123.79,39.89 122.88,39.89 v2(122.76,40.01) ; v1(110.92,35.97) RH736.2 112.49,35.97 v2(112.84,36.31)
  IN1 w0.102: v2(112.84,36.31) 112.14,37.01 112.14,39.53 111.78,39.89 111.78,41.75 111.97,41.93 111.97,50.13 110.51,51.58 110.51,56.78 109.38,57.91 109.38,63.93 108.91,64.4 108.91,66.75 111.21,69.05 111.21,70.78 111.94,71.51 111.94,75.38 113.4,76.84 113.4,83.92 115.2,85.72 115.2,89.11 112.96,91.35 112.96,94.88 111.72,96.12 110.66,96.12 110.25,96.53 110.25,105.26 107.83,107.68 107.83,112.37 110.05,114.6 110.05,126.25 v2(112.47,128.67)
  IN2 w0.081: v2(112.47,128.67) 114.17,130.37 v2(127.63,130.37) ; v2(112.84,36.31) 112.84,36.59 113.47,37.22 113.8,37.22 114.41,37.83 114.67,37.83 115.39,38.55 116.62,38.55 117.62,37.56 119.07,37.56 119.55,38.03 122.31,38.03 122.92,38.64 122.92,39.88 122.79,40.01 v2(122.76,40.01)
  BOTTOM w0.109: RZ545.1 130.73,133.47 v2(127.63,130.37)
3.3V_RUN_GFX_ON: length 346.5
  TOP w0.109: UE1.K9 v2(139.61,71.68) ; UZ41.5 300.07,67.85 v2(300.17,67.96) ; QZ20.2 133.05,87.82 RZ547.1 v2(131.16,86.55)
  IN1 w0.102: v2(144.16,95.39) 143.29,94.53 143.29,91.31 141.48,89.5 141.48,83.92 140.62,83.07 139.46,83.07 139.06,82.67 139.06,80.46 138.17,79.57 138.17,75.29 139.22,74.25 139.22,72.07 v2(139.61,71.68) ; v2(130.44,93.39) 130.57,93.26 130.57,90.36 130.55,90.35 130.55,87.16 v2(131.16,86.55)
  IN2 w0.081: v2(154.89,58.43) 153.73,59.6 153.43,59.6 150.51,62.52 149.79,62.52 147.75,64.56 143.16,64.56 141.34,66.37 141.34,68.74 140.85,69.23 139.84,69.23 139.2,69.86 139.2,71.27 v2(139.61,71.68)
  VCC w0.086: v2(154.89,58.43) 154.44,58.88 154.11,58.88 149.92,54.68 149.92,52.2 160.31,41.81 160.31,34.93 161.6,33.64 161.6,28.64 162.75,27.49 162.75,24.84 157.94,20.04 157.94,18.75 165.54,11.15 170.67,11.15 171.34,11.82 174.05,11.82 174.73,11.15 217.9,11.15 218.52,10.52 220.18,10.52 220.8,11.15 231.76,11.15 237.1,16.48 240.24,16.48 240.46,16.26 244.75,16.26 245.21,15.8 258.53,15.8 259.18,16.46 260.85,16.46 262,15.31 266.31,15.31 269.9,11.71 291.61,11.71 292.43,12.54 292.43,13.24 296.26,17.07 297.92,17.07 299.11,18.25 299.11,23.3 308.3,32.5 308.3,35.32 309.06,36.08 309.06,45.63 310.25,46.82 310.25,53.03 310.96,53.73 310.96,57.93 310.2,58.68 310.2,64.63 307.94,66.89 302.71,66.89 301.65,67.96 v2(300.17,67.96)
  IN3 w0.081: v2(144.16,95.39) 143.75,95.8 140.64,95.8 139.62,94.78 137.42,94.78 136.99,94.34 134.54,94.34 133.58,93.39 v2(130.44,93.39)
  BOTTOM w0.109: v2(300.17,67.96) 300.05,67.83 RZ548.1
3.3V_WWAN_EN: length 34.5
  TOP w0.203: UZ44.5 148.43,102.13 148.59,101.97
  TOP w0.254: R129.1 150.62,101.5 148.78,101.5 v2(148.7,101.42) 148.7,101.86 148.59,101.97 ; UE1.C6 v2(136.47,78.02)
  IN1 w0.254: v2(136.47,78.02) 136.47,78.88 136.95,79.37 137.42,79.37 137.62,79.57 137.62,80.6 136.93,81.29 136.93,82.47 137.3,82.83 137.3,84.66 138.1,85.46 139.19,85.46 140.33,86.6 140.33,89.52 142.67,91.86 142.67,95.88 144.85,98.07 v2(144.85,98.9)
  IN2 w0.254: v2(148.7,101.42) 146.17,98.9 v2(144.85,98.9)
3V_FB: length 1.8
  TOP w0.254: PU100.13 133.72,112.48 133.61,112.59 v2(133.31,112.59) 132.85,112.59 PC112.1
+0.6V_DDR_VTT: length 57.8
  IN1 w1.778: 143.84,11.88 141.07,9.11 135.37,9.11 133.98,7.72 127.7,7.72 124.08,11.34
  IN1 w2.032: 176.22,85.77 174.29,83.83 174.29,75.44 174.03,75.17 174.03,61.36 173.19,60.52
  BOTTOM w0.305: JDIMM1.258 180.57,81.98
  BOTTOM w0.508: v2(176.89,87.29) 177.81,86.36 178.08,86.36 180.17,84.27 180.17,82.38 180.57,81.98
  vias: v2(121.41,11.91) v2(121.99,11.91) v2(122.58,11.91) v2(143.86,13.63) v2(143.86,13.05) v2(144.45,13.63) v2(144.45,13.05) v2(164.62,40.01) v2(164.62,39.42) v2(165.2,40.01) v2(165.2,39.42) v2(175.92,87.85) v2(176.13,87.29) v2(176.5,87.85) v2(177.62,94.93) v2(178,94.34) v2(178.2,94.93) v2(178.6,94.33) v2(199.31,80.69) v2(199.95,80.69) v4(176.13,91.34)
+0.6V_P:
  vias: v1(115.86,16.25)
+0.9V_LAN: length 17.5
  TOP w0.203: v2(153.46,135.91) 153.46,136.11 153.38,136.19 UL1.43 ; v2(153.95,142.05) 154.18,142.28 UL1.16 ; v2(157.11,141.9) 156.97,141.9 156.7,141.63 UL1.11 ; UL1.46 154.58,135.94 v2(155.08,135.43) ; UL1.37 150.98,135.99 v2(150.61,135.63) ; UL1.40 152.18,135.69 v2(152.17,135.69) ; v2(151.64,144.11) 151.64,144.08 151.78,143.94 UL1.22 ; v2(156.06,135.5) 155.65,135.91 155.28,135.91 154.98,136.22 UL1.47 ; v2(157.22,140.78) 156.86,140.43 UL1.8
  TOP w0.356: CL4.1 155.72,134.8 v2(155.08,135.43) ; CL12.1 156.61,134.95 v2(156.06,135.5)
  TOP w0.508: CL9.1 150.45,135.46 v2(150.61,135.63)
  BOTTOM w0.127: CL10.1 v1(153.95,143.77)
  BOTTOM w0.508: CL11.1 151.8,143.92 151.64,144.08 v2(151.64,144.11) ; v2(153.95,142.05) CL10.1
  vias: v2(161.44,138.71) v2(161.83,139.23)
+0.9V_TBT_LC: length 1.1
  TOP w0.305: v2(36.44,49.79) 36.39,49.74 CT333.1
  BOTTOM w0.254: v2(36.44,49.79) UT1.J8
+0.9V_TBT_LVR_OUT: length 5.4
  TOP w0.254: 33.89,48.53 34.14,48.78 34.14,48.8 v1(34.65,49.32) 35.12,49.78 v2(35.14,49.78) ; 33.89,48.53 CT332.1 ; 33.89,48.53 CT331.1
  TOP w0.381: CT330.1 CT329.1 33.01,47.68 CT332.1
  BOTTOM w0.203: UT1.H8 35.46,49.46 v2(35.14,49.78) 35.46,50.11 UT1.H6
+0.9V_TBT_PCIE: length 8.2
  TOP w0.254: v2(37.09,45.24) 37.67,45.82 CT338.1 ; v2(36.44,44.59) v1(36.95,44.59) 37.09,44.59 37.72,43.96 37.72,43.41 CT339.1
  TOP w0.356: CT337.1 38.02,42.71 CT341.1 CT340.1 37.07,43.92 v2(37.09,43.94)
  BOTTOM w0.254: UT1.L18 v2(36.44,44.59) UT1.J18 ; UT1.M16 v2(37.09,45.24) UT1.M18 ; UT1.M19 v2(37.09,43.94) UT1.L19
+0.9V_TBT_SVR: length 24
  TOP w0.203: CT310.1 37.65,47.92 v2(37.74,47.84)
  TOP w0.254: v2(33.82,49.15) 33.82,49.15 33.18,49.8 CT320.2
  TOP w0.305: CT319.2 35.72,45.95 v2(35.79,45.89) ; CT316.2 38.39,47.83 v2(38.39,47.84) ; v2(35.14,48.49) 35.18,48.53 CT306.1 ; v2(39.04,45.24) 39.55,45.75 CT321.2 ; CT311.1 39.47,48 39.04,48.43 v2(39.04,48.49) ; CT318.2 36.37,47.77 v2(36.44,47.84) ; v2(35.79,47.19) 35.78,47.19 CT308.1 CT305.1
  TOP w0.356: v2(39.69,46.54) 39.7,46.55 CT322.2
  TOP w0.381: CT309.1 36.99,46.63 v2(37.09,46.54) ; v2(37.74,49.79) 37.58,49.63 CT307.1 ; CT317.2 38.39,46.54 v2(38.39,46.54)
  BOTTOM w0.203: UT1.N11 v2(37.74,47.84) UT1.M11 ; UT1.T12 UT1.T13 v2(39.69,46.54) UT1.T15 ; 39.06,49.16 39.01,49.16 UT1.R8 ; 39.06,49.16 UT1.T8 ; 39.06,49.16 39.06,49.11 UT1.T9 v2(39.04,48.49) ; v2(37.74,49.79) 38.06,49.46 UT1.N8 ; UT1.T16 v2(39.04,45.24) UT1.R16 ; UT1.H13 v2(35.79,47.19) UT1.H12 ; v2(33.82,49.15) 33.82,49.15 33.83,49.16 33.84,49.16 33.84,49.16 33.85,49.16 UT1.E8 ; v2(39.04,48.49) UT1.R11 v2(38.39,47.84) ; v2(39.04,48.49) 39.36,48.16 UT1.T11 ; UT1.R13 v2(38.39,46.54) UT1.N13 ; UT1.L13 v2(36.44,47.19) UT1.J13 ; UT1.H15 v2(35.79,45.89) UT1.H16 ; UT1.M13 v2(37.09,46.54) ; v2(36.44,47.84) UT1.L11
  BOTTOM w0.254: UT1.M8 v2(37.74,49.79) UT1.N6 ; UT1.H11 35.46,48.16 v2(35.14,48.49) UT1.H9
  vias: v1(30.53,61.43) v2(32.15,61.25) v2(32.34,60.69) v2(32.77,61.29) v2(33.37,61.28) v2(34.06,61.28)
+1.0V_ALW_PCH: length 72.2
  TOP w0.508: v2(146.56,60.19) 146.07,59.7 LH421.1 ; RH255.1 118.36,23.64 v2(117.67,22.94) ; v2(148.17,16.31) 147.09,16.31 146.96,16.17 145.8,16.17 145.68,16.05 LH423.1
  IN1 w0.508: v2(135.58,42.18) 135.58,42.43 136.63,43.48 137.11,43.48 137.43,43.16 138.21,43.16 138.54,42.82 138.54,42.45 138.62,42.37 138.62,41.89 138.88,41.62 138.88,41.44 139.06,41.26 141.44,41.26 v2(141.57,41.13)
  IN2 w0.508: v2(148.17,16.31) 148.17,19.59 147.69,20.06 147.69,22.32 148.05,22.68 148.05,26.78 146.17,28.66 146.17,29.66 146.76,30.24 146.76,30.71 147.14,31.09 149.07,31.09 149.36,31.38 v2(149.36,31.98) ; 124.74,29.89 124.36,29.5 123.89,29.5 123.67,29.28 123.67,28.73 122.28,27.35 121.47,27.35 120.53,26.41 120.53,25.13 118.35,22.94 v2(117.67,22.94)
  IN4 w0.508: v2(146.56,60.19) 144.32,57.95 v2(144.32,56.7)
  BOTTOM w0.381: RH260.1 141.47,41.23 v2(141.57,41.13) 141.84,40.86 141.84,40.14 141.63,39.93 RH286.1 ; RH258.1 136.35,40.72 136.35,40.77 135.91,41.21 RH257.1 135.91,41.85 v2(135.58,42.18)
  BOTTOM w0.508: v2(138.45,51.03) 138.45,51.39 138.96,51.89 RH171.1 ; v2(144.32,56.7) 145.62,55.4 RH241.1 145.62,54.44 CH29.1 147.83,54.44 150.06,52.21 150.12,52.21 150.65,51.69 RH259.1 150.65,48.07 150.21,47.64 RH240.1
  vias: v1(151.03,33.71) v2(131.57,32.91) v2(135.33,32.65) v2(149.35,32.58) v2(149.88,46.94) v2(149.91,32.57) v2(149.97,32.01) v2(150.47,46.94) v2(150.47,32.58) v2(150.6,32.02) v2(151.05,32.65) v2(151.18,32.07)
+1.0V_AMPHYPLL: length 10.4
  TOP w0.508: LH423.2 145.37,17.49 145.37,18.23 v1(145.34,18.27) 144.45,19.15 CH560.1 144.3,20.2 CH324.1 144.3,20.55 CH555.1 CH267.1 145.87,21.86 146.51,22.49 146.51,23.64 145.9,24.25 145.4,24.25
+1.0V_AZPLL: length 7.6
  TOP w0.254: UH1.E1 UH1.D1
  TOP w0.381: v2(145.67,50.08) 145.63,50.04 145.35,50.04 144.17,48.86 UH1.D1
  BOTTOM w0.127: v1(144.21,53.96) 145.13,53.04 RH241.2
  BOTTOM w0.381: RH241.2 145.62,52.14 CH32.1 CH46.1 v2(145.67,50.08)
+1.0V_BCLKPLL2: length 2.8
  BOTTOM w0.109: RH259.2 149.73,51.81 v1(149.24,52.3)
  BOTTOM w0.33: LC2.1 149.17,50.61 149.08,50.69 CC330.1 149.21,51.32 RH259.2
+1.0V_BCLKPLL2_R: length 5.5
  TOP w0.254: v2(145.77,49.01) 145.3,48.54 UH1.B1 145.05,48.09 UH1.B2 UH1.B3
  BOTTOM w0.254: v2(145.77,49.01) 145.81,49.05 v1(146.38,49.05) 146.86,49.53 CH31.1 147.79,49.53 147.86,49.46 CC311.1 148.42,49.72 LC2.2
+1.0V_CLPLLEBB: length 4.8
  TOP w0.254: v2(136.13,34.01) 136.13,33.98 136.48,33.63 UH1.W31
  BOTTOM w0.109: v2(136.13,34.01) 136.12,34.01 v1(135.74,34.39)
  BOTTOM w0.254: RH290.2 134.78,33.24 CC328.1 136.23,33.01 CH66.1 136.92,33.33 136.24,34.01 v2(136.13,34.01)
+1.0V_DSW: length 5.5
  TOP w0.254: 122.42,25.9 122.68,26.17 122.8,26.17 UH1.BG46 UH1.BG45
  TOP w0.381: 122.42,25.9 121.04,24.53 CH35.1 RH255.2
+1.0V_DUSB: length 5
  TOP w0.254: UH1.W22 136.56,38.28 v2(136.91,37.93) 136.91,37.88 UH1.W23
  BOTTOM w0.508: RH286.2 138.75,39.58 CH38.1 138.51,38.74 138.38,38.88 138.35,38.88 138.31,38.92 137.84,38.92 137.5,38.58 v1(137.5,38.24) 137.19,37.93 v2(136.91,37.93)
+1.0V_MPHY: length 7.6
  TOP w0.203: v2(137.67,34.02) 137.31,33.66 UH1.V31 137.27,33.63 v2(136.88,34.02) ; UH1.U29 UH1.V28 ; UH1.V28 v2(136.91,34.79) ; UH1.V28 137.35,35.18 v2(137.72,35.55) 137.31,35.96 UH1.V27 137.31,36.01 136.96,36.36 v2(136.93,36.36) UH1.V25 137.58,36.41 UH1.U26
  TOP w0.254: v2(137.67,34.02) 137.31,34.38 UH1.V30 ; v2(136.88,34.02) 136.92,34.02 UH1.V30 ; UH1.V30 137.47,34.57 137.64,34.57 UH1.U29 ; UH1.V30 136.93,34.79 v2(136.91,34.79)
  vias: v1(145.4,34.5)
+1.0V_OC: length 5.4
  TOP w0.254: UH1.V19 137.31,39.71 136.93,39.33 v2(136.93,38.57)
  BOTTOM w0.305: RH260.2 138.63,41.23 138.33,40.92 138.29,40.92 CH44.1 137.95,39.73 v1(137.75,39.54) 137.23,39.02 137.23,39.01 136.93,38.71 v2(136.93,38.57)
+1.0V_OCPLL1: length 4.2
  BOTTOM w0.305: 148.18,46.65 148.18,46.57 v1(147.6,45.99) 147.22,45.99 CC332.1 146.65,46.55 LC3.1
  BOTTOM w0.508: RH240.2 148.18,46.98 148.18,46.65
+1.0V_OCPLL1_R: length 5
  TOP w0.254: v2(145.16,49.11) 144.67,48.63 UH1.C1 UH1.C2
  BOTTOM w0.109: CH20.1 144.54,47.94 v1(144.02,48.47)
  BOTTOM w0.305: LC3.2 145.52,47.79 CC331.1 145.1,49.05 v2(145.16,49.11)
  BOTTOM w0.356: CH20.1 CC331.1
+1.0V_PRIM_CNV_HVLO: length 2.8
  TOP w0.254: UH1.AE17 133.63,40.65 133.88,40.4 v2(133.93,40.4)
  BOTTOM w0.109: v1(134.24,39.91) 133.93,40.21 v2(133.93,40.4)
  BOTTOM w0.305: v2(133.93,40.4) 133.93,40.63 134.72,41.42 RH257.2
+1.0V_PRIM_FUSE: length 4.5
  TOP w0.203: UH1.AD31 v2(134.6,34.02)
  BOTTOM w0.381: RH256.2 132.72,35.65 133.78,35.65 v1(133.87,35.56) 134.02,35.41 134.02,34.6 v2(134.6,34.02)
+1.0V_PRIM_XDP: length 27.5
  TOP w0.109: v1(246.06,19.75) 246.17,19.86 v2(246.17,20.33)
  IN4 w0.508: v2(258.73,17.12) 257.27,18.58 248.67,18.58 246.92,20.33 v2(246.17,20.33)
  BOTTOM w0.305: 244.56,20.36 243.38,19.18 JXDP1.44 243.38,18.22 242.86,17.69 242.86,16.82 243.68,15.99 JXDP1.43 243.68,14.33 243.54,14.19 CC28.1
  BOTTOM w0.356: 246.88,21.03 246.84,21.07 246.11,21.07 CC29.1 245.11,21.34 RC115.2
  BOTTOM w0.508: v2(258.73,17.12) 258.99,16.86 258.99,16.41 RC138.1 ; 244.56,20.36 244.98,20.78 244.98,21.21 RC115.2 ; v2(246.17,20.33) 246.88,21.03 RC216.2
+1.0V_SRC: length 2.5
  TOP w0.203: UH1.W20 v2(136.15,39.44) UH1.W19
  BOTTOM w0.109: v1(135.79,40.05) 135.79,39.8 v2(136.15,39.44)
  BOTTOM w0.305: RH258.2 136.18,39.41 v2(136.15,39.44)
+1.0V_VCCSFR: length 1.1
  TOP w0.109: RC304.2 v1(267.46,69.01)
+1.0V_VCCSFR_R: length 35.9
  TOP w0.109: LC562.2 v1(265.32,69.17)
  TOP w0.254: v2(250.7,61.79) 250.7,61.99 v2(251.03,62.31) 251.41,62.69 251.41,62.69 UC1.J28 UC1.H28
  IN1 w0.381: 254.02,62.58 257.16,62.58 257.98,63.4 258.87,63.4 260.22,64.75 260.22,66.29 v2(260.91,66.98)
  IN3 w0.508: v2(261.44,67.26) 265,67.26 265.73,66.53 265.73,64.28 263.86,62.42 263.34,62.42 263,62.75 260.46,62.75 260.08,63.13 256.99,63.13 256.65,62.79 253.66,62.79 253.29,63.16 252.48,63.16 252.01,62.69 251.41,62.69 v2(251.03,62.31)
+1.0V_VCCST: length 356.1
  TOP w0.203: v2(253.43,63.79) 253.42,63.79 253.03,63.4 UC1.H30
  TOP w0.305: PR1104.1 311.41,39.13 PR1199.1 311.41,39.11 PR1105.2 PR1103.1 311.43,37.2 PC1101.2 312.29,36.51 v2(312.24,36.46)
  TOP w0.508: v2(159.84,61.56) 159.84,60.92 158.9,59.98 154.76,59.98 151.66,63.08 151.66,66.79 149.97,68.48 v2(148.85,68.48) ; v2(259.69,11.58) 260.33,10.94 264.45,10.94 v2(265.15,11.64) ; v2(267.82,17.97) 267.82,17.58 266.7,16.46 262.06,16.46 259.64,18.89 259.64,19.79 258.61,20.82 RC79.1
  IN1 w0.508: v2(257.44,73.1) 257.44,74.44 256.8,75.07 255.53,75.07 254.84,74.37 254.84,70.31 253.88,69.36 253.88,67.96
  IN2 w0.254: v2(277.65,69.13) 279.12,70.6 v2(279.12,71.77)
  IN2 w0.508: v2(169.42,66.44) 167.59,66.44 163.46,62.31 162.05,62.31 161.3,61.56 v2(159.84,61.56)
  IN3 w0.508: v2(253.43,63.79) 253.85,63.79 254.9,64.83 254.9,66.03 254.5,66.43 254.5,66.95 253.72,67.74 251.1,67.74 250.63,68.2 250.63,68.77 249.29,70.12 238.16,70.12 235.71,67.67 234.63,67.67 234.07,68.23 234.07,69.38 231.04,72.42 223.01,72.42 213.24,82.19 195.03,82.19 194.11,81.27 191.02,81.27 190.17,82.12 189.23,82.12 188.55,82.79 179.65,82.79 179.18,82.32 177.29,82.32 176.44,83.17 174.43,83.17 173.29,82.03 173.29,69.01 172.15,67.88 171.19,67.88 170.49,67.18 169.98,67.18 169.42,66.61 v2(169.42,66.44) ; v2(270.39,71.78) 269.64,71.78 266.96,69.1 262.27,69.1 261.06,70.31 260.61,70.31 258.39,72.53 258.01,72.53 v2(257.44,73.1)
  IN4 w0.381: v2(312.24,36.46) 311.35,37.35 308.97,37.35 308.14,38.18 308.14,47.74 308.97,48.57 308.97,51.5 305.8,54.66 294.31,54.66 293.44,53.79 291.48,53.79 290.73,54.53 290.43,54.53 289.99,54.97 289.99,57.19 287.78,59.4 287.43,59.4 287.16,59.67 287.16,63.77 286.79,64.14 284.53,64.14 283.54,65.14 283.54,67.64 282.59,68.59 278.18,68.59 v2(277.65,69.13)
  IN4 w0.508: v2(259.81,30.93) 259.81,40.07 258.95,40.93 258.95,44.33 259.28,44.66 259.28,55.11 262.92,58.75 262.92,60.61 261.08,62.45 259.65,62.45 259.2,62.9 257.09,62.9 256.85,62.66 253.94,62.66 253.43,63.17 v2(253.43,63.79)
  BOTTOM w0.254: v2(279.12,71.77) 279.36,71.53 280.39,71.53 281.62,72.75 281.62,74.21 281.12,74.71 UV69.5
  BOTTOM w0.381: RC80.1 277.01,66.95 RC71.1 277.03,67.79 RC166.1 277.06,68.54 v2(277.65,69.13)
  BOTTOM w0.508: v2(148.85,68.48) 147.18,68.48 RE59.1 ; v2(159.84,61.56) 160.3,61.1 RE90.2 ; RC218.1 259.25,12.02 v2(259.69,11.58) ; v2(259.81,30.93) 259.86,30.88 261.79,30.88 262.7,29.97 262.7,28.27 268.21,22.76 268.21,18.36 v2(267.82,17.97) v4(267.82,16.94) 267.82,12.31 267.14,11.64 v2(265.15,11.64) 265.17,11.66 RC152.1 265.17,12.69 265.25,12.77 RC157.1
  BOTTOM w0.889: 277.49,70 276.86,70.63 271.82,70.63 271.28,71.16 270.89,71.16
  vias: v2(270.9,72.21)
+1.0V_VCCST_C:
  vias: v1(273.45,74.14)
+1.0V_VCCSTG: length 282.1
  TOP w0.203: v2(251.55,61.94) 251.48,62 251.48,62.21 251.89,62.62 251.89,63.09 UC1.H29
  TOP w0.381: v2(264.95,64.58) 264.87,64.66 264.59,64.66 264.42,64.82 CC195.2 CC186.2 264.42,65.97 264.26,66.13 v2(262.88,66.13)
  TOP w0.508: RH315.2 128.09,57.34 128.93,58.18 128.93,58.91 ; 128.93,58.91 128.39,59.45 127.37,59.45 125.56,57.64 RH312.2 ; 128.93,58.91 129.29,59.27 129.94,59.27 v2(129.99,59.21) 130.23,58.98 130.23,57.69 130.11,57.58 RH314.2 ; v2(252.77,24.88) 252.38,24.49 RC83.1
  IN1 w0.508: v2(251.55,61.94) 251.62,61.94 252.49,61.07 252.49,60.82 253.09,60.21 257.11,60.21 257.67,60.78 257.67,62.33 258.21,62.87 259.44,62.87 260.76,64.18 260.76,65.74 261.2,66.18 262.82,66.18 v2(262.88,66.13)
  IN2 w0.381: v2(129.99,59.21) 130.17,59.39 130.17,63.06 130.65,63.54 131.83,63.54 132.42,62.94 141.13,62.94 141.25,62.83 145.79,62.83 146.97,61.65 147.44,61.65 147.99,61.1 v2(149.91,61.1)
  IN2 w0.508: v2(268.42,75.45) 268.42,72.3 v2(270.07,70.65)
  IN3 w0.381: v2(149.91,61.1) 149.95,61.14 149.95,61.54 153.67,65.25 157.14,65.25 158.81,66.92 158.81,68.51 161.38,71.08 161.38,74.32 164.41,77.36 165.59,77.36 173.43,85.19 179.34,85.19 180.54,84 188.71,84 189.89,85.19 193.22,85.19 194.86,83.54 216.87,83.54 218.29,82.13 221.74,82.13 222.01,81.86 229.85,81.86 231.9,79.81 231.9,74.82 233.25,73.47 236.38,73.47 236.89,72.96 237.92,72.96 238.25,73.3 254.3,73.3 255.04,72.56 255.04,68.46 255.74,67.76 256.31,67.76 256.51,67.55 257.78,67.55 259.08,66.26 261.19,66.26 261.61,66.68 263.18,66.68 264.95,64.91 v2(264.95,64.58)
  IN4 w0.381: v2(270.07,70.65) 270.07,69.44 268.28,67.65 267.93,67.65 265,64.72 265,64.63 v2(264.95,64.58) 264.86,64.58 264.48,64.2 264.48,62.13 263.82,61.48 263.82,56.91 262.85,55.93 262.85,39.16 261.06,37.37 261.06,26.82 260.46,26.22 258.05,26.22 256.83,27.43 254.43,27.43 253.76,26.76 253.76,25.34 253.3,24.88 v2(252.77,24.88) 252.77,25.49 253.11,25.83 253.11,26.32 252.22,27.21 247.98,27.21 247.89,27.12 247.42,27.12 247.33,27.21 246.88,27.21 246.61,26.94 246.22,26.94 246.05,27.12 245.26,27.12 245.08,26.94 243.57,26.94 242.6,25.96 v2(242.6,25.75)
  BOTTOM w0.109: v4(269.39,71.25) 269.98,70.65 v2(270.07,70.65)
  BOTTOM w0.508: v2(242.6,25.75) 242.6,24.95 241.97,24.32 RC135.2
+1.0V_VCCSTG_C:
  vias: v1(270.69,82.1)
+1.0V_XTAL: length 15.5
  TOP w0.152: 139.39,48.2 139.14,47.94 UH1.P2 139.14,47.44 UH1.P3
  TOP w0.381: 139.39,48.2 139.69,48.5 139.69,49.82 140.29,50.42 140.29,51.32 v1(140.63,51.66) 141.6,51.66 v2(141.6,51.65)
  TOP w0.508: LH421.2 CH45.2 144.21,57.74 143.71,57.24 v2(143.71,56.19)
  BOTTOM w0.508: v2(143.71,56.19) 143.68,56.16 143.34,56.16 142,54.82 142,54.21 141.6,53.81 v2(141.6,51.65)
+1.0VS_VCCIO: length 175.6
  TOP w0.203: v2(249.41,62.37) 249.48,62.31 250.26,62.31 250.62,62.67 UC1.J27 UC1.H27 ; v2(238.86,49.29) 238.83,49.16 UC1.AG12 ; UC1.H26 UC1.J26
  TOP w0.254: v2(249.41,62.37) 249.74,62.7 UC1.J26
  TOP w0.305: UC1.G19 244.2,63.93 244.2,63.47 UC1.H19 ; UC1.H21 UC1.G21 ; UC1.H17 UC1.G17
  TOP w0.381: RC2.1 226.69,65.85 226.96,66.12 228.91,66.12 v2(229.36,65.67) ; v2(261.1,14.05) 261.16,13.98 RC132.1
  IN1 w0.508: v2(261.1,14.05) 261.1,14.52 261.97,15.39 265.64,15.39 266.1,15.85 266.1,17.05 v2(266.06,17.09) 265.78,17.36 261.41,17.36 255.25,23.52 253.96,23.52 v2(253.5,23.07)
  IN3 w0.508: v2(229.36,65.67) 218.23,65.67 202.52,81.38 196.33,81.38 196.04,81.09 195.34,81.09 194.8,80.55 ; 174.67,81.18 174.32,80.83 174.32,68.01 172.51,66.2 170.3,66.2 169.79,65.7 v2(168.96,65.7)
  IN4 w0.508: v2(266.06,17.09) 266.06,17.61 269.87,21.43 269.87,24.35 265.25,28.97 265.25,49.88 266.14,50.77 266.14,60.02 266.52,60.4 266.52,63.01 v2(272.49,68.98)
  BOTTOM w0.305: v2(168.96,65.7) 168.81,65.55 164.31,65.55 163.04,64.28 160.88,64.28 v4(159.9,63.3) 159.27,62.66 159.27,60.64 158.87,60.25 157.82,60.25 157.43,59.86 QE11.1
  BOTTOM w0.508: RC1.2 270.08,68.17 270.29,68.39 270.29,68.62 270.55,68.87 272.39,68.87 v2(272.49,68.98) ; v2(253.5,23.07) 253.22,22.78 253.22,22.11 RC439.2
  vias: v2(241.18,62.12) v2(241.86,62.12) v2(242.8,62.12) v2(244.69,62.06) v2(245.31,62.07) v2(245.92,62.08) v2(295.35,58.84) v2(295.35,58.21) v2(295.35,57.55) v2(295.35,56.81) v2(295.96,58.87) v2(295.96,58.23) v2(295.96,57.57) v2(295.96,56.83) v2(296.54,58.87) v2(296.54,58.23) v2(296.54,57.57) v2(296.54,56.83)
+1.0VS_VCCIOP: length 12.5
  TOP w0.203: 297.1,60.19 296.49,60.8 296.49,62.65 297.48,63.64 298.32,63.64 299.21,64.53 v1(304.25,64.53) PR303.1
  vias: v2(298.02,59.96) v2(299.06,59.96) v2(299.06,59.32)
+1.2V_MEM: length 444.6
  TOP w0.203: UC1.AG5 v2(234.23,49.35) ; v2(234.23,49.35) UC1.AF6 ; v2(234.23,49.35) UC1.AF5 ; UC1.AR6 234.6,42.13 v2(234.27,41.82) ; v2(238.18,54.78) 238.22,54.74 238.22,54.61 UC1.Y12 ; UC1.AW6 234.32,39.38 v2(234.26,39.3) 234.59,38.9 UC1.AY6 ; UC1.AJ12 238.36,46.8 v2(238.18,46.55) UC1.AL11
  TOP w0.211: UC1.J6 234.6,63.29 v2(234.27,63.61) 233.95,63.29 UC1.J5
  TOP w0.254: v2(171.65,46.19) 171.95,46.48 JDIMM2.124 ; v2(238.2,41.07) 238.48,41.51 UC1.AT12 ; UC1.L6 234.6,61.6 v2(234.27,61.93) 234.6,62.25 UC1.K6 ; v2(238.2,62.86) 238.51,62.55 UC1.K12 238.68,62.3 238.68,61.89 238.51,61.72 UC1.L12 ; UC1.AE12 v2(238.83,51.1) ; UC1.AG9 236.56,48.97 v2(236.88,49.29)
  TOP w0.305: JDIMM2.54 172.23,28.98 172,28.75 171.29,28.75 170.74,29.27 v2(170.74,29.25) ; v2(185.37,62.69) 186.08,61.98 JDIMM4.178 ; JDIMM4.241 196.86,77.73 197.12,77.46 ; v2(185.53,52.25) 185.53,51.43 185.99,50.98 JDIMM4.142 ; JDIMM4.123 195.59,46.22 196.98,46.22 v2(197,46.24) ; JDIMM4.117 197.05,44.73 v2(198.58,46.25) ; v2(171.38,44.12) 171.38,43.89 171.78,43.48 JDIMM2.112 ; 183.19,49.21 183.16,49.23 JDIMM2.135 ; JDIMM2.75 182.9,34.23 183.44,34.78 184.23,34.78 184.49,34.52 CD42.1 184.08,33.9 v2(183.59,33.9) ; v2(198.69,24.09) 198.69,23.66 198.57,23.54 197.16,23.54 196.97,23.73 JDIMM4.33 ; JDIMM4.220 186.01,72.48 185.36,73.12 CD104.1 184.56,71.95 v2(184.43,71.82) ; JDIMM4.147 196.59,54.23 196.59,54.22 196.71,54.09 v2(196.71,53.38) ; JDIMM2.199 182.89,67.23 183.37,67.71 183.37,68.56 183.68,68.87 CD45.1 185.24,68.87 185.54,69.17 185.54,70.29 v2(185.65,70.39) ; JDIMM4.153 198.04,55.73 198.06,55.74 198.06,55.77 198.69,56.4 v2(198.69,56.63) ; v2(198.16,51.22) 197.66,50.73 JDIMM4.141 ; v2(171.2,73.19) 171.2,72.88 171.6,72.48 JDIMM2.220 ; v2(198.9,34.86) 198.26,34.23 JDIMM4.75 ; UC1.W6 234.6,54.71 v2(234.27,54.38) 234.27,54.31 UC1.AA6 ; JDIMM2.136 172.21,49.48 172.09,49.37 v2(170.97,49.37) ; v2(198.74,51.22) 198.74,51.03 196.94,49.23 JDIMM4.135 ; JDIMM2.130 172.03,47.98 171.66,48.36 v2(171.66,48.36) ; JDIMM2.142 172,50.98 v2(171.71,51.28) ; v2(197.59,46.23) 197.59,46.75 196.61,47.73 JDIMM4.129 ; v2(234.27,56.9) 234.6,57.22 UC1.T6 UC1.R6 ; JDIMM2.148 172.52,54.48 v2(171.91,53.87) 171.87,53.91 171.87,54.96 172.89,55.98 JDIMM2.154 ; JDIMM2.178 v2(172.16,61.98) ; UC1.AP7 234.86,43.35 UC1.AP6 UC1.AR6 ; 198.51,67.2 197.61,67.2 197.58,67.23 JDIMM4.199 ; v2(185.57,38.59) 185.57,38.71 186.34,39.48 JDIMM4.96 ; JDIMM2.118 172.73,44.98 172.07,44.33 v2(172.07,44.12) ; v2(184.32,17.86) 184.68,18.22 184.68,19.58 CD106.1 185.26,19.68 186.46,18.48 JDIMM4.12 ; v2(185.14,55.51) 184.71,55.08 184.71,54.94 184.67,54.9 CD114.1 185.43,54.47 185.43,54.48 JDIMM4.148 ; v2(171.44,19.17) 171.73,19.17 172.41,18.48 JDIMM2.12 ; v2(184.92,50.45) 184.64,50.73 CD50.1 184.27,50.73 JDIMM2.141 ; v2(170.74,40.09) 171.29,39.48 JDIMM2.96 ; JDIMM2.129 183.65,47.73 CD51.1 ; JDIMM4.163 196.43,58.23 v2(198.03,56.62) 197.31,56.62 196.7,57.23 JDIMM4.159 ; JDIMM2.111 183.17,43.23 ; JDIMM2.33 182.95,23.73 183.43,23.26 184.43,23.26 CD43.1 184.45,23.87 184.41,23.87 184.01,24.27 v2(183.84,24.27) ; CD118.1 185.83,49.53 185.88,49.48 JDIMM4.136 ; v2(185.47,77.25) 185.36,77.14 CD39.1 184.41,77.14 183.82,77.73 JDIMM2.241 ; v2(171.65,57.01) 171.76,57.01 172.23,57.48 JDIMM2.160 ; UC1.AR12 238.77,42.17 238.77,41.78 UC1.AT12 ; v2(183.9,28.25) 184.54,28.89 CD105.1 184.77,28.98 JDIMM4.54 ; JDIMM4.111 197.06,43.23 v2(197.27,43.44)
  TOP w0.356: v2(185.18,44.19) 184.92,43.93 CD115.1 ; JDIMM4.124 185.71,46.48 184.99,45.75 CD117.1
  TOP w0.508: v2(185.9,45.77) 185.55,45.42 CD117.1 ; 197.12,77.46 198.12,76.46 198.12,75.34 v2(198.11,75.33) ; v2(185.19,48.22) 184.22,47.25 CD51.1 ; v2(199.88,71.52) 199.88,68.57 198.51,67.2 ; CD118.1 184.89,49.53
  IN2 w1.016: 111.76,99.2 111.76,101.22 115.12,104.59 122.83,104.59 127.33,100.09 131.3,100.09 131.87,100.66 137.61,100.66 138.25,101.3 143.16,101.3 144.6,99.86 145.95,99.86 147.17,101.08 147.17,103.93 147.72,104.49 148.26,104.49 149.07,105.3 150.8,105.3 153.29,102.81 157.73,102.81 159.28,101.26 163.8,101.26 164.54,100.52
  IN3 w0.508: 108.74,97.2 107.39,95.86 107.39,88.15 107.03,87.79 107.03,86.15 107.39,85.79 107.39,85.36
  IN4 w0.508: 109.98,97.4 109.98,96.79 110.72,96.05 111.78,96.05 113.03,94.81 113.03,92.05 110.2,89.22 109.14,89.22 108.16,88.24 107.99,88.24 107.26,87.52 107.26,86.15 107.34,86.07 107.34,84.47
  BOTTOM w0.254: JDIMM1.241 172.26,77.73 v2(172.24,77.76) ; JDIMM1.159 172.23,57.23 v2(171.77,57.69) 171.88,57.69 172.42,58.23 JDIMM1.163 ; JDIMM3.147 185.79,54.22 185.1,53.53 185.1,53.09 ; JDIMM1.147 172.27,54.23 v2(171.91,53.87) 171.91,55.04 172.61,55.73 JDIMM1.153
  BOTTOM w0.305: CD75.1 185.51,67.24 185.52,67.22 JDIMM3.199 ; v2(183.89,40.15) 184.48,40.15 CD6.1 184.31,39.48 JDIMM1.96 ; v2(198.22,61.72) 198.22,62.08 198.02,62.28 196.82,62.28 196.51,61.97 JDIMM3.178 ; JDIMM3.220 198.1,72.47 198.16,72.53 CD73.1 ; JDIMM3.142 195.59,50.98 197.91,50.98 v2(198.16,51.22) ; JDIMM3.160 195.59,57.48 196.45,57.48 197.31,56.62 v2(198.03,56.62) ; CD9.1 170.72,23.89 171.07,24.25 171.84,24.25 172.36,23.73 JDIMM1.33 ; JDIMM1.148 183.14,54.48 183.2,54.54 ; v2(185.9,45.77) 186.36,46.23 187.39,46.23 JDIMM3.123 ; v2(186,55.49) 186.24,55.72 JDIMM3.153 ; JDIMM1.141 172.65,50.73 172.1,51.28 v2(171.71,51.28) ; v2(185.18,44.19) 185.09,44.29 CD23.1 184.17,44.29 183.37,43.48 JDIMM1.112 ; v2(198.91,28.04) 199.15,28.29 CD72.1 199.14,28.98 195.59,28.98 JDIMM3.54 ; v2(185.47,77.25) 185.32,77.1 184.67,77.1 184.45,77.31 CD71.1 185.57,77.87 185.72,77.72 JDIMM3.241 ; JDIMM3.33 186.06,23.72 185.68,23.34 CD68.1 184.67,23.34 183.84,24.17 v2(183.84,24.27) ; JDIMM1.130 182.86,47.98 183.53,47.32 CD24.1 ; v2(183.9,28.25) 183.95,28.29 184.36,28.29 184.68,28.61 CD7.1 183.62,29.26 183.34,28.98 JDIMM1.54 ; JDIMM1.142 182.91,50.98 183.74,50.15 CD79.1 184.62,50.15 v2(184.92,50.45) ; v2(183.59,33.9) 183.77,34.08 183.77,34.48 183.96,34.67 CD70.1 184.78,33.95 185.19,33.54 185.75,33.54 186.43,34.22 JDIMM3.75 ; JDIMM1.75 172.6,34.23 171.94,33.57 CD8.1 170.6,34.47 v2(170.61,34.48) ; CD86.1 184.67,45.47 185.02,45.12 185.23,45.12 185.58,44.78 185.58,44.73 187.39,44.73 JDIMM3.117 ; JDIMM3.118 195.59,44.98 196.59,44.98 197,45.38 v2(197,46.24) ; JDIMM1.199 172.31,67.23 171.76,66.68 171.33,66.68 170.69,67.32 CD11.1 ; v2(183.89,62.63) 183.77,62.5 183.41,62.5 182.89,61.98 JDIMM1.178 ; CD84.1 184.29,54.97 184.24,55.01 184.24,55.04 v2(183.79,55.5) ; JDIMM1.220 183.17,72.48 183.68,72.99 CD10.1 184.68,72.93 184.68,72.07 v2(184.43,71.82) ; JDIMM3.148 196.44,54.47 196.71,54.2 v2(196.71,53.38) 196.86,53.23 199.97,53.23 202.28,55.54 CD77.1 ; v2(184.32,17.86) 184.56,17.86 184.86,18.17 CD12.1 183.8,18.53 183.75,18.48 JDIMM1.12 ; JDIMM3.159 186.09,57.22 v2(185.99,57.33) ; v2(198.89,20.16) CD69.1 198.68,18.47 JDIMM3.12 ; JDIMM3.154 196.97,55.97 197.05,55.89 CD85.1 ; JDIMM3.112 195.59,43.48 197.23,43.48 v2(197.27,43.44) 197.78,42.93 198.14,42.93 198.42,43.21 CD82.1 ; v2(171.38,44.12) 171.38,44.34 171.77,44.73 JDIMM1.117 ; v2(198.48,38.73) 198.64,38.89 CD74.1 197.41,39.58 197.31,39.48 195.59,39.48 JDIMM3.96 ; JDIMM3.130 195.59,47.98 196.96,47.98 197.22,47.72 197.68,47.72 CD81.1 ; JDIMM3.124 196.46,46.47 196.74,46.76 197.25,46.76 197.59,46.42 v2(197.59,46.23) ; JDIMM3.111 185.7,43.22 CD80.1 184.39,42.51 v2(184.04,42.17) ; CD121.1 198.74,51.95 v2(198.74,51.22) 198.74,50.45 CD83.1 198.07,50.43 197.65,50.01 197.09,50.01 196.55,49.47 JDIMM3.136 ; JDIMM1.129 172.28,47.73 v2(171.66,48.36) 171.92,48.36 172.8,49.23 JDIMM1.135 ; JDIMM1.123 171.7,46.23 v2(171.65,46.19) ; JDIMM1.111 172.51,43.23 172.07,43.67 v2(172.07,44.12)
  BOTTOM w0.356: CD116.1 198.63,56.69 v2(198.69,56.63) 198.63,56.57 CD85.1 ; v2(164.84,56.99) 165.27,57.42 RD8.1 CD16.1 ; CD84.1 183.2,54.54
  BOTTOM w0.457: CD111.1 199.02,23.77 v2(198.69,24.09) ; v2(183.79,48.43) 183.79,48.2 184.17,47.82 CD24.1
  BOTTOM w0.508: RD34.1 CD96.1 208.08,59.67 208.44,59.31 208.44,58.47 207.88,57.92 v2(207.51,57.92) ; CD110.1 199.19,70.82 v2(199.88,71.52) 199.27,72.12 CD73.1 ; v2(170.77,20.22) 170.6,20.04 CD46.1 171.23,19.37 v2(171.44,19.17) ; CD11.1 v2(170.32,68.21) ; CD44.1 170.39,72.38 v2(171.2,73.19) ; CD108.1 198.89,34.85 v2(198.9,34.86) ; CD40.1 170.36,28.87 v2(170.74,29.25) ; CD107.1 198.57,74.82 198.11,75.28 v2(198.11,75.33) ; v2(171.75,74.67) 171.32,75.1 170.91,75.1 170.57,75.44 CD13.1 ; CD109.1 198.5,44.35 CD120.1 198.5,46.17 v2(198.58,46.25) 198.42,46.41 CD81.1 ; v2(183.72,66.56) 184.39,67.24 CD75.1 ; CD119.1 CD83.1 ; CD77.1 RD30.1
  BOTTOM w1.016: 165.45,32.25 165.45,26.42
  vias: v2(95.02,56.5) v2(95.44,56.94) v2(107.34,83.63) v2(107.41,82.87) v2(108.75,98.62) v2(109.17,98.08) v2(152.78,13.5) v2(153.43,13.48) v2(153.67,16.47) v2(154.72,15.64) v2(156.25,13.87) v2(159.71,19.06) v2(160.14,19.53) v2(160.4,88.76) v2(160.37,88.15) v2(160.6,19.06) v2(160.6,18.18) v2(161.08,88.76) v2(161.11,88.15) v2(161.49,17.92) v2(161.49,17.03) v2(161.69,88.76) v2(161.69,88.15) v2(162.25,17.29) v2(162.25,16.4) v2(163.4,20.72) v2(163.4,19.83) v2(163.4,18.94) v2(163.42,21.71) v2(164.16,21.73) v2(164.16,20.72) v2(164.16,19.83) v2(164.16,18.94) v2(164.44,98.92) v2(164.92,21.73) v2(164.92,20.72) v2(164.92,19.83) v2(164.92,18.94) v2(165.1,98.92) v2(165.41,80.71) v2(165.44,80.07) v2(165.99,80.47) v2(165.97,79.79) v2(166.19,43.96) v2(167.97,44.85) v2(168.73,46.24) v2(170.13,45.61) v2(171.02,45.61) v2(171.27,54.37) v2(171.27,52.97) v2(171.27,51.96) v2(183.96,45.78) v2(225.67,58.73) v4(220.91,60.72)
+1.2V_MEN_P: length 62.8
  TOP w0.203: PC211.2 110.88,16.14 PR206.2 111,16.06 111.76,16.06 111.88,16.18 PC212.1 112.15,15.62 111.99,15.46 v2(111.99,15.43) 112.37,15.04 PU200.5
  IN2 w1.016: 117.3,13.62 120.03,10.9 123.58,10.9 125.63,12.95 127.02,12.95 128.6,14.53 131.41,14.53 134.76,11.18 138.21,11.18
  IN4 w0.254: v2(111.99,15.43) 111.99,15.42 112.79,14.62 116.66,14.62 119.27,12.02 119.56,12.02 120.27,11.31 123.73,11.31 124.79,12.36 127.85,12.36 128.55,11.66 132.67,11.66 133.47,12.46 136.91,12.46 138,13.55 139.06,13.55 139.39,13.22 139.39,10.85 v2(139.24,10.7)
  BOTTOM w0.127: v2(111.99,15.43) v1(111.35,15.43)
  vias: v2(115.53,13.79) v2(116.16,13.79) v2(139.88,10.7)
+1.2V_RUN: length 25.7
  TOP w0.508: LV8.2 54.19,41.58 53.54,40.93 53.54,40.3 v2(53.67,40.17) ; v2(67.74,57.05) 67.74,57.37 68.16,57.79 LV12.2 ; v2(58.6,58.41) 58.6,58.43 58.39,58.64 57.73,58.64 57.4,58.31 57.4,57.67 56.42,56.7 LV7.2
  IN2 w0.508: v2(60.78,40.53) 60.78,40.68 60.04,41.42 59.23,41.42 58.09,40.27 53.83,40.27 53.73,40.17 v2(53.67,40.17)
  BOTTOM w0.127: v4(60.78,39.85) v2(60.78,40.53)
  BOTTOM w0.508: v2(67.74,57.05) 67.74,55.74 LV13.2 ; v2(48.69,56.96) 48.74,56.91 48.74,56.47 49.25,55.96 LV5.2 ; LV11.2 67.07,45.21 66.27,46.01 v2(66.27,46.4) ; LV6.2 v2(60.78,40.53)
  vias: v2(87.37,59.87) v2(87.97,59.56) v2(88.68,59.56)
+1.2V_RUN_PWR: length 2.1
  TOP w0.127: 90.51,58.17 90.51,60.05 v1(90.33,60.23)
+1.05V_PRIM: length 215.7
  TOP w0.203: v2(135.37,37.89) UH1.AA23 v2(135.37,37.12) UH1.AB23 ; v2(135.37,37.89) UH1.AB22 v2(134.6,37.89) ; v2(135.37,37.89) UH1.AB23 ; UH1.AD30 v2(134.58,34.78) 134.8,34.55 134.95,34.41 UH1.AB30 ; UH1.AB23 v2(134.6,37.89) ; v2(133.02,34.81) 133.42,34.41 UH1.AF30 ; v2(134.6,37.89) UH1.AD23
  TOP w0.254: UH1.AD28 134.22,35.18 134.62,35.57 ; UH1.AD28 134.21,35.14 v2(134.58,34.78) UH1.AB28 ; UH1.AD28 133.84,34.81 133.8,34.81 ; UH1.AD30 133.8,34.81 ; 133.8,34.81 133.44,34.44 UH1.AF30 ; UH1.AB30 135.01,34.41 135.35,34.75 135.35,34.81 135.21,34.96 UH1.AB28 ; UH1.AB28 134.98,35.21 134.62,35.57 ; UH1.AB28 135.36,35.56 v2(135.36,35.58) UH1.AB27 ; 134.62,35.57 134.24,35.96 UH1.AD27 ; 134.62,35.57 134.98,35.94 UH1.AB27 ; UH1.AD27 134.19,35.96 v2(133.83,36.31) 133.8,36.28 133.8,36.27 133.49,35.96 UH1.AF27 v2(133.07,36.32) ; UH1.AD27 134.57,36.32 v2(134.62,36.32) UH1.AB27 ; UH1.AD23 134.18,37.51 v2(133.8,37.89) 133.44,37.53 UH1.AF23 v2(133.05,37.89) ; v2(134.6,38.67) UH1.AD20 ; UH1.AA22 v2(135.37,37.89)
  TOP w0.305: UH1.AB20 v2(134.65,39.39)
  IN1 w0.762: 220.16,10.06 221.74,10.06 222.08,9.72 236.4,9.72 236.83,10.14 236.83,11.42 237.55,12.14 237.55,13.62 237.27,13.9 237.27,14.61 238.14,15.48 238.14,21.24 238.14,21.24 238.14,24.35 240.55,26.75 241.52,26.75 242.48,27.72 244.15,27.72 244.94,26.93 244.94,26.3 246.39,24.84 246.39,24.46
  IN4 w0.762: v2(155.5,29.01) 155.5,30.53 156.93,31.97 161.08,31.97 162.13,30.93 164.5,30.93 169.53,25.9 169.53,23.93 169.95,23.51 169.95,15.48 172.95,12.49 174.24,12.49 175.71,11.01 217.37,11.01 ; 275.86,74.18 275.86,73.51 274.97,72.63 274.97,71 274.5,70.52 272.96,70.52 265.41,62.98 265.41,61.59 264.79,60.97 264.79,51.5 264.06,50.76 264.06,28.26 263.07,27.27 263.07,26 261.09,24.03 261.09,23.33 259.31,21.55 256.09,21.55 255.35,20.81 253.45,20.81 252.9,21.37 248.15,21.37 247.03,22.49
  BOTTOM w0.254: v2(135.37,37.12) 135.35,37.1 CH36.1
  vias: v2(27.78,18.19) v2(28.29,18.83) v2(28.49,18.26) v2(115.57,53.7) v2(115.76,53.14) v2(115.77,52.55) v2(115.72,51.97) v2(116.16,50.68) v2(116.28,53.71) v2(116.36,53.09) v2(116.36,52.48) v2(116.33,51.88) v2(116.3,51.27) v2(116.89,51.3) v2(116.94,53.1) v2(116.94,52.52) v2(116.93,51.91) v2(146.98,31.87) v2(147.21,32.44) v2(147.53,31.87) v2(147.76,32.49) v2(148.08,31.86) v2(148.3,32.68) v2(148.64,31.87) v2(148.78,32.41) v2(155.5,28.11) v2(218.75,10.94) v2(219.36,10.96) v2(246.33,23.7) v2(246.33,23.1) v2(268.56,78.21) v2(268.59,77.61) v2(275.28,74.96) v2(275.92,75.01) v4(275.49,75.67)
+1.05V_PRIMP: length 19.1
  TOP w0.254: PR809.1 110.46,27.19 110.46,29.08 110.25,29.29 110.25,29.95 v2(110.39,30.09)
  IN1 w0.254: v2(110.49,45.58) 110.49,44.8 110.41,44.72 110.41,38.52 110.77,38.16 110.77,31.71 110.59,31.53 110.59,30.29 v2(110.39,30.09)
  vias: v1(111.75,53.89)
+1.05V_VDD: length 4.5
  BOTTOM w0.254: UR1.9 21.51,15.03 21.54,15
  BOTTOM w0.508: CR219.2 24.31,15.81 23.5,15 21.54,15
  vias: v2(10.18,23.69) v2(10.16,22.95) v2(10.2,22.35) v2(10.79,22.34) v2(12.12,16.15) v2(12.22,14.09) v2(19.47,10.12) v2(19.48,9.53) v2(24.99,16.44) v2(25.06,21.84) v2(25.89,16.47) v4(10.34,21.76)
+1.8V_ALW_PCHRES: length 10
  IN2 w0.508: v2(130.4,32.93) 130.4,33.26 128.84,34.83 127.16,34.83 126.16,35.83 124.76,35.83 v2(124.48,35.55)
  BOTTOM w0.254: v2(130.4,32.93) 130.84,33.37 RH294.2
  BOTTOM w0.508: RH250.2 130.38,25.59 130.93,26.15 v2(130.93,26.64)
  vias: v1(123.34,35)
+1.8V_ALW_VTR3: length 37.2
  TOP w0.254: v2(135.52,68.77) 136.04,69.3 UE1.N5
  TOP w0.381: v2(111.9,65.51) 111.89,65.51 111.41,65.51 110.97,65.06 110.97,64.58 110.69,64.3 UE11.5 ; v1(114.16,69.18) v2(115.02,69.18)
  TOP w0.508: RE549.1 129.77,69.63 130.2,69.2 131.29,69.2 v2(131.8,68.7)
  IN4 w0.508: v2(111.9,65.51) 111.95,65.46 113.67,65.46 114.25,66.03 114.25,68.4 v2(115.02,69.18) 116.39,70.55 120.52,70.55 121.44,69.64 122.5,69.64 124.05,68.09 125.6,68.09 v2(127.38,69.86) 127.58,69.66 130.83,69.66 v2(131.8,68.7) 132.07,68.43 132.83,68.43 133.79,69.39 134.94,69.39 135.52,68.81 v2(135.52,68.77)
+1.8V_PHVLDO: length 39.4
  TOP w0.254: UH1.AF19 133.44,39.81 v2(133.78,39.46) 133.78,39.4 UH1.AF20
  TOP w0.508: v2(128.43,64.6) 127.46,64.6 126.31,65.76 126.09,65.76 125.32,66.52 v1(124.11,66.52) RH239.1
  IN1 w0.508: v2(128.43,64.6) 128.85,64.6 129.24,64.22 130.11,64.22 131.03,63.3 131.77,63.3 133.43,61.64 133.72,61.64 133.73,61.64 134.47,61.64 134.87,61.24 134.87,58.77 135.66,57.98 135.66,52.54 134.52,51.4 134.52,50.15 132.99,48.63 132.99,46.27 132.31,45.58 132.31,41.21 133.78,39.74 v2(133.78,39.46)
+1.8V_PRIM: length 376.9
  TOP w0.33: v2(122.65,53.35) 122.18,52.88 RH605.2
  TOP w0.381: RZ543.2 279.5,72.6 v2(279.37,72.47) 279.27,72.37 276.24,72.37 275.86,72.75 UZ61.5 275.38,73.11 275.02,73.47 274.93,73.47 274.91,73.48 CZ544.1 ; RH613.1 126.55,52.83 v2(126.55,53.63)
  TOP w0.508: RH614.1 123.52,52.76 123.68,52.93 123.68,53.04 123.72,53.08 v2(123.72,53.42) ; v2(325.37,31.04) 325.37,30.46 324.7,29.78 324.7,18.77 323.97,18.05 323.97,15.99 326.93,13.03 331.47,13.03 332.36,13.92
  IN1 w0.508: v2(109.89,19) 110.18,18.71 110.18,18.18 110.73,17.63 v2(110.73,15.18) ; v2(325.37,31.04) 325.37,31.27 324.9,31.74 324.23,31.74 323.63,32.34 320.73,32.34 319.19,33.89 314.92,33.89 309.76,28.73 306.75,28.73 300.12,22.1 v2(300.12,16.78)
  IN2 w0.508: v2(279.37,72.47) 279.37,72.39 280.1,71.67 284.95,71.67 285.71,70.91 290.89,70.91 292.22,69.57 295.51,69.57 297.09,71.15 300.99,71.15 302.25,69.89 306.01,69.89 310.26,65.64 310.26,63.35 310.32,63.29 310.32,61.61 308.18,59.46 308.18,55.02 300.72,47.57 300.72,45.93 299.97,45.18 299.97,37.4 300.29,37.08 300.29,35.5 299.79,35 299.79,31.94 302.39,29.34 302.39,28.21 302.96,27.64 302.96,22.66 300.12,19.83 v2(300.12,16.78)
  BOTTOM w0.33: RH607.1 127.89,44.68 127.22,45.35 v2(126.94,45.35) ; v2(123.72,53.42) 124.63,52.51 124.9,52.51 RH604.1
  BOTTOM w0.508: v2(300.12,16.78) 300.07,16.73 300.07,15.5 294.52,9.95 280.04,9.95 279.94,10.05 258.28,10.05 255.76,12.56 244.73,12.56 242.24,10.07 239.64,10.07 238.58,9.02 234.86,9.02 233.25,10.63 230.41,10.63 229.47,11.57 215.99,11.57 213.67,9.25 162.86,9.25 161.97,10.14 143.04,10.14 141.75,8.84 134.72,8.84 132.73,6.85 124.43,6.85 122.83,8.45 117.52,8.45 116.17,9.79 113.74,9.79 112.38,11.15 v4(112.38,11.84) 111.45,12.77 111.45,14.45 v2(110.73,15.18) ; RH247.1 123.26,37.95 124.09,38.78 124.53,38.78 124.58,38.83 v2(125.11,38.83)
  vias: v2(109.27,18.98) v2(109.54,19.51) v2(119.66,28.76) v2(120.23,28.76) v2(125.13,69.31) v2(125.14,68.7) v2(125.8,38.72) v2(126.62,45.8) v2(127.18,53.65)
