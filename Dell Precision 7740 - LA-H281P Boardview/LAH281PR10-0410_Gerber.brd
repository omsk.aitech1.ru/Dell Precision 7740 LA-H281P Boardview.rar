# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SW4_DP2_N2_C: length 2.5
  BOTTOM w0.076: 33.27,53.42 33.27,53.4 33.11,53.24 33.11,53.04 33.17,52.98 33.42,52.98 33.5,52.9 33.5,52.53 33.45,52.48 33.36,52.48 UT1.C1
  BOTTOM w0.109: 33.27,53.42 33.27,54.27 CT179.1
SW4_DP2_N3: length 65.9
  TOP w0.076: UV67.44 76.67,54.97 76.83,55.13 76.83,55.15
  TOP w0.109: v2(77.54,58.84) 77.32,58.62 77.32,56.97 76.83,56.49 76.83,55.15
  IN1 w0.102: v2(33.88,55.52) 33.88,54.35 34.79,53.44 36.14,53.44 37.35,52.23 41.9,52.23 42.56,51.58 43.23,51.58 43.89,50.92 47.14,50.92 53.59,44.46 57.63,44.46 58.65,45.48 58.65,48.78 59.28,49.42 63.7,49.42 64.14,49.85 67.39,49.85 70.27,52.73 75.64,52.73 76.94,54.04 76.94,55.92 77.54,56.52 v2(77.54,58.84)
  BOTTOM w0.109: v2(33.88,55.52) 33.96,55.44 33.96,54.93 CT181.2
SW4_DP2_N3_C: length 2.4
  BOTTOM w0.076: 33.99,53.56 34.17,53.38 34.17,53.03 33.97,52.82 33.97,52.45 34.02,52.39 34.13,52.39 34.19,52.46 UT1.E1
  BOTTOM w0.109: CT181.1 33.99,54.23 33.99,53.56
SW4_DP2_P0: length 60.5
  TOP w0.076: UV67.54 72.67,55.24 72.4,55.51
  TOP w0.109: v2(72.3,58.12) 72.4,58.02 72.4,55.51
  IN1 w0.102: v2(72.3,58.12) 71.93,57.76 70.89,57.76 70.52,58.12 67.61,58.12 67.41,58.33 65.06,58.33 64.61,57.88 59.89,57.88 59.3,57.29 52.88,57.29 52.22,57.95 50.29,57.95 49.79,58.45 45.69,58.45 45.31,58.07 44.79,58.07 44.6,58.26 42.95,58.26 42.14,59.07 40.76,59.07 40.5,59.32 37.69,59.32 36.87,60.15 30.3,60.15 26.53,56.38 26.53,54.04 27.52,53.06 28.16,53.06 28.37,53.26 v2(28.51,53.26)
  BOTTOM w0.109: CT186.2 29.47,53.3 28.54,53.3 v2(28.51,53.26)
SW4_DP2_P0_C: length 5
  BOTTOM w0.076: 30.57,52.9 30.76,52.7 v3(30.76,52.44) 30.76,52.18 32.01,50.93 32.01,50.82 31.95,50.76 31.95,50.66 32.11,50.49 32.5,50.49 32.57,50.56 32.57,50.67 32.5,50.73 UT1.A5
  BOTTOM w0.109: 30.57,52.9 30.57,53.33 30.42,53.48 30.25,53.48 CT186.1
SW4_DP2_P1: length 60
  TOP w0.076: UV67.51 73.87,54.82 73.78,54.91 73.78,55.13 73.54,55.37 73.54,55.39
  TOP w0.109: 73.54,55.39 73.54,58.51 v2(73.3,58.74)
  IN1 w0.102: v2(73.3,58.74) 73.36,58.74 73.63,58.47 73.63,57.64 72.59,56.59 69.35,56.59 69.18,56.43 66.57,56.43 66.35,56.66 60.37,56.66 59.84,56.12 52.47,56.12 52.04,55.69 51.45,55.69 50.74,56.4 48.04,56.4 47.69,56.75 42.8,56.75 42.07,57.48 40.08,57.48 39.62,57.94 37.08,57.94 36.6,57.46 36.28,57.46 35.15,58.59 30.95,58.59 30.09,57.73 30.09,56.06 29.49,55.45 28.91,55.45 28.74,55.62 28.74,55.99 28.62,56.11 28.43,56.11 28.3,55.97 v2(28.3,55.53)
  BOTTOM w0.109: v2(28.3,55.53) 28.4,55.43 29.93,55.43 CT183.2
SW4_DP2_P1_C: length 5.4
  BOTTOM w0.076: 31.75,54.28 31.75,54.26 31.57,54.08 31.57,53.92 31.85,53.64 31.85,52.23 32.2,51.88 32.37,51.88 arc(32.57,51.84) 32.73,51.73 UT1.B3
  BOTTOM w0.109: 31.75,54.28 31.75,54.74 v3(31.43,55.06) 31.07,55.42 30.69,55.42 CT183.1
SW4_DP2_P2: length 55.1
  TOP w0.076: UV67.48 75.07,53.79 75.16,53.88 75.25,53.88 75.32,53.95 75.32,55.07 75.18,55.21 75.18,55.23
  TOP w0.109: v2(74.98,58.12) 75.18,57.92 v3(75.18,56.71) 75.18,55.23
  IN1 w0.102: v2(74.98,58.12) 75.13,57.97 75.13,56.97 73.6,55.44 72.95,55.44 72.27,54.75 66.97,54.75 66.57,54.35 58.29,54.35 57.84,54.8 53.72,54.8 52.42,53.51 51.59,53.51 50.25,54.85 48.18,54.85 47.73,54.41 45.04,54.41 44.09,55.36 42.66,55.36 41.72,54.42 39.55,54.42 38.45,55.52 36.57,55.52 35.08,57.01 33.31,57.01 32.53,56.23 v2(32.53,55.58)
  BOTTOM w0.109: v2(32.53,55.58) 32.69,55.42 CT185.2
SW4_DP2_P2_C: length 2.5
  BOTTOM w0.076: UT1.C2 33.06,52.33 33.06,52.87 32.96,52.98 32.96,53.21 32.76,53.41
  BOTTOM w0.109: 32.76,53.41 32.76,54.26 CT185.1
SW4_DP2_P3: length 66
  TOP w0.076: UV67.45 76.27,53.81 76.35,53.89 76.44,53.89 76.52,53.97 76.52,54.92 76.32,55.13 76.32,55.15
  TOP w0.109: v2(76.61,58.85) 76.8,58.67 76.8,57.19 76.32,56.7 76.32,55.15
  IN1 w0.102: v2(76.61,58.85) 76.38,58.85 76.27,58.75 76.27,58.56 76.39,58.45 76.88,58.45 76.98,58.34 76.98,56.75 76.38,56.15 76.38,54.27 75.4,53.29 70.04,53.29 67.16,50.41 63.9,50.41 63.47,49.98 59.05,49.98 58.09,49.01 58.09,45.71 57.4,45.02 53.82,45.02 47.37,51.48 44.12,51.48 43.46,52.14 42.79,52.14 42.13,52.79 37.58,52.79 36.37,54 35.02,54 34.44,54.58 34.44,54.96 34.53,55.05 34.9,55.05 35.01,55.16 35.01,55.43 34.91,55.52 v2(34.59,55.52)
  BOTTOM w0.109: CT182.2 34.48,54.96 34.48,55.41 v2(34.59,55.52)
SW4_DP2_P3_C: length 2.4
  BOTTOM w0.076: 34.51,53.57 34.32,53.39 34.32,53.02 34.41,52.93 34.41,52.33 UT1.E2
  BOTTOM w0.109: CT182.1 34.51,54.26 34.51,53.57
SW_1PH: length 2.8
  TOP w0.152: v2(279.27,66.89) 279.54,66.63 PL1800.2
  BOTTOM w0.109: v2(279.27,66.89) v1(278.62,66.89)
  BOTTOM w0.152: v2(279.27,66.89) 279.27,65.92 PR1102.2
SW_TBT_A_USB20_N1: length 41.3
  IN2 w0.094: v2(14.95,28.37) 15.19,28.37 15.36,28.2 15.36,27.96 15.74,27.58 16.27,27.58 16.56,27.29 17.21,27.29 17.72,27.8 17.72,30.01 17.4,30.32 17.4,34.19 17.45,34.24 17.45,35.19 19.36,37.1 19.36,38.68 19.82,39.13 19.82,43.06 20.68,43.92 20.68,51.53 19.45,52.75 18.89,52.75 v2(18.8,52.84)
  BOTTOM w0.102: DT1.3 19.68,52.64 19.63,52.59 19.05,52.59 v2(18.8,52.84) 18.55,52.59 18.22,52.59 v3(16.7,54.11) 16.54,54.28 15.87,54.28 RT121.1 ; UT5.A2 17.96,30.6 17.96,30.27 17.48,29.8 16.47,29.8 15.82,29.14 15.82,28.74 15.62,28.54 15.12,28.54 v2(14.95,28.37)
SW_TBT_A_USB20_N1_R: length 9.2
  TOP w0.102: JUSBC1.B7 6.68,55.23 v2(6.73,55.28)
  BOTTOM w0.102: v2(6.73,55.28) 6.94,55.07 9.76,55.07 10.55,54.28 v3(10.84,54.28) 11.67,54.28 12.07,54.69 DT7.4 DT7.7 13.6,54.69 13.66,54.75 RT121.2
SW_TBT_A_USB20_N2: length 31.7
  TOP w0.102: DT2.3 18.49,53.72 v2(17.99,53.72) 17.99,53.77 17.77,53.98 v3(17.35,53.98) 17.01,53.98 16.75,54.24 16.5,54.24 16.33,54.42 16.08,54.42 RT122.2
  IN2 w0.094: v2(16.58,31.49) 16.36,31.49 16.28,31.4 16.28,31.16 16.2,31.08 16.08,31.08 16,31.16 16,32.94 16.27,33.21 16.27,34.88 16.63,35.24 16.63,37.45 18.52,39.34 18.52,41.62 18.81,41.9 18.81,45.95 19.67,46.82 19.67,50.12 18.21,51.58 18.21,52.45 17.56,53.1 17.56,53.96 17.75,54.14 17.83,54.14 17.83,54.14 18.02,54.14 18.11,54.05 18.11,53.84 v2(17.99,53.72)
  BOTTOM w0.102: v2(16.58,31.49) 16.84,31.23 16.92,31.23 17.22,31.52 17.39,31.52 UT5.C1
SW_TBT_A_USB20_N2_R: length 8
  TOP w0.102: RT122.1 14.43,53.69 DT8.2 DT8.8 11.95,53.69 11.59,54.05 11.42,54.05 11.33,54.14 11.28,54.14 10.82,54.6 v3(9.93,54.6) 8.11,54.6 7.99,54.48 JUSBC1.A7
SW_TBT_A_USB20_P1: length 41.4
  IN2 w0.094: v2(18.8,52.13) 19.1,52.13 19.19,52.22 19.19,52.47 19.28,52.56 19.37,52.56 20.48,51.45 20.48,44 19.62,43.14 19.62,39.21 19.17,38.76 19.17,37.18 17.26,35.27 17.26,34.32 17.2,34.27 17.2,30.24 17.52,29.92 17.52,27.88 17.13,27.49 16.64,27.49 16.35,27.78 15.82,27.78 15.56,28.04 15.56,28.28 15.43,28.4 15.43,28.6 v2(14.95,29.09)
  BOTTOM w0.102: UT5.A1 17.69,30.67 17.77,30.6 17.77,30.35 17.4,29.99 16.39,29.99 15.63,29.22 15.63,28.82 15.54,28.73 15.41,28.73 15.29,28.86 15.29,29 15.2,29.09 v2(14.95,29.09) ; DT1.2 19.68,52.23 19.5,52.4 19.07,52.4 v2(18.8,52.13) 18.53,52.4 18.14,52.4 16.8,53.74 16.75,53.74 16.41,54.09 15.87,54.09 RT120.1
SW_TBT_A_USB20_P1_R: length 9.2
  TOP w0.102: JUSBC1.B6 6.7,54.73 v2(6.73,54.7)
  BOTTOM w0.102: RT120.2 13.54,53.61 13.46,53.69 DT7.8 DT7.2 12.06,53.69 11.66,54.09 11.21,54.09 11.17,54.05 10.51,54.05 9.68,54.88 6.92,54.88 v2(6.73,54.7)
SW_TBT_A_USB20_P2: length 31.6
  TOP w0.102: DT2.2 18.53,54.54 v2(17.99,54.54) 17.67,54.21 17.05,54.21 16.83,54.43 16.58,54.43 16.4,54.61 16.04,54.61 RT123.2
  IN2 w0.094: v2(17.99,54.54) 17.79,54.34 17.67,54.34 17.37,54.04 17.37,53.02 18.02,52.37 18.02,51.5 19.48,50.04 19.48,46.9 18.61,46.03 18.61,41.99 18.32,41.7 18.32,39.42 16.44,37.53 16.44,35.32 16.08,34.96 16.08,33.29 15.8,33.02 15.8,31.07 15.99,30.88 16.47,30.88 v2(16.58,30.77)
  BOTTOM w0.102: v2(16.58,30.77) 16.85,31.04 17,31.04 17.3,31.33 17.38,31.33 UT5.B1
SW_TBT_A_USB20_P2_R: length 8
  TOP w0.102: JUSBC1.A6 7.55,54.98 7.86,54.98 8.05,54.79 10.9,54.79 11,54.69 11.05,54.69 v3(11.23,54.51) 11.5,54.24 11.63,54.24 12.07,54.69 DT8.7 DT8.4 14.66,54.69 RT123.1
SW_TBT_B_USB20_N1: length 35.5
  IN2 w0.094: v2(15.46,62.08) 15.25,61.87 15.25,61.48 15,61.23 15,59.28 15.78,58.5 15.78,50.9 15.37,50.49 15.37,48.79 16.41,47.75 16.41,42.94 16.74,42.61 16.74,41.44 14.72,39.42 14.72,39.02 14.3,38.6 14.3,36.58 15.1,35.78 15.1,34.28 15.16,34.21 15.29,34.21 15.39,34.32 15.39,34.51 15.48,34.6 v2(15.63,34.6)
  BOTTOM w0.102: v2(15.63,34.6) 15.85,34.38 16.19,34.38 16.42,34.16 17.05,34.16 17.2,34.01 17.37,34.01 UT5.H1 ; DT3.3 15.69,61.85 v2(15.46,62.08) 15.19,62.35 15.19,62.7 RT540.1
SW_TBT_B_USB20_N1_R: length 14.6
  TOP w0.102: v2(6.71,71.47) 6.67,71.43 JUSBC1.1B7
  BOTTOM w0.102: v2(6.71,71.47) 6.9,71.27 7.22,71.27 7.44,71.05 10.15,71.05 12.84,68.36 v3(13.68,68.36) 14.41,68.36 15.34,67.43 15.34,66.64 15.59,66.38 DT11.4 DT11.7 15.59,64.02 RT540.2
SW_TBT_B_USB20_N2: length 36.4
  TOP w0.102: RT539.2 14.94,62.76 14.94,62.69 15.14,62.48 15.82,62.48 16.01,62.29 v3(16.01,61.17) 16.01,60.91 16.25,60.67 16.29,60.67 v2(16.69,60.28) 16.89,60.47 DT16.3
  IN2 w0.094: v2(15.82,37.06) 15.82,36.68 15.75,36.61 15.43,36.61 15.15,36.89 15.15,38.09 17.62,40.55 17.62,42.91 17.2,43.32 17.2,45.85 18.87,47.52 18.87,49.79 17.41,51.25 17.41,52.08 16.59,52.91 16.59,59.34 16.15,59.78 16.15,60.54 16.31,60.7 16.68,60.7 16.79,60.6 16.79,60.46 v2(16.69,60.28)
  BOTTOM w0.102: UT5.L1 17.37,35.51 17.19,35.51 16.76,35.94 16.76,36.34 16.4,36.7 16.17,36.7 v2(15.82,37.06)
SW_TBT_B_USB20_N2_R: length 12.8
  TOP w0.102: RT539.1 DT12.2 DT12.8 14.59,66.43 14.8,66.63 15.11,66.63 15.19,66.72 15.19,67.04 14.06,68.17 13.63,68.17 13.59,68.13 12.97,68.13 12.93,68.17 12.32,68.17 v3(11.14,69.35) 9.93,70.56 8.38,70.56 8.14,70.8 7.98,70.8 7.87,70.68 JUSBC1.1A7
SW_TBT_B_USB20_P1: length 35.5
  IN2 w0.094: v2(14.74,62.08) 15.05,61.76 15.05,61.56 14.8,61.31 14.8,59.2 15.58,58.42 15.58,50.98 15.17,50.57 15.17,48.71 16.21,47.67 16.21,42.86 16.54,42.53 16.54,41.52 14.52,39.5 14.52,39.1 14.1,38.68 14.1,36.5 14.9,35.7 14.9,34.19 15.08,34.02 15.42,34.02 v2(15.63,33.97)
  BOTTOM w0.102: DT3.2 14.69,62.02 v2(14.74,62.08) 15,62.33 15,62.7 RT538.1 ; v2(15.63,33.97) 15.84,34.19 16.12,34.19 16.34,33.97 16.97,33.97 17.12,33.82 17.39,33.82 UT5.G1
SW_TBT_B_USB20_P1_R: length 14.6
  TOP w0.102: JUSBC1.1B6 6.66,70.93 v2(6.71,70.88)
  BOTTOM w0.102: RT538.2 DT11.8 DT11.2 14.59,66.5 14.73,66.63 15.06,66.63 15.15,66.72 15.15,67.36 14.33,68.17 14.02,68.17 13.98,68.13 13.35,68.13 13.31,68.17 12.76,68.17 10.07,70.86 7.36,70.86 7.14,71.08 6.9,71.08 v2(6.71,70.88)
SW_TBT_B_USB20_P2: length 36.4
  TOP w0.102: RT541.2 15.33,63.1 15.13,62.9 15.13,62.76 15.22,62.67 15.9,62.67 16.2,62.37 16.2,61.5 16.24,61.46 16.24,60.95 16.33,60.86 16.54,60.86 16.75,61.08 v2(16.75,61.17) 17.06,61.48 DT16.2
  IN2 w0.094: v2(16.75,61.17) 16.48,60.9 16.23,60.9 15.96,60.62 15.96,59.7 16.39,59.26 16.39,52.82 17.22,52 17.22,51.17 18.68,49.71 18.68,47.6 17.01,45.93 17.01,43.24 17.42,42.83 17.42,40.63 14.96,38.17 14.96,36.81 15.35,36.41 15.52,36.41 v2(15.81,36.12)
  BOTTOM w0.102: UT5.K1 17.39,35.32 17.11,35.32 16.57,35.87 16.57,36.26 16.32,36.51 16.19,36.51 v2(15.81,36.12)
SW_TBT_B_USB20_P2_R: length 12.8
  TOP w0.102: RT541.1 15.59,65.28 DT12.4 DT12.7 15.59,66.34 15.38,66.56 15.38,67.12 14.14,68.36 v3(13.28,68.36) 12.4,68.36 11.58,69.17 11.58,69.23 11.03,69.78 10.98,69.78 10.01,70.75 8.46,70.75 8.22,70.99 8.02,70.99 7.83,71.18 JUSBC1.1A6
SYS_PWROK: length 270.2
  TOP w0.109: v2(233.56,13.95) 236.23,11.29 238.23,11.29 238.45,11.51 239.29,11.51 241.1,9.69 241.83,9.69 244.46,12.32 255.94,12.32 259.18,9.08 259.18,6.15 259.93,5.4 262.3,5.4 262.87,4.83 263.87,4.83 264.49,5.45 v2(264.49,5.48) ; RE56.1 134.15,66.92 134.15,66.75 133.86,66.47 RE548.1 133.76,65.27 133.37,64.87 131.83,64.87 130.33,63.37 130.33,61.94 128.94,60.55 127.72,60.55 125.09,57.92 125.09,56.16 124.44,55.5 RH199.1 124.4,55.22 125.31,55.22 v2(125.73,54.8) ; v2(126.96,50.68) 126.96,50.37 127.66,49.68 127.66,49.66 127.67,49.65 127.67,48.34 127.72,48.28 127.72,47.73 UH1.AU3
  IN3 w0.081: v2(264.49,5.48) 264.01,5.96 264.01,6.81 263.83,6.99 262.02,6.99 260.79,5.76 256.72,5.76 254.2,8.28 246.97,8.28 242.3,3.61 167.78,3.61 166.75,4.65 158.04,4.65 154.3,8.38 149.21,8.38 147.71,9.89 138.74,9.89 137.88,10.75 133.49,10.75 132.89,11.34 130.44,11.34 129.46,12.32 128.72,12.32 128.21,12.83 123.76,12.83 122.58,14.02 120.08,14.02 119.63,14.47 119.63,16.94 118.56,18.01 118.56,20.28 117.2,21.64 117.2,23.28 118.39,24.47 118.39,26.42 117.9,26.91 117.9,29.37 118.26,29.73 118.56,29.73 118.95,30.11 118.95,30.83 119.11,30.99 119.11,35.16 119.37,35.41 119.37,37.04 119.69,37.37 119.69,44.6 120.26,45.17 120.26,46.79 121.18,47.7 122.37,47.7 123.5,48.83 125.56,48.83 126.96,50.24 v2(126.96,50.68)
  IN4 w0.102: v2(126.96,50.68) 126.96,50.8 125.33,52.44 125.33,54.4 v2(125.73,54.8)
  BOTTOM w0.109: v4(233.37,12.61) 233.64,12.88 233.64,13.88 v2(233.56,13.95) 233.57,13.95 233.64,14.01 235.41,14.01 235.91,14.52 RC129.1
SYS_PWROK_R: length 17.8
  TOP w0.109: RC133.2 CC33.1 232.17,14.53 v2(233.19,13.51)
  BOTTOM w0.109: v2(233.19,13.51) 233.08,13.61 233.08,14.28 v1(233.31,14.51) 233.74,14.51 233.99,14.25 235.31,14.25 235.53,14.47 235.53,14.87 235.15,15.25 RC128.2 235.15,15.7 235.73,16.29 RC129.2 236.03,16.29 236.72,15.6 236.72,14.81 237.87,13.65 241.12,13.65 242.48,15.02 JXDP1.47
SYS_RESET#: length 48.8
  TOP w0.109: v2(119.77,56.78) CC302.1 120.24,56.55 120.63,56.55 120.81,56.37 UC3.4 ; v1(127.57,51.59) 127.82,51.34 v2(127.82,51.07) 127.45,50.71 127.45,50.16 127.87,49.75 127.87,48.42 127.94,48.34 UH1.AU2 ; v2(126.3,59.86) 126.3,59.93 125.98,60.25 125.48,60.25 RH66.1
  IN3 w0.081: v2(126.3,59.86) 125.82,59.37 122.59,59.37 120,56.78 v2(119.77,56.78)
  IN4 w0.102: v2(126.3,59.86) 126.3,59.44 125.94,59.07 125.94,58.48 127.1,57.32 127.1,54.75 127.66,54.19 127.66,51.22 v2(127.82,51.07)
  BOTTOM w0.109: v2(119.77,56.78) 120.1,56.78 121.45,58.13 121.45,59.69 120.65,60.49 120.65,63.56 120.5,63.71 120.5,65.15 119.13,66.53 117.87,66.53 116.88,65.54 113.23,65.54 112.79,65.1 111.58,65.1 111.49,65.02 JAPS1.13
SYSTEM_ID: length 17.2
  TOP w0.109: UE1.J10 v2(140.41,72.48) ; v2(138.91,65.85) 138.35,65.29 v1(138.35,64.68) 138.35,62.1 137.88,61.63 CE47.1 134.22,62.33 RE300.2
  IN3 w0.081: v2(138.91,65.85) 139.22,66.16 139.22,66.69 140.08,67.55 140.08,68.34 140.31,68.57 140.31,69.26 140.03,69.53 140.03,71.87 140.41,72.26 v2(140.41,72.48)
TACH_FAN1: length 22.6
  TOP w0.109: JFAN1.3 117.06,76.42 118,76.42 118.43,76.85 v4(118.58,76.85) 119.15,76.85 119.63,76.37 RZ508.2 119.4,76.01 v2(118.74,76.01) ; UE1.E3 v2(134.07,76.42)
  IN4 w0.102: v2(118.74,76.01) 119.22,76.49 120.48,76.49 120.59,76.6 125.99,76.6 126.44,77.05 128.35,77.05 128.8,76.6 129.49,76.6 130.27,75.82 130.77,75.82 131.01,75.58 132.51,75.58 132.86,75.93 132.86,76.59 133.1,76.83 133.5,76.83 133.9,76.42 v2(134.07,76.42)
TACH_FAN2: length 204.3
  TOP w0.109: JFAN2.3 306.82,70.6 v2(305.57,71.85) ; UE1.D1 v2(132.31,76.85)
  IN2 w0.081: v2(168.89,74.7) 167.55,76.04 162.57,76.04 162.26,76.34 156.35,76.34 156.04,76.02 153,76.02 150.57,78.45 146.78,78.45 144.5,80.73 136.35,80.73 135.48,81.6 133.75,81.6 133.47,81.32 133.47,79.61 132.86,78.99 132.86,77.4 v2(132.31,76.85)
  VCC w0.086: v2(258.21,73.95) 257.43,74.74 256.41,74.74 255.22,73.56 238.17,73.56 238.12,73.6 233.57,73.6 232.2,72.23 222.41,72.23 212.09,82.54 196.33,82.54 194.52,84.36 183.64,84.36 182.97,83.69 180.3,83.69 178.68,85.31 172.04,85.31 168.89,82.15 168.89,78.38 168.68,78.17 168.68,74.91 v2(168.89,74.7)
  IN3 w0.081: v2(305.57,71.85) 294.96,71.85 293.55,73.27 269.88,73.27 266.5,69.89 262.31,69.89 258.25,73.95 v2(258.21,73.95)
  BOTTOM w0.109: v2(132.31,76.85) 131.98,77.18 RZ507.2 ; v2(305.57,71.85) v1(306.33,71.85)
TB_STAT#: length 171.9
  TOP w0.109: v2(76.01,17.51) 75.98,17.53 PQ704.2
  TOP w0.203: PU700.16 69.28,20.76 68.63,20.11 v2(67.74,20.11) 67.74,19.91 PR725.1
  IN1 w0.102: v2(67.74,20.11) 67.74,19.54 68.45,18.83 73.3,18.83 74.62,17.51 v2(76.01,17.51) 76.21,17.51 77.22,18.52 77.22,19.45 82.37,24.6 85.06,24.6 86.85,26.38 87.2,26.38 88.09,27.27 93.96,27.27 95.4,28.71 98.63,28.71 100.41,30.49 102.6,30.49 102.88,30.78 102.88,31.69 103.42,32.23 103.42,33.83 101.9,35.35 99.6,35.35 98.9,36.05 97.84,36.05 96.39,37.51 96.39,45.42 96.26,45.54 94.98,45.54 93.85,46.67 93.85,51.28 100.64,58.08 v2(102.16,58.08)
  IN3 w0.081: v2(155.07,83.21) 153.54,81.68 148.44,81.68 148.02,81.26 142.99,81.26 142.26,80.53 137.69,80.53 137.21,81.02 135.07,81.02 133.65,79.59 132.84,79.59 132.59,79.35 131.44,79.35 131.19,79.59 130.1,79.59 129.14,78.64 128.05,78.64 127.51,79.19 125.19,79.19 122.83,76.82 121.77,76.82 116.34,71.39 114.16,71.39 110.81,68.04 108.28,65.51 108.28,62.66 103.69,58.08 v2(102.16,58.08)
  BOTTOM w0.109: v2(155.07,83.21) 155.29,83.43 158.47,83.43 159.2,82.7 160.33,82.7 165.38,77.65 v1(165.38,76.64) 165.5,76.52 165.5,73.98 165.1,73.57 162.66,73.57 162.55,73.68 UE12.5
TBT_A_SBU1: length 46.3
  IN1 w0.102: v2(26.32,27.48) 26.17,27.64 25.9,27.64 25.66,27.88 25.66,28.35 26.05,28.73 26.05,29.08 25.91,29.22 25.67,29.22 v2(25.47,29.03)
  IN2 w0.094: v2(35.14,51.09) 35.29,51.09 35.45,51.24 35.45,51.44 35.43,51.46 35.43,51.7 35.18,51.95 35.1,51.95 35.01,51.85 35.01,51.54 34.92,51.45 34.73,51.45 34.63,51.54 34.63,51.85 34.54,51.95 33.87,51.95 30.33,48.4 30.33,40.77 29.54,39.98 28.33,39.98 27.26,38.92 25.96,38.92 24.08,37.04 23.1,37.04 21.45,35.39 20.32,35.39 19.85,34.91 19.85,31.44 20.34,30.94 22.38,30.94 24.92,28.4 25.81,28.4 26.23,28.82 26.23,29.17 25.99,29.41 25.84,29.41 25.47,29.04 v2(25.47,29.03)
  BOTTOM w0.102: v2(25.47,29.03) 25.28,29.22 25.13,29.22 RT387.2 ; v2(35.14,51.09) UT1.H4 ; v2(26.32,27.48) 26.19,27.61 25.84,27.61 RT606.2
TBT_A_SBU2: length 46.4
  IN1 w0.102: v2(25.47,29.61) 25.67,29.41 25.98,29.41 26.24,29.16 26.24,28.65 25.85,28.27 25.85,27.96 25.98,27.83 26.08,27.83 v2(26.32,28.07)
  IN2 w0.094: v2(25.47,29.61) 25.48,29.61 26.07,29.61 26.43,29.25 26.43,28.74 25.9,28.21 24.84,28.21 22.3,30.75 20.26,30.75 19.65,31.36 19.65,34.99 20.24,35.58 21.37,35.58 23.02,37.24 24,37.24 25.88,39.11 27.18,39.11 28.25,40.18 29.46,40.18 30.13,40.85 30.13,48.48 33.79,52.14 35.26,52.14 35.62,51.78 35.62,51.78 35.68,51.72 v2(35.79,51.72)
  BOTTOM w0.102: v2(25.47,29.61) 25.28,29.42 25.13,29.42 RT388.2 ; v2(26.32,28.07) 26.07,27.82 25.85,27.82 RT607.2 ; UT1.J4 35.81,51.72 v2(35.79,51.72)
TBT_A_TRX_DTX_N1: length 23.9
  TOP w0.229: JUSBC1.A10 7.69,52.98 arc(7.87,52.96) 8.04,52.89 8.09,52.84 arc(8.15,52.79) 8.21,52.75 arc(8.3,52.72) 8.39,52.71 arc(8.65,52.58) 8.87,52.4 9.77,51.51 arc(10.24,51.19) 10.8,51.08 11.58,51.08 arc(11.82,51.06) 12.05,51.01 12.77,50.82 14.8,50.19 arc(14.86,50.17) 14.93,50.14 15.01,50.1 arc(15.57,49.91) 16.16,49.84 arc(16.48,49.91) DT14.1 arc(16.93,49.97) 17.14,49.93 17.35,49.93 arc(17.51,49.93) 17.66,49.93 17.67,49.93 arc(17.67,49.93) 17.67,49.93 arc(17.92,49.91) 18.16,49.89 arc(18.28,49.88) 18.4,49.86 arc(18.41,49.86) 18.41,49.86 arc(18.77,49.81) 19.13,49.73 arc(19.18,49.72) 19.24,49.71 arc(19.63,49.6) 20.02,49.47 arc(20.11,49.44) 20.19,49.41 arc(20.2,49.41) 20.21,49.4 arc(20.91,49.1) 21.58,48.72 arc(21.71,48.64) 21.84,48.55 arc(22.44,48.1) 23,47.59 23.67,46.92 25.77,44.82 26.57,44.02 arc(26.86,43.83) 27.2,43.76 28.07,43.76 arc(28.09,43.76) 28.11,43.77 RT594.1
TBT_A_TRX_DTX_N1_R: length 4.6
  TOP w0.229: RT594.2 28.9,43.74 arc(29.01,43.66) 29.15,43.63 29.15,43.63 arc(29.45,43.56) 29.7,43.39 29.95,43.14 arc(30.1,43.04) 30.27,43 30.35,43 arc(30.55,43.05) v2(30.73,43.16)
  BOTTOM w0.089: v2(30.73,43.16) 30.94,42.95 arc(30.98,42.93) 31.03,42.92 31.03,42.92 arc(31.1,42.93) 31.16,42.98 31.24,43.05 arc(31.37,43.14) 31.53,43.17 31.63,43.17 arc(31.74,43.2) 31.83,43.26 32.09,43.52 arc(32.18,43.58) 32.28,43.6 32.39,43.6 arc(32.51,43.48) 32.39,43.37 UT1.A21
TBT_A_TRX_DTX_N2: length 27.6
  TOP w0.229: JUSBC1.B10 6.15,56.73 arc(6.29,56.76) 6.41,56.84 6.53,56.96 arc(6.6,57) v2(6.68,57.02)
  BOTTOM w0.229: v2(6.68,57.02) 6.81,57.15 8.14,57.15 arc(8.35,57.19) 8.54,57.29 arc(8.62,57.34) 8.72,57.36 12.15,57.36 DT9.1 12.45,57.32 arc(12.55,57.39) 12.68,57.42 13.83,57.42 arc(13.91,57.4) 13.98,57.36 arc(14.22,57.19) 14.51,57.14 17.85,57.14 arc(18.17,57.08) 18.44,56.9 24.18,51.15 arc(24.36,50.89) 24.42,50.57 24.42,50.24 arc(24.51,49.8) 24.75,49.43 27.12,47.07 27.35,46.84 arc(27.59,46.68) 27.87,46.62 27.92,46.62 arc(28.09,46.59) RT596.1
TBT_A_TRX_DTX_N2_R: length 4.3
  BOTTOM w0.089: UT1.B15 32.72,46.04 arc(32.72,46.04) 32.71,46.03 arc(32.69,46.02) 32.68,46 arc(32.67,46) 32.67,46 arc(32.57,45.94) 32.46,45.91 arc(32.43,45.91) 32.4,45.91 32.28,45.91 arc(32.19,45.93) 32.12,45.98 31.89,46.21 arc(31.83,46.25) 31.77,46.28 31.75,46.29 arc(31.69,46.31) 31.62,46.32 31.43,46.32 arc(31.35,46.3) 31.28,46.25 31.2,46.18 31.17,46.18
  BOTTOM w0.229: 31.17,46.18 30.49,46.18 arc(30.2,46.22) 29.94,46.33 arc(29.75,46.45) 29.54,46.5 29.32,46.5 RT596.2
TBT_A_TRX_DTX_P1: length 23.9
  TOP w0.229: JUSBC1.A11 7.92,52.48 arc(7.99,52.48) 8.07,52.47 arc(8.19,52.42) 8.32,52.4 arc(8.49,52.3) 8.65,52.18 9.54,51.28 arc(10.12,50.9) 10.8,50.76 11.58,50.76 arc(11.78,50.75) 11.97,50.71 12.68,50.51 14.72,49.88 arc(14.76,49.87) 14.79,49.86 14.87,49.82 arc(15.5,49.6) 16.16,49.53 16.45,49.53 arc(16.61,49.49) DT13.1 arc(16.99,49.56) 17.28,49.61 17.35,49.61 arc(17.5,49.61) 17.65,49.61 17.66,49.61 arc(17.87,49.6) 18.08,49.58 arc(18.57,49.52) 19.06,49.42 arc(20.28,49.04) 21.41,48.45 arc(21.54,48.37) 21.66,48.29 arc(22.24,47.86) 22.78,47.37 23.45,46.7 26.35,43.8 arc(26.74,43.54) 27.2,43.45 27.7,43.45 arc(27.96,43.39) 28.18,43.25 RT595.1
TBT_A_TRX_DTX_P1_R: length 4.6
  TOP w0.229: v2(30.73,42.45) 30.64,42.53 arc(30.47,42.65) 30.27,42.69 arc(29.98,42.75) 29.73,42.91 29.48,43.16 arc(29.32,43.27) 29.14,43.31 29.11,43.31 arc(28.95,43.28) RT595.2
  BOTTOM w0.089: v2(30.73,42.45) 30.97,42.69 arc(31.01,42.72) 31.06,42.73 arc(31.17,42.76) 31.27,42.83 arc(31.28,42.84) 31.29,42.85 31.37,42.93 arc(31.44,42.98) 31.53,43 31.63,43 arc(31.79,43.03) 31.94,43.11 arc(31.98,43.14) 32.02,43.15 32.49,43.15 arc(32.58,43.17) 32.66,43.22 UT1.B21
TBT_A_TRX_DTX_P2: length 27.6
  TOP w0.229: v2(6.68,57.6) 6.56,57.48 arc(6.28,57.3) JUSBC1.B11
  BOTTOM w0.229: RT597.1 28.16,47.06 arc(28.03,46.97) 27.87,46.94 arc(27.71,46.97) 27.58,47.06 27.35,47.29 24.98,49.66 arc(24.8,49.93) 24.74,50.24 24.74,50.57 arc(24.65,51.01) 24.4,51.38 18.66,57.12 arc(18.29,57.37) 17.85,57.46 14.51,57.46 arc(14.35,57.49) 14.21,57.58 arc(14.03,57.7) 13.83,57.74 12.49,57.74 12.43,57.8 12.4,57.8 DT10.1 arc(12.08,57.73) 11.8,57.67 8.72,57.67 arc(8.52,57.64) 8.34,57.54 arc(8.24,57.49) 8.14,57.47 7,57.47 arc(6.83,57.5) v2(6.68,57.6)
TBT_A_TRX_DTX_P2_R: length 4.3
  BOTTOM w0.089: 31.17,46.5 31.69,46.5 arc(31.73,46.49) 31.77,46.49 arc(31.85,46.46) 31.93,46.42 arc(32,46.37) 32.08,46.36 32.44,46.36 arc(32.49,46.35) 32.53,46.33 arc(32.53,46.15) 32.36,46.13 UT1.A15
  BOTTOM w0.229: 31.17,46.5 30.49,46.5 arc(30.42,46.5) 30.34,46.51 arc(30.23,46.54) 30.13,46.59 30.13,46.59 arc(29.85,46.76) 29.54,46.81 29.44,46.81 arc(29.36,46.82) 29.29,46.83 arc(29.09,46.9) 28.91,47.03 RT597.2
TBT_A_TTX_C_DRX_N1: length 26.9
  TOP w0.229: v2(6.68,52.92) 6.6,52.92 arc(6.56,52.93) 6.54,52.95 6.27,53.19 arc(6.23,53.22) 6.17,53.23 6.17,53.23 JUSBC1.B3
  BOTTOM w0.229: CT96.2 29.75,44.2 arc(29.58,44.13) 29.39,44.09 29.32,44.09 arc(29.29,44.08) 29.25,44.08 28.87,44.08 28.53,44.1 arc(26.99,44.49) 25.69,45.4 23.91,47.18 arc(20.91,49.18) 17.38,49.89 17.22,49.89 arc(16.97,49.95) DT6.1 16.67,50.01 arc(16.53,49.92) 16.37,49.88 15.69,49.88 arc(15.09,50) 14.59,50.34 arc(13.79,50.87) 12.86,51.06 10.05,51.06 arc(9.41,51.18) 8.87,51.54 8.02,52.4 arc(7.59,52.68) 7.08,52.78 6.9,52.78 6.87,52.79 arc(6.79,52.82) 6.72,52.88 v2(6.68,52.92)
TBT_A_TTX_C_DRX_N2: length 29.6
  TOP w0.229: v2(28.69,44.9) 28.53,45.06 arc(28.46,45.11) 28.37,45.13 27.79,45.13 arc(27.23,45.24) 26.76,45.55 22.44,49.87 arc(22.05,50.45) 21.92,51.13 21.92,53.13 arc(21.81,53.69) 21.49,54.16 18.71,56.95 arc(18.23,57.26) 17.67,57.37 12.75,57.37 arc(12.52,57.33) DT18.1 arc(12.15,57.31) 11.95,57.35 10.98,57.35 10.98,57.34 10.02,57.34 arc(9.73,57.32) 9.45,57.24 9.45,57.24 arc(9.12,57.08) 8.83,56.85 8.83,56.85 arc(8.8,56.82) 8.76,56.79 arc(8.71,56.76) 8.65,56.73 8.17,56.53 arc(8.04,56.49) 7.9,56.48 JUSBC1.A3
  BOTTOM w0.229: v2(28.69,44.9) arc(28.91,45.05) 29.17,45.1 29.48,45.1 arc(29.66,45.06) CT98.2
TBT_A_TTX_C_DRX_P1: length 26.9
  TOP w0.229: JUSBC1.B2 5.96,52.73 arc(6.17,52.69) 6.36,52.59 6.63,52.35 arc(6.66,52.34) v2(6.68,52.33)
  BOTTOM w0.229: v2(6.68,52.33) 6.81,52.46 7.19,52.46 arc(7.52,52.37) 7.79,52.17 8.64,51.32 arc(9.29,50.89) 10.05,50.74 12.86,50.74 arc(13.67,50.58) 14.36,50.12 arc(14.97,49.71) 15.69,49.57 16.59,49.57 DT5.1 arc(16.96,49.53) 17.2,49.57 17.37,49.57 17.37,49.57 arc(20.79,48.89) 23.68,46.96 25.46,45.18 arc(26.86,44.21) 28.5,43.78 arc(28.69,43.77) 28.87,43.77 29.06,43.77 arc(29.25,43.76) 29.43,43.73 CT95.2
TBT_A_TTX_C_DRX_P2: length 29.6
  TOP w0.229: JUSBC1.A2 7.86,56.98 arc(7.97,56.96) 8.06,56.9 8.12,56.9 arc(8.22,56.91) 8.33,56.94 8.53,57.03 arc(8.55,57.04) 8.58,57.05 arc(8.59,57.06) 8.61,57.07 8.61,57.08 arc(8.95,57.35) 9.34,57.54 9.35,57.54 arc(9.68,57.63) 10.02,57.66 10.85,57.66 10.85,57.66 11.83,57.66 arc(12.07,57.71) 12.28,57.85 DT17.1 12.35,57.85 arc(12.53,57.73) 12.74,57.69 17.67,57.69 arc(18.35,57.56) 18.93,57.17 21.71,54.39 arc(22.1,53.81) 22.24,53.13 22.24,51.13 arc(22.35,50.57) 22.66,50.1 26.98,45.78 arc(27.35,45.53) 27.79,45.44 28.28,45.44 arc(28.5,45.49) v2(28.69,45.61)
  BOTTOM w0.229: v2(28.69,45.61) arc(28.91,45.47) 29.16,45.42 29.5,45.42 arc(29.67,45.45) CT97.2
TBT_A_TTX_DRX_N1: length 2.7
  BOTTOM w0.089: CT96.1 30.45,44.18 arc(30.58,44.1) 30.74,44.06 31.02,44.06 arc(31.06,44.07) 31.09,44.09 31.15,44.15 arc(31.26,44.22) 31.38,44.25 31.63,44.25 arc(31.83,44.28) 32.01,44.36 arc(32.07,44.4) 32.12,44.45 32.12,44.45 arc(32.19,44.5) 32.28,44.52 32.42,44.52 arc(32.58,44.48) 32.71,44.39 32.81,44.3 UT1.B19
TBT_A_TTX_DRX_N2: length 2.6
  BOTTOM w0.089: CT98.1 30.5,45.07 arc(30.6,45.13) 30.72,45.16 31.87,45.16 arc(31.98,45.13) 32.07,45.07 32.08,45.06 arc(32.17,45) 32.29,44.98 32.41,44.98 arc(32.56,45) 32.69,45.09 UT1.B17
TBT_A_TTX_DRX_P1: length 2.7
  BOTTOM w0.089: UT1.A19 32.45,44.29 arc(32.49,44.28) 32.52,44.26 32.54,44.24 arc(32.56,44.21) 32.57,44.18 arc(32.56,44.12) 32.52,44.08 arc(32.49,44.07) 32.46,44.07 31.38,44.07 arc(31.33,44.06) 31.28,44.03 31.22,43.97 arc(31.13,43.91) 31.02,43.89 30.69,43.89 arc(30.64,43.88) 30.59,43.84 CT95.1
TBT_A_TTX_DRX_P2: length 2.6
  BOTTOM w0.089: CT97.1 30.51,45.43 arc(30.62,45.36) 30.75,45.33 31.85,45.33 arc(31.91,45.35) 31.96,45.38 31.98,45.39 arc(32.03,45.43) 32.09,45.44 32.42,45.44 arc(32.49,45.43) 32.54,45.39 32.55,45.38 arc(32.57,45.33) 32.55,45.27 32.53,45.26 arc(32.49,45.22) 32.43,45.21 UT1.A17
TBT_A_USB20N: length 3.7
  BOTTOM w0.102: UT5.A7 20.38,30.52 20.38,30.29 20.65,30.02 20.65,29.53 20.5,29.38 20.5,28.32 20.62,28.2 RT562.1 RT560.1
TBT_A_USB20P: length 3.7
  BOTTOM w0.102: RT559.1 RT561.1 20.18,28.2 20.31,28.33 20.31,29.46 20.46,29.61 20.46,29.94 20.19,30.21 20.19,30.52 UT5.A6
TBT_B_SBU1: length 41.7
  IN1 w0.102: v2(26,36.05) 25.85,36.2 25.65,36.2 25.59,36.13 25.59,35.49 25.87,35.21 25.87,33.41 26.49,32.78 26.49,31.32 26.11,30.94 25.77,30.94 v2(25.48,30.65)
  IN2 w0.094: v2(25.48,30.65) 25.41,30.72 23.89,30.72 22.07,32.54 22.07,35.41 23.15,36.49 24.45,36.49 24.68,36.72 25.15,36.72 26.19,37.76 27.22,37.76 28.81,39.35 29.8,39.35 32.07,41.63 32.07,46.87 34.29,49.09 34.29,49.81 35.03,50.55 35.24,50.55 35.74,50.55 36.1,50.91 36.26,50.91 v2(36.43,51.08)
  BOTTOM w0.102: RT385.1 24.85,31.03 25.08,31.03 25.16,30.95 25.37,30.95 25.48,30.84 v2(25.48,30.65) ; v2(36.43,51.08) UT1.L4 ; RT608.1 25.09,36.46 25.27,36.29 25.76,36.29 v2(26,36.05)
TBT_B_SBU2: length 41.8
  IN1 w0.102: v2(25.49,31.42) 25.77,31.13 26.03,31.12 26.3,31.4 26.3,32.7 25.68,33.33 25.68,35.13 25.4,35.41 25.4,36.21 25.49,36.3 25.57,36.39 25.75,36.39 v2(26,36.64)
  IN2 w0.094: v2(36.44,50.44) 36.44,50.67 36.39,50.72 36.19,50.72 35.83,50.36 35.24,50.36 35.11,50.36 34.49,49.73 34.49,49.01 32.27,46.78 32.27,41.54 29.88,39.16 28.89,39.16 27.3,37.57 26.27,37.57 25.23,36.53 24.76,36.53 24.53,36.29 23.23,36.29 22.27,35.33 22.27,32.62 23.97,30.92 25.06,30.92 25.17,31.02 25.17,31.33 25.26,31.42 v2(25.49,31.42)
  BOTTOM w0.102: v2(25.49,31.42) 25.49,31.22 25.41,31.14 25.24,31.14 25.16,31.22 24.84,31.22 RT386.1 ; UT1.L5 36.44,50.44 v2(36.44,50.44) ; v2(26,36.64) 25.84,36.48 25.35,36.48 25.17,36.65 24.94,36.65 24.55,37.04 RT609.1
TBT_B_TRX_DTX_N1: length 34.2
  TOP w0.229: JUSBC1.1A10 7.87,69.18 7.96,69.09 8.2,69.09 arc(8.45,69.04) 8.66,68.9 11.38,66.18 arc(11.62,65.81) 11.71,65.38 11.71,65.11 arc(11.76,64.86) DT45.1 arc(11.76,64.43) 11.71,64.18 11.71,62.27 arc(11.88,61.47) 12.33,60.78 13.06,60.06 arc(14.14,59.33) 15.42,59.08 18.7,59.08 arc(18.91,59.04) 19.09,58.92 23.22,54.79 arc(23.34,54.61) 23.38,54.4 23.38,51.99 arc(23.49,51.43) 23.81,50.96 26.49,48.27 arc(26.96,47.96) 27.51,47.85 28.23,47.85 arc(28.32,47.86) 28.4,47.9 RT598.2
TBT_B_TRX_DTX_N1_R: length 4
  TOP w0.229: RT598.1 29.33,47.92 arc(29.41,47.88) 29.49,47.87 29.79,47.87 arc(30.03,47.82) 30.24,47.68 arc(30.42,47.56) 30.63,47.52 30.65,47.52 arc(30.9,47.57) v2(31.11,47.72)
  BOTTOM w0.089: v2(31.11,47.72) 31.25,47.57 arc(31.4,47.48) 31.56,47.45 31.62,47.45 arc(31.76,47.42) 31.89,47.36 arc(31.97,47.31) 32.06,47.29 32.39,47.29 arc(32.51,47.27) 32.63,47.22 arc(32.67,47.19) 32.71,47.16 UT1.B13
TBT_B_TRX_DTX_N2: length 38.2
  TOP w0.229: JUSBC1.1B10 6.09,72.93 arc(6.39,72.99) 6.64,73.16 6.64,73.16 arc(6.66,73.17) v2(6.68,73.18)
  BOTTOM w0.229: RT600.2 29.28,50.78 arc(29.21,50.83) 29.13,50.87 29.08,50.88 arc(28.9,50.93) 28.74,51.04 28.28,51.5 arc(27.91,51.74) 27.47,51.83 27.34,51.83 arc(26.78,51.94) 26.31,52.26 22.13,56.44 arc(22.09,56.49) 22.05,56.54 22.03,56.58 arc(22.02,56.59) 22.02,56.6 22.01,56.61 18.7,63.36 arc(18.61,63.58) 18.55,63.8 18.19,65.6 arc(18.05,66.57) 18,67.54 18,70.14 arc(17.82,71.03) 17.32,71.78 15.95,73.15 arc(15.69,73.32) 15.39,73.38 15.17,73.38 arc(15.14,73.38) 15.11,73.38 arc(15.04,73.35) 14.99,73.31 DT51.1 arc(14.7,73.31) 14.5,73.35 12.68,73.35 arc(12.5,73.38) 12.33,73.47 arc(12.29,73.48) 12.25,73.48 8.25,73.48 arc(8.2,73.48) 8.15,73.47 arc(7.99,73.38) 7.82,73.35 7.1,73.35 arc(6.87,73.31) v2(6.68,73.18)
TBT_B_TRX_DTX_N2_R: length 3.4
  BOTTOM w0.089: 31.56,50.08 31.58,50.06 31.71,50.05 32.11,49.66 arc(32.18,49.61) 32.27,49.59 32.43,49.59 arc(32.52,49.63) 32.55,49.71 32.55,49.72 arc(32.53,49.79) 32.46,49.81 UT1.A7
  BOTTOM w0.229: 31.56,50.08 31.36,50.27 arc(31.29,50.32) 31.2,50.34 arc(30.93,50.4) 30.7,50.55 30.49,50.76 arc(30.45,50.8) 30.39,50.83 arc(30.36,50.84) 30.33,50.84 arc(30.13,50.8) RT600.1
TBT_B_TRX_DTX_P1: length 34.1
  TOP w0.229: JUSBC1.1A11 7.91,68.68 8,68.77 8.2,68.77 arc(8.33,68.75) 8.44,68.67 11.16,65.95 arc(11.33,65.69) 11.39,65.38 11.39,65.08 arc(11.35,64.84) DT44.1 arc(11.35,64.44) 11.4,64.2 11.4,62.27 arc(11.58,61.34) 12.11,60.56 12.83,59.83 arc(14.02,59.04) 15.42,58.76 18.7,58.76 arc(18.79,58.74) 18.86,58.69 22.99,54.57 arc(23.04,54.49) 23.06,54.4 23.06,51.99 arc(23.2,51.31) 23.58,50.73 26.27,48.05 arc(26.84,47.67) 27.51,47.54 28.25,47.54 arc(28.44,47.5) RT599.2
TBT_B_TRX_DTX_P1_R: length 4
  TOP w0.229: v2(31.11,47) 31.11,47 arc(30.89,47.15) 30.63,47.2 arc(30.29,47.27) 30.01,47.46 arc(29.91,47.53) 29.79,47.55 29.59,47.55 arc(29.38,47.51) RT599.1
  BOTTOM w0.089: v2(31.11,47) 31.27,47.15 arc(31.39,47.24) 31.55,47.27 31.62,47.27 arc(31.73,47.24) 31.83,47.17 32.08,46.91 arc(32.18,46.85) 32.3,46.82 32.38,46.82 arc(32.43,46.83) 32.47,46.86 32.48,46.88 arc(32.51,46.94) 32.46,47 UT1.A13
TBT_B_TRX_DTX_P2: length 38.2
  TOP w0.229: JUSBC1.1B11 6.08,73.43 arc(6.32,73.48) 6.53,73.62 6.66,73.75 arc(6.67,73.76) v2(6.68,73.77)
  BOTTOM w0.229: RT601.2 arc(29.18,51.23) 28.97,51.26 28.96,51.26 28.5,51.72 arc(28.03,52.04) 27.47,52.15 27.34,52.15 arc(26.91,52.24) 26.54,52.48 22.36,56.66 arc(22.34,56.68) 22.32,56.7 22.3,56.74 22.29,56.76 18.98,63.5 arc(18.91,63.68) 18.86,63.87 18.5,65.66 arc(18.36,66.6) 18.32,67.54 18.32,70.14 arc(18.12,71.15) 17.55,72 16.18,73.38 arc(15.82,73.62) 15.39,73.7 15.17,73.7 arc(15.07,73.72) 14.98,73.78 DT53.1 arc(14.63,73.72) 14.34,73.67 12.68,73.67 arc(12.6,73.68) 12.54,73.72 12.54,73.72 arc(12.52,73.74) 12.5,73.75 arc(12.38,73.79) 12.25,73.8 8.25,73.8 arc(8.11,73.79) 7.98,73.74 arc(7.91,73.69) 7.82,73.67 6.91,73.67 arc(6.79,73.7) v2(6.68,73.77)
TBT_B_TRX_DTX_P2_R: length 3.4
  BOTTOM w0.089: UT1.B7 32.63,49.99 arc(32.58,50.03) 32.5,50.04 32.11,50.04 arc(31.99,50.07) 31.88,50.14 31.78,50.24 31.78,50.3
  BOTTOM w0.229: RT601.1 29.98,51.3 arc(30.14,51.2) 30.33,51.16 arc(30.41,51.15) 30.49,51.13 arc(30.62,51.07) 30.73,50.97 30.92,50.77 arc(31.05,50.69) 31.2,50.66 arc(31.41,50.62) 31.58,50.5 31.78,50.3
TBT_B_TTX_C_DRX_N1: length 34.9
  TOP w0.229: JUSBC1.1B3 6.09,69.43 arc(6.21,69.41) 6.32,69.35 6.43,69.25 arc(6.55,69.17) v2(6.69,69.14)
  BOTTOM w0.229: CT360.2 29.64,48.24 arc(29.57,48.19) 29.48,48.17 28.85,48.17 arc(28.29,48.28) 27.81,48.6 26.09,50.32 arc(25.87,50.66) 25.79,51.05 25.79,51.18 arc(25.69,51.69) 25.4,52.13 19.34,58.19 arc(18.76,58.58) 18.08,58.71 15.62,58.71 arc(15.06,58.82) 14.59,59.14 12.12,61.6 arc(11.81,62.08) 11.69,62.64 11.69,64.3 arc(11.72,64.42) 11.78,64.52 DT48.1 11.86,64.68 arc(11.75,64.85) 11.71,65.05 11.71,65.2 arc(11.66,65.47) 11.51,65.7 8.96,68.25 arc(8.17,68.77) 7.25,68.95 7.01,68.95 arc(6.82,69) v2(6.69,69.14)
TBT_B_TTX_C_DRX_N2: length 38.1
  TOP w0.229: JUSBC1.1A3 8.02,72.68 arc(8.33,72.74) 8.6,72.92 8.65,72.97 arc(9.11,73.28) 9.65,73.39 14.41,73.39 arc(14.66,73.34) DT54.1 14.93,73.25 arc(15.12,73.38) 15.34,73.42 arc(15.56,73.38) 15.74,73.25 17.71,71.29 arc(18.07,70.76) 18.19,70.13 18.19,65.81 arc(18.25,65.35) 18.43,64.92 23.83,55.51 arc(23.92,55.34) 23.98,55.16 23.98,55.16 24.17,54.46 arc(24.18,54.43) 24.18,54.4 24.18,53.31 arc(24.32,52.63) 24.7,52.05 26.92,49.83 arc(27.29,49.58) 27.73,49.5 27.86,49.5 27.92,49.5 arc(28.15,49.45) v2(28.35,49.32)
  BOTTOM w0.229: v2(28.35,49.32) 28.41,49.39 arc(28.51,49.45) 28.62,49.47 28.63,49.47 arc(28.68,49.47) 28.74,49.46 CT365.2
TBT_B_TTX_C_DRX_P1: length 34.9
  TOP w0.229: JUSBC1.1B2 6.1,68.93 arc(6.2,68.91) 6.29,68.86 6.56,68.63 arc(6.62,68.57) v2(6.69,68.55)
  BOTTOM w0.229: v2(6.69,68.55) 6.77,68.64 7.25,68.64 arc(8.05,68.48) 8.73,68.02 11.28,65.47 arc(11.37,65.35) 11.39,65.2 11.39,64.82 DT43.1 11.23,64.63 arc(11.34,64.46) 11.38,64.27 11.38,62.64 arc(11.51,61.96) 11.9,61.38 14.36,58.92 arc(14.94,58.53) 15.62,58.39 18.08,58.39 arc(18.64,58.28) 19.11,57.97 25.17,51.91 arc(25.4,51.57) 25.47,51.18 25.47,51.05 arc(25.58,50.54) 25.87,50.1 27.59,48.38 arc(28.17,47.99) 28.85,47.86 29.46,47.86 arc(29.61,47.83) CT359.2
TBT_B_TTX_C_DRX_P2: length 38.1
  TOP w0.229: JUSBC1.1A2 7.95,73.18 8.05,73.08 8.2,73.08 arc(8.3,73.1) 8.38,73.15 8.42,73.19 arc(8.99,73.57) 9.65,73.7 14.43,73.7 arc(14.67,73.75) DT52.1 14.95,73.81 arc(15.03,73.76) 15.12,73.74 15.34,73.74 arc(15.68,73.67) 15.97,73.48 17.94,71.51 arc(18.36,70.88) 18.51,70.13 18.51,65.81 arc(18.56,65.43) 18.7,65.08 24.11,55.67 arc(24.21,55.46) 24.29,55.24 24.29,55.24 24.48,54.54 arc(24.49,54.47) 24.5,54.4 24.5,53.31 arc(24.61,52.75) 24.93,52.28 27.15,50.05 arc(27.41,49.88) 27.73,49.81 27.86,49.81 27.92,49.81 28.11,49.86 arc(28.19,49.89) 28.25,49.94 v2(28.35,50.04)
  BOTTOM w0.229: v2(28.35,50.04) 28.53,49.85 arc(28.58,49.82) 28.63,49.79 arc(28.71,49.79) 28.79,49.78 28.93,49.78 arc(29,49.79) 29.08,49.81 CT366.2
TBT_B_TTX_DRX_N1: length 2.8
  BOTTOM w0.089: UT1.B11 32.62,48.16 arc(32.58,48.19) 32.53,48.2 32.18,48.2 arc(32.13,48.19) 32.09,48.16 32.03,48.11 arc(32,48.09) 31.96,48.08 31.74,48.08 arc(31.69,48.09) 31.64,48.12 31.57,48.19 arc(31.48,48.26) 31.37,48.28 30.88,48.28 arc(30.81,48.26) 30.75,48.22 arc(30.73,48.21) 30.71,48.19 arc(30.65,48.16) 30.58,48.15 30.54,48.15 arc(30.49,48.16) 30.45,48.19 CT360.1
TBT_B_TTX_DRX_N2: length 3.4
  BOTTOM w0.089: UT1.B9 32.69,48.77 arc(32.57,48.69) 32.43,48.66 32.3,48.66 arc(32.19,48.69) 32.09,48.75 31.95,48.9 arc(31.93,48.91) 31.92,48.93 arc(31.85,48.98) 31.76,49 31.59,49 arc(31.49,48.98) 31.41,48.92
  BOTTOM w0.229: 31.41,48.92 31.15,48.92 arc(30.94,48.96) 30.76,49.08 30.7,49.14 arc(30.54,49.25) 30.34,49.29 29.84,49.29 CT365.1
TBT_B_TTX_DRX_P1: length 2.8
  BOTTOM w0.089: UT1.A11 32.47,47.97 arc(32.49,47.97) 32.52,47.95 arc(32.54,47.82) 32.43,47.75 32.29,47.75 arc(32.2,47.76) 32.13,47.8 32.13,47.8 arc(32.08,47.83) 32.03,47.86 arc(31.96,47.89) 31.88,47.9 31.74,47.9 arc(31.62,47.92) 31.52,47.99 31.44,48.07 arc(31.41,48.09) 31.37,48.1 30.95,48.1 arc(30.88,48.08) 30.81,48.03 arc(30.73,47.98) 30.64,47.98 arc(30.62,47.97) 30.61,47.97 arc(30.54,47.95) 30.48,47.91 CT359.1
TBT_B_TTX_DRX_P2: length 3.4
  BOTTOM w0.089: UT1.A9 32.39,48.88 arc(32.49,48.88) 32.55,48.96 32.56,48.98 arc(32.56,49.05) 32.5,49.1 arc(32.45,49.11) 32.41,49.12 32.06,49.12 arc(32,49.12) 31.94,49.14 31.91,49.15 arc(31.84,49.17) 31.76,49.17 31.5,49.17 31.44,49.24 31.41,49.24
  BOTTOM w0.229: 31.41,49.24 31.15,49.24 arc(31.06,49.26) 30.98,49.31 30.92,49.37 arc(30.66,49.54) 30.34,49.61 30.11,49.61 arc(30.01,49.63) 29.93,49.69 CT366.1
TBT_B_USB20N: length 2.9
  BOTTOM w0.102: UT5.G11 22.69,33.52 22.94,33.52 23.07,33.66 24.18,33.66 RT558.2 RT556.2
TBT_B_USB20P: length 2.9
  BOTTOM w0.102: RT555.2 RT557.2 24.19,33.47 23.15,33.47 23.02,33.33 22.69,33.33 UT5.F11
TBT_CIO_PLUG_EVENT#: length 112.7
  TOP w0.102: v2(95.83,66.73) 103.45,66.73 107.31,62.87 107.31,59.65 110.91,56.06 115.82,56.06 117.63,54.24 v1(117.65,54.24) 117.65,51.32 116.39,50.07 115.78,50.07 115.52,49.8 115.52,47.71 115.65,47.59 120.37,47.59 121.82,46.14 121.82,45.91 122.45,45.28 123.31,45.28 UH1.BF8
  IN4 w0.102: v2(46.56,57.49) 46.56,56.95 47.1,56.4 48.31,56.4 49.2,55.51 52.82,55.51 53.11,55.81 57.82,55.81 58.14,56.12 59.59,56.12 60.05,56.58 66.59,56.58 67.01,56.16 68.45,56.16 69.2,56.91 85.51,56.91 85.7,57.1 88.21,57.1 92.78,61.66 92.78,64.01 95.5,66.73 v2(95.83,66.73)
  BOTTOM w0.109: UT1.AA1 41.55,52.82 42.08,53.35 43.25,53.35 43.39,53.49 43.98,53.49 44.98,52.49 45.39,52.49 46.49,53.59 RT391.1 46.49,57.44 46.54,57.48 46.55,57.48 v2(46.56,57.49)
TBT_FORCE_PWR: length 106.2
  TOP w0.102: UH1.BE15 123.81,41.82 123.54,42.09 122.44,42.09 v2(122.3,42.22)
  TOP w0.109: v2(39.68,51.08) 40.11,51.51 40.11,52.08 40.34,52.3 40.68,52.3 40.97,52.59 RT592.1 41.6,52.97 RT27.1
  IN2 w0.081: v2(122.3,42.22) 119.62,44.91 115.69,44.91 115.37,45.22 115.37,45.61 v2(114.92,46.06)
  IN4 w0.102: v2(114.92,46.06) 114.61,45.76 114.08,45.76 113.72,46.12 113.72,50.42 109.74,54.4 107.91,54.4 103.24,59.07 95.38,59.07 90.87,54.55 83.39,54.55 82.2,53.35 75.83,53.35 75.23,53.95 75.23,54.52 75.03,54.73 74.25,54.73 74.03,54.5 74.03,54.19 72.83,53 71.81,53 71.3,52.49 66.8,52.49 65.93,53.36 59.72,53.36 59.49,53.13 53.96,53.13 52.64,51.81 46.45,51.81 45.77,52.49 44.96,52.49 43.98,53.47 43.19,53.47 42.77,53.05 41.65,53.05 v2(39.68,51.08)
  BOTTOM w0.109: v2(114.92,46.06) 115.25,46.4 v1(115.25,46.56) ; UT1.V4 v2(39.68,51.08)
TBT_I2C_SCL: length 82.3
  IN3 w0.081: v2(12.77,31.89) 12.37,31.49 12.37,29.63 14.61,27.39 15.51,27.39 15.89,27.77 20.53,27.77 21.19,28.42 25.46,28.42 27.07,30.04 27.07,31.41 27.56,31.89 27.56,36.57 26.03,38.1 26.03,40.63 23.98,42.69 23.98,56.63 25.27,57.93 29.06,57.93 30.15,59.02 38.5,59.02 38.62,58.9 41.25,58.9 41.3,58.94 42.91,58.94 v2(42.94,58.98)
  BOTTOM w0.076: UT1.V2 40.41,52.35 40.41,52.77 ; UT5.E2 17.79,32.43 17.07,32.43
  BOTTOM w0.109: 40.41,52.77 40.41,53.2 42.13,54.93 42.36,54.93 42.67,55.23 42.67,57.01 42.58,57.1 42.58,58.61 v2(42.94,58.98) ; RT514.1 v2(12.77,31.89) 13.13,31.53 v1(14.85,31.53) 15.75,32.43 17.07,32.43
TBT_I2C_SDA: length 77.8
  IN3 w0.081: v2(42.54,59.45) 42.26,59.17 41.2,59.17 41.16,59.13 38.7,59.13 38.58,59.25 29.89,59.25 28.9,58.25 25.17,58.25 23.7,56.78 23.7,42.38 23.68,42.37 23.68,40.28 25.75,38.21 25.75,38.05 26.43,37.37 26.43,35.84 26.1,35.51 26.1,33.66 24.45,32.01 24.45,31.17 23.56,30.28 17.69,30.28 16.25,28.84 16.25,28.64 15.49,27.88 14.75,27.88 14.21,28.41 14.21,29.39 12.8,30.8 v2(12.8,31.1)
  BOTTOM w0.076: 17.14,31.92 17.78,31.92 UT5.D2
  BOTTOM w0.109: v2(42.54,59.45) 42.34,59.25 42.34,57 42.43,56.91 42.43,55.28 42.28,55.12 42.05,55.12 40.17,53.25 UT1.V1 ; 17.14,31.92 16.42,31.92 15.08,30.58 v1(13.69,30.58) 13.33,30.58 v2(12.8,31.1) 12.32,31.1 RT510.1
TBT_ID: length 6.5
  TOP w0.102: 123.07,34.62 123.15,34.62 123.34,34.81 123.34,34.81 UH1.BF29
  TOP w0.109: RH267.1 117.7,33.21 119.33,33.21 RH268.1 119.99,33.72 121.45,33.72 121.97,34.24 122.69,34.24 123.07,34.62
TBT_JTAG_TCK: length 10
  TOP w0.109: v2(38.2,40.56) 38.22,40.56 38.54,40.88 RT6.1 v1(39.11,39.88)
  IN1 w0.102: v2(40.34,44.59) 40.34,44.61 39.82,45.13 39.57,45.13 38.96,44.52 38.2,44.52 37.95,44.26 37.95,43.63 38.99,42.59 38.99,41.33 38.22,40.56 v2(38.2,40.56)
  BOTTOM w0.109: UT1.W19 v2(40.34,44.59)
TBT_JTAG_TDI: length 1.7
  TOP w0.109: RT8.1 40.34,43.02 v2(40.34,43.94)
  BOTTOM w0.109: UT1.W20 v2(40.34,43.94)
TBT_JTAG_TDO: length 2.6
  TOP w0.109: RT5.1 v1(41.73,43.85) v2(40.99,44.59)
  BOTTOM w0.109: UT1.Y19 v2(40.99,44.59)
TBT_JTAG_TMS: length 1.7
  TOP w0.109: RT7.1 40.99,42.86 v2(40.99,43.94)
  BOTTOM w0.109: UT1.Y20 v2(40.99,43.94)
TBT_PCIE_RBIAS: length 1.2
  TOP w0.109: RT34.1 37.97,45 v2(37.74,45.24)
  BOTTOM w0.102: UT1.N16 37.74,45.24 v2(37.74,45.24)
TBT_PERST#: length 91.7
  TOP w0.109: v2(115.5,57.4) 115.45,57.45 RT621.2 115.85,59.01 116.57,59.01 116.77,58.8 v1(118.77,58.8) 118.98,59.02 RT501.2 119.63,59.77 RT612.2
  IN2 w0.081: v2(115.5,57.4) 114.93,57.4 114.42,56.89 108.05,56.89 v2(107.1,55.95)
  IN4 w0.102: v2(39.04,51.09) 41.19,53.24 42.7,53.24 43.19,53.74 44.14,53.74 44.93,52.95 46.13,52.95 47.05,52.03 50.65,52.03 51.53,52.91 53.02,52.91 53.47,53.36 59.32,53.36 59.57,53.61 71.65,53.61 72.99,54.96 75.19,54.96 75.46,54.68 75.46,54.05 75.92,53.58 82.1,53.58 83.3,54.78 90.77,54.78 95.29,59.29 103.33,59.29 106.68,55.95 v2(107.1,55.95)
  BOTTOM w0.109: v2(39.04,51.09) UT1.T4
TBT_PERST#_R: length 2.6
  TOP w0.109: v1(117.52,59.31) 117.98,59.77 RT501.1 RT611.2 118.35,60.39 UT34.4
TBT_PWR_EN: length 2.5
  TOP w0.102: UH1.BF15 123.41,41.86 121.17,41.86 T269.1
TBT_RBIAS: length 3.6
  TOP w0.109: RT39.1 34.69,52.12 34.69,50.89 35.78,49.81 v2(35.78,49.78)
  BOTTOM w0.109: UT1.J6 v2(35.78,49.78)
TBT_RESET_N_EC: length 134.3
  TOP w0.109: v2(121.21,64.2) 120.91,64.5 v1(120.91,64.9) 120.91,65.08 119.23,66.76 118.18,66.76 117.17,67.78 117.17,70.16 116.63,70.7 112.92,70.7 111.89,69.67 101.35,69.67 100.19,68.51 98.19,68.51 97.59,67.91 v2(96.09,67.91) ; v2(138.63,68) 138.88,68 139.16,67.72 139.16,66.58 139.05,66.47 RE506.2
  IN2 w0.081: v2(96.09,67.91) 94.89,67.91 90.49,63.51 87.22,63.51 83.21,59.5 80.08,59.5 79.69,59.11 78.57,59.11 76.93,57.47 70.04,57.47 69.77,57.74 66.98,57.74 66.16,56.92 64.29,56.92 63.86,57.34 58.01,57.34 57.35,58 57.35,58.43 57.09,58.69 52.27,58.69 51.76,58.18 45.69,58.18 45.41,57.9 44.21,57.9 43.62,58.49 38.22,58.49 37.13,57.4 36.55,57.4 35.42,56.27 32.4,56.27 v2(31.75,55.62)
  IN3 w0.081: v2(33.83,50.43) 32.99,51.27 32.99,54.06 32.57,54.49 32.01,54.49 31.75,54.75 v2(31.75,55.62) ; v2(121.21,64.2) 121.47,64.47 126.71,64.47 127.23,63.95 129.72,63.95 129.95,64.18 133.13,64.18 133.83,64.89 133.83,65.97 134.01,66.14 135.92,66.14 136.03,66.26 137.34,66.26 138.5,67.43 138.5,67.87 v2(138.63,68)
  BOTTOM w0.109: v2(33.83,50.43) 34.16,50.76 UT1.E5 ; RT37.1 31.18,56.33 31.23,56.38 RT11.1 31.99,55.93 31.75,55.69 v2(31.75,55.62)
TBT_RESET_N_EC_R: length 4.9
  TOP w0.109: RE506.1 RE95.2 137.91,67.39 137.88,67.41 137.88,68.77 138.06,68.95 138.06,70.87 UE1.L8
TBT_ROM_CLK: length 5.6
  TOP w0.109: v2(40.99,45.89) v1(41.78,45.89) 42.51,45.16 43.86,45.16 44.05,44.97 44.71,44.97 44.9,44.77 UT2.6
  BOTTOM w0.109: v2(40.99,45.89) UT1.Y16
TBT_ROM_CS#: length 18.3
  TOP w0.109: UT2.1 47.44,52.05 47.06,52.43 RT2.1 v2(47.75,52.72)
  IN2 w0.081: v2(47.75,52.72) 47.45,52.72 45.16,50.43 45.16,47.58 44.14,46.56 44.14,45.88 43.45,45.19 42.7,45.19 41.36,46.52 40.31,46.52 39.82,46.04 39.82,45.75 v2(40.34,45.24)
  BOTTOM w0.109: v1(47.37,52.25) 47.37,52.34 v2(47.75,52.72) ; UT1.W18 v2(40.34,45.24)
TBT_ROM_DI: length 5.6
  TOP w0.109: v2(40.99,45.24) 41.3,44.93 43.3,44.93 43.63,44.59 UT2.5 43.63,42.98 v1(44.07,42.55)
  BOTTOM w0.109: UT1.Y18 v2(40.99,45.24)
TBT_ROM_DO: length 14.6
  TOP w0.109: RT3.1 46.17,52.55 UT2.2 46.17,47.41 44.22,45.46 v2(44.22,45.38)
  IN2 w0.081: v2(44.22,45.38) 43.8,44.96 42.66,44.96 41.35,46.27 40.72,46.27 v2(40.34,45.89)
  BOTTOM w0.109: UT1.W16 v2(40.34,45.89) ; v1(45.2,44.85) 44.66,45.38 v2(44.22,45.38)
TBT_ROM_HOLD#: length 2.6
  TOP w0.109: v1(46.48,41.54) RT1.1 46.17,42.86 UT2.7
TBT_ROM_WP#: length 9.5
  TOP w0.109: v2(45.51,52.08) 45.51,51.5 45.28,51.27 UT2.3 44.9,52.34 RT4.1
  IN2 w0.081: v2(40.34,51.09) 41.07,51.83 45.26,51.83 v2(45.51,52.08)
  BOTTOM w0.109: v2(40.34,51.09) UT1.W4 ; v1(45.9,52.45) 45.53,52.08 v2(45.51,52.08)
TBT_RSENSE: length 2.1
  TOP w0.109: v2(35.79,51.11) 35.9,51.11 36.22,51.43 36.22,51.98 RT39.2
  BOTTOM w0.109: UT1.J5 36.11,50.78 v2(35.79,51.11)
TBT_RTD3_WAKE#: length 115.4
  TOP w0.109: v2(134.76,21.16) 135.27,21.16 135.52,20.91 135.52,20.53 135.13,20.14 135.13,19.78 135.52,19.4 135.52,17.41 136.62,16.31 137.64,16.31 137.86,16.54 139.45,16.54 140.36,17.45 140.36,19.12 RH732.2 ; RT622.1 111.94,66.09 112.31,65.72 112.31,65.26 112.14,65.09 111.61,65.09 111.44,64.92 111.44,64.42 111.62,64.24 112.3,64.24 112.66,64.59 RT456.1 112.84,64.28 112.33,63.77 v2(112.33,63.3) ; v2(106.19,59.44) 108.42,57.21 108.42,55.18 103.65,50.42 100.41,50.42 99.45,49.46 v1(99.45,46.33) v2(99.45,40.21) ; v2(109.42,30.94) 110.37,30.94 110.82,30.49 110.82,29.92 110.62,29.72 110.62,29.35 110.77,29.21 110.77,27.25 111.64,26.37 RH735.2
  IN1 w0.102: v2(134.76,21.16) 131.46,21.16 130.29,19.99 130.29,16.59 129.62,15.93 126.21,15.93 125.45,15.17 122.36,15.17 117.67,19.85 117.67,20.36 116.88,21.15 116.38,21.15 116.3,21.23 115.94,21.38 115.09,22.23 112.86,22.23 111.83,23.26 110.75,23.26 110.05,23.96 110.05,25.47 109.17,26.36 109.17,30.69 v2(109.42,30.94) 109.17,31.19 109.17,34.25 108.73,34.69 105.48,34.69 99.95,40.21 v2(99.45,40.21)
  IN2 w0.081: v2(112.33,63.3) 112.33,62.46 109.76,59.9 106.64,59.9 v2(106.19,59.44)
TBT_RTD3_WAKE#_GPD7: length 13.5
  TOP w0.102: 116.52,26.92 116.53,26.93 118.07,26.93 118.75,26.25 119.23,26.25 120.52,27.54 120.52,27.92 121.15,28.55 121.46,28.55 122.17,29.26 123.29,29.26 123.37,29.18 123.73,29.18 123.96,28.95 UH1.BE41
  TOP w0.109: 116.52,26.92 115.96,26.92 v1(115.86,26.82) 115.78,26.82 115.11,26.15 RH602.1 114.86,26.33 114.57,26.61 113.36,26.61 RH735.1
TBT_RTD3_WAKE#_R: length 7.1
  TOP w0.109: RH732.1 138.94,19.94 139.27,20.27 139.27,21.53 139.18,21.62 RH731.2 138.76,22.24 138.57,22.43 138.57,25.54 138.31,25.8 UH1.T47
TBTA_CC1: length 39.9
  TOP w0.109: v2(15.12,51.77) v1(15.12,52.78)
  TOP w0.254: v2(6.69,54.1) 6.61,54.1 6.48,54.23 JUSBC1.B5
  TOP w0.508: DT2001.1 v2(15.12,51.77)
  IN3 w0.508: v2(15.12,51.77) 14.3,50.94 14.3,45.99 16.53,43.75 16.53,43.27 14.7,41.44 14.7,38.75 v2(13.31,37.35) 13.31,36.87 13.65,36.53 14.23,36.53 14.63,36.13 14.63,35.54 14.9,35.27 17.01,35.27 17.39,34.89 18.85,34.89 19.07,34.66 v2(19.1,34.66)
  BOTTOM w0.254: 13.48,52.84 DT7.9 DT7.1 11.76,53.19 ; UT5.K2 18.38,34.83 19.03,34.83 19.1,34.76 v2(19.1,34.66)
  BOTTOM w0.381: v2(13.31,37.35) 14.56,37.35 15.03,36.87 15.03,36.79 CT352.1
  BOTTOM w0.457: v2(6.69,54.1) 7.28,54.1
  BOTTOM w0.508: 7.28,54.1 9.62,54.1 10.39,53.33 11.61,53.33 11.76,53.19 ; v2(15.12,51.77) 14.55,51.77 13.48,52.84
TBTA_CC2: length 44.2
  TOP w0.254: v2(13.22,55.83) 13.22,55.27 DT8.5 DT8.6 11.33,55.19 ; 8.37,55.35 8.02,55.35 7.89,55.48 JUSBC1.A5
  TOP w0.508: DT2003.1 14.94,56.06 13.45,56.06 v2(13.22,55.83) ; 8.37,55.35 11.13,55.35 11.3,55.19 11.33,55.19
  IN2 w0.508: v2(12.7,34.73) 12.36,35.07 12.16,35.07 11,36.24 11,37.76 9.94,38.81 9.94,45.53 11.23,46.82 13.05,46.82 13.38,47.16 13.38,52.22 12.72,52.89 12.72,54.71 13.22,55.2 v2(13.22,55.83)
  IN3 w0.508: v2(12.7,34.73) 13.3,34.73 13.54,34.5 13.54,33.88 14.59,32.83 17.29,32.83 18.1,33.64 v2(18.54,33.64)
  BOTTOM w0.109: v1(11.03,36.2) 11.96,35.27 CT354.1
  BOTTOM w0.254: v2(18.54,33.64) 18.54,33.68 18.04,34.17 UT5.H2
  BOTTOM w0.508: v2(12.7,34.73) 12.48,34.73 12.01,35.19 CT354.1
TBTA_DPSRC_AUX_N_C: length 6.6
  BOTTOM w0.102: UT5.C11 22.64,31.57 22.88,31.57 23.05,31.4 23.05,30.65 23.82,29.87 23.82,29.49 23.97,29.35 24.1,29.35 RT388.1 24.72,29.97 25.68,29.97 25.92,29.73 25.92,29.16 25.98,29.1 26.17,29.1 26.41,29.34 RT516.1
TBTA_DPSRC_AUX_P_C: length 6.2
  BOTTOM w0.102: UT5.B11 22.54,31.24 22.68,31.38 22.8,31.38 22.86,31.32 22.86,30.57 23.63,29.79 23.63,29.42 23.89,29.16 24.23,29.16 RT387.1 24.93,28.46 25.54,28.46 25.99,28.92 26.16,28.92 26.41,28.67 RT523.1
TBTA_HPD: length 46.7
  IN3 w0.081: v2(22.17,40.15) 22.17,41.51 23.24,42.57 23.24,57.27 24.8,58.83 28.46,58.83 29.66,60.03 33.6,60.03 33.91,60.34 38.11,60.34 38.55,59.9 38.55,59.68 38.88,59.36 41.01,59.36 41.33,59.67 v2(41.49,59.67)
  BOTTOM w0.076: 20.8,35.84 20.78,35.82 20.78,35.42 UT5.K7
  BOTTOM w0.109: RT619.1 41.4,57.42 40.85,57.97 RT23.1 41.49,58.98 v1(41.49,59.07) v2(41.49,59.67) ; v2(22.17,40.15) 22.17,39.8 22.6,39.38 22.6,38.5 22.07,37.98 RT529.2 22.04,37.54 21.98,37.48 21.98,37.1 20.95,36.07 20.95,35.98 20.8,35.84
TBTA_HPD_R: length 8.4
  BOTTOM w0.076: 39.47,52.85 39.47,52.33 UT1.T2
  BOTTOM w0.109: 39.47,52.85 39.47,53.99 40.5,55.02 40.5,56.08 v1(40.66,56.23) 40.82,56.39 RT619.2 40.5,57.53 40.5,57.92 40.01,58.42 39.76,58.42 39.2,58.97 RT623.2
TBTA_I2C_INT#: length 80.3
  TOP w0.109: v2(37.09,51.07) 37.09,51.58 36.49,52.19 RT16.1
  IN2 w0.081: v2(37.09,51.07) 37.09,51.07 37.09,52.87 35.98,53.98 35.98,56.53 36.64,57.19 37.63,57.19 37.84,56.97 v2(37.84,56.7)
  IN3 w0.081: v2(37.84,56.7) 37.84,56.85 37.21,57.48 36.26,57.48 35.63,58.1 30.95,58.1 30.15,57.3 30.15,52.05 29.65,51.55 28.09,51.55 27.34,50.8 27.34,42.77 26.26,41.69 26.26,38.19 27.79,36.67 27.79,31.8 27.3,31.31 27.3,27.74 26.57,27.02 25.96,27.02 24.78,28.2 21.28,28.2 20.58,27.49 15.93,27.49 15.61,27.16 14.51,27.16 12.14,29.54 12.14,32.27 v2(12.77,32.91)
  BOTTOM w0.076: 17.14,33.42 17.15,33.42 17.7,33.42 17.94,33.17 UT5.F2
  BOTTOM w0.109: RT511.1 v2(12.77,32.91) 13.34,33.48 v1(13.69,33.48) 14.09,33.08 15.05,33.08 15.46,33.49 17.08,33.49 17.14,33.42 ; v2(37.09,51.07) 37.09,51.09 UT1.M4
