# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP (solid shape): 110.01,101.92 110.79,101.92 111.17,101.54 111.17,99.46 110.87,99.15 108.89,99.15 107.94,100.1 107.94,102.19 107.94,102.2 107.94,102.8 108.08,102.95 108.98,102.95
GND on TOP (solid shape): 116.15,92.36 116.15,88.79 116.02,88.66 115.45,88.66 115.33,88.79 115.33,89.3 115.2,89.42 114.82,89.42 114.25,89.99 114.25,91.72 114.78,92.26 115.1,92.26 115.35,92.5 116.01,92.5
GND on TOP (solid shape): 316.1,59.32 316.1,57.9 315.52,57.32 312.62,57.32 311.17,58.77 309.56,58.77 309.47,58.85 309.47,59.06 309.52,59.11 311.17,59.11 311.61,59.55 312.64,59.55 312.65,59.55 315.87,59.55
GND on TOP (solid shape): 77.66,10.98 77.66,9.58 77.12,9.04 76.58,9.04 76.58,9.03 71.19,9.03 71.12,9.11 71.12,10.12 71.27,10.28 71.73,10.28 71.85,10.4 71.85,11.34 72.21,11.7 76.95,11.7
GND on TOP (solid shape): 155.15,3.08 155.31,2.75 155.55,2.46 155.55,1.89 155.19,1.54 148.69,1.54 148.54,1.69 148.54,4.36 148.79,4.61 153.62,4.61
GND on TOP (solid shape): 274.82,60.54 274.82,59.65 274.5,59.34 273.67,59.34 273.57,59.24 265.53,59.24 265.4,59.37 265.4,60.16 265.45,60.2 267.87,60.2 268.29,60.62 274.74,60.62
GND on TOP (solid shape): 65.71,28.28 65.71,27.88 65.71,27.88 66.26,27.88 66.26,27.87 66.26,27.68 66.26,27.68 65.72,27.68 65.71,27.66 65.71,27.23 65.67,27.19 65.05,27.19 64.96,27.28 64.96,28.25 65,28.29 65.7,28.29
GND on TOP (solid shape): 370.15,44.8 370.87,44.8 370.9,44.77 370.9,44.76 371.12,44.54 371.12,44.1 371.03,44.01 367.49,44.01 367.36,44.14 367.36,45.47 367.48,45.6 369.36,45.6
GND on TOP (solid shape): 138.23,66.76 138.23,66.05 138.24,66.04 138.24,65.44 138.17,65.37 138.17,65.26 136.56,65.26 136.56,65.29 136.2,65.29 135.75,65.74 135.75,65.75 135.75,66.09 135.79,66.09 135.79,66.82 135.8,66.84 138.15,66.84
GND on TOP (solid shape): 62.96,8.45 64.36,8.45 65.38,7.43 65.38,5.68 64.72,5.02 60.37,5.02 59.33,6.06 56.46,6.06 55.19,7.33 55.19,8.37 55.34,8.52 56.87,8.52 57.17,8.22 58.17,8.22 58.85,8.9 62.5,8.9
GND on TOP (solid shape): 107.49,39.88 107.49,38.81 108.3,37.99 108.3,34.44 107.97,34.1 107.31,34.1 107.22,34.19 107.22,34.85 107.06,35 105.42,35 105.27,35.16 105.27,39.82 105.43,39.98 107.39,39.98
GND on TOP (solid shape): 129.46,175.35 138.44,175.35 138.44,169.02 137.46,168.04 133.01,168.04 132.63,168.07 132.25,168.04 129.11,168.04 128.04,166.97 127.53,166.97 126.73,167.77 126.73,177.9 129.46,177.9
GND on TOP (solid shape): 124.41,123.76 124.41,118.89 123.77,118.25 123.07,118.25 123.02,118.3 123.02,120.27 123.01,120.28 123.01,120.52 123.12,120.63 123.12,121.95 122.97,122.1 121.79,122.1 121.59,122.29 121.59,123.74 121.75,123.89 124.28,123.89
GND on TOP (solid shape): 394.51,29.52 394.51,28.96 394.5,28.95 394.5,28.32 392.62,26.44 392.62,24.58 392.19,24.15 391.22,24.15 390.95,24.42 390.95,25.11 391.51,25.67 391.51,26.73 393.21,28.43 393.21,29.61 393.54,29.95 394.07,29.95
GND on TOP (solid shape): 386.41,15.13 386.41,14.59 386.42,14.58 386.98,14.58 387.12,14.44 387.12,13.57 386.99,13.43 385.37,13.43 385.3,13.5 385.3,14.42 385.4,14.52 385.73,14.52 385.79,14.58 386.19,14.58 386.2,14.6 386.2,15.13 386.21,15.13 386.4,15.13
GND on TOP (solid shape): 392.88,57.16 392.88,55.51 392.5,55.13 390.52,55.13 390.26,55.25 390,55.13 389.24,55.13 389.07,55.3 389.07,57.67 389.33,57.93 392.12,57.93
GND on TOP (solid shape): 101.7,10.42 101.7,9 101.67,8.97 101.67,1.93 101.5,1.76 97.65,1.76 97.47,1.95 97.47,3.36 96.87,3.95 96.87,7.18 97.07,7.38 98.3,7.38 100.07,9.15 100.07,10.54 100.22,10.68 101.44,10.68
GND on TOP (solid shape): 301.57,72.81 301.62,72.81 302.44,72.81 302.51,72.81 303.17,72.81 303.22,72.76 303.22,72.05 302.96,71.78 302.96,68.96 302.59,68.59 300.81,68.59 300.78,68.62 300.78,72.25 301.34,72.81
GND on TOP (solid shape): 386.51,12.06 386.78,11.79 386.78,10.33 386.69,10.24 386.14,10.24 386.02,10.36 386.02,11.05 385.96,11.11 384.36,11.11 384.2,10.95 384.2,10.34 384.1,10.24 382.89,10.24 382.88,10.23 382.8,10.32 382.8,11.07 383.79,12.06 383.8,12.06 384.04,12.3 386.22,12.3
GND on TOP (solid shape): 101.57,20.82 101.57,20.16 101.42,20 100.67,20 100.52,19.85 100.52,17.79 101.17,17.15 101.17,15.65 101.07,15.56 100.36,15.56 100.35,15.55 99.37,15.55 99.18,15.75 99.18,18.12 99.09,18.21 98.84,18.21 98.55,18.5 98.55,18.77 98.64,18.86 99.47,18.86 99.59,18.98 99.59,20.65 99.91,20.97 101.43,20.97
GND on TOP (solid shape): 118.73,51.99 118.73,51.2 118.58,51.05 118.58,49.33 118.46,49.21 117.89,49.21 117.75,49.34 117.75,49.55 117.56,49.74 117.39,49.74 117.37,49.75 117.3,49.77 117.23,49.78 117.21,49.78 117.11,49.88 117.11,50.52 117.83,51.23 117.83,52.01 117.89,52.08 118.64,52.08
GND on TOP (solid shape): 120.22,114.82 120.62,114.82 121.33,114.12 121.29,114.07 121.21,113.79 121.38,113.54 121.41,113.52 121.41,109.77 121.33,109.69 118.74,109.69 117.68,110.76 117.68,114.31 118.18,114.82 120.22,114.82
GND on TOP (solid shape): 126.66,114.99 126.66,114.14 126.06,113.54 126.06,111.27 125.7,110.92 124.64,110.92 124.28,111.27 124.28,112.33 123.99,112.62 123.98,112.64 123.76,112.99 123.37,113.12 123.17,113.12 123.03,113.26 123.03,113.98 124.42,115.38 126.27,115.38
GND on TOP (solid shape): 353.9,42.71 355.69,42.71 356.1,42.3 356.93,42.3 357,42.23 357,42.06 356.92,41.98 355.87,41.98 355.51,41.63 354.34,41.63 353.91,42.05 352.63,42.05 351.74,41.16 349.96,41.16 349.33,40.54 349.33,39.88 348.63,39.17 345.83,39.17 345.13,39.88 345.13,42.18 345.39,42.43 348.94,42.43 349.29,42.78 353.83,42.78
GND on TOP (solid shape): 262.76,93.66 262.76,92.27 262.63,92.14 261.24,92.14 261.15,92.23 261.11,92.31 261.14,92.4 261.2,92.73 260.98,92.96 260.93,92.98 260.93,94.1 260.98,94.15 262.28,94.15
GND on TOP (solid shape): 6.37,68.52 6.37,68.51 6.61,68.24 6.94,68.36 8.03,68.36 8.42,67.96 8.42,66.37 8.18,66.13 6.02,66.13 5.65,66.5 5.65,67.66 5.53,67.78 5.53,68.54 5.61,68.61 6.05,68.61 6.06,68.62 6.26,68.62
GND on TOP (solid shape): 122.53,49.44 123.19,48.78 123.25,48.78 123.44,48.59 123.44,48.3 123.64,48.1 123.64,47.71 123.64,47.7 123.62,47.59 123.64,47.48 123.64,47.47 123.64,47.41 123.61,47.38 123.6,47.38 123.52,47.32 123.47,47.24 123.46,47.23 123.26,47.03 122.82,47.03 122.15,47.7 122.15,48.5 121.82,48.83 121.82,49.39 121.89,49.47 122.53,49.47
GND on TOP (solid shape): 128.13,161.3 128.48,160.96 128.84,161.3 130.12,161.3 130.38,161.05 130.38,157.86 130.01,157.49 127.71,157.49 127.45,157.75 127.45,161.18 127.58,161.3
GND on TOP (solid shape): 158.63,94.09 158.63,93.78 158.56,93.71 157.63,93.71 157.63,93.08 157.62,93.07 157.62,92.64 157.63,92.64 157.63,92.17 157.83,91.96 158.54,91.96 158.55,91.96 158.68,91.96 158.85,91.79 158.85,89.45 158.7,89.3 156.87,89.3 156.61,89.55 156.61,91.66 156.31,91.96 155.78,91.96 155.62,92.12 155.62,92.5 155.67,92.55 156.41,92.55 156.64,92.78 156.64,93.76 156.64,94.04 156.79,94.2 158.52,94.2
GND on TOP (solid shape): 6.37,52.31 6.37,52.3 6.61,52.02 6.95,52.16 6.97,52.19 7.33,52.19 7.4,52.17 7.45,52.17 7.93,52.17 8.03,52.06 8.03,50.12 7.75,49.85 5.98,49.85 5.66,50.16 5.66,51.4 5.45,51.61 5.45,52.24 5.62,52.42 6.24,52.42
GND on TOP (solid shape): 292.05,42.43 292.05,42.03 291.92,41.9 291.28,41.9 290.5,41.11 287.81,41.11 287.47,40.78 287.47,39.64 287.86,39.26 287.86,36.39 288.01,36.23 289.43,36.23 289.51,36.15 289.51,34.77 289.3,34.56 288.18,34.56 287.87,34.87 287.87,35.14 287.8,35.21 287.08,35.21 286.97,35.09 286.97,34.81 286.84,34.69 285.95,34.69 285.82,34.81 285.82,38.37 284.55,39.64 280.87,39.64 280.49,40.02 280.49,41.92 280.66,42.09 286.43,42.09 286.89,42.56 291.92,42.56
GND on TOP (solid shape): 116.34,18.33 116.34,18.29 116.38,18.25 116.38,17.72 116.23,17.56 116.21,17.33 116.22,17.3 116.09,17.17 113.72,17.17 113.29,16.74 111.86,16.74 111.86,16.8 111.79,16.96 111.66,17.07 111.63,17.09 111.63,17.4 112.03,17.4 112.36,17.74 113.35,17.74 113.47,17.85 113.5,17.85 113.5,17.88 113.57,17.95 113.57,18.33 114.01,18.77 115.89,18.77
GND on TOP (solid shape): 292.76,21.73 292.76,21.22 292.94,21.05 293.88,21.05 294.05,20.87 294.05,20.44 293.8,20.18 288.09,20.18 287.95,20.04 287.95,15.67 288.13,15.49 289.24,15.49 289.43,15.3 289.43,13.92 289.3,13.8 288.14,13.8 287.99,13.95 287.99,14.49 287.81,14.67 287.24,14.67 287.03,14.46 287.03,14.44 287.05,14.42 287.05,14.02 286.86,13.83 285.94,13.83 285.83,13.94 285.83,17.66 284.17,19.32 281.51,19.32 281.31,19.52 281.31,21.05 281.79,21.54 287.49,21.54 287.76,21.81 292.68,21.81
GND on TOP (solid shape): 8.13,59.82 8.13,57.48 7.95,57.3 7.12,57.3 7.06,57.36 7.06,57.48 6.99,57.55 7,57.58 6.71,57.92 6.36,57.63 6.36,57.58 6.35,57.57 6.3,57.57 6.29,57.56 5.58,57.56 5.42,57.72 5.42,58.43 5.72,58.72 5.72,59.76 6.27,60.32 7.63,60.32
GND on TOP (solid shape): 8.22,76.4 8.22,73.74 7.98,73.49 7.19,73.49 7.09,73.59 7.09,73.72 7,73.82 6.99,73.84 6.64,74.08 6.36,73.75 6.36,73.75 5.64,73.75 5.49,73.9 5.49,74.53 5.49,74.58 5.5,74.65 5.62,74.77 5.62,75.64 6.45,76.47 8.15,76.47
GND on TOP (solid shape): 93.95,60.26 93.95,58.56 93.77,58.38 93.77,58.29 93.77,58.28 93.74,58.17 93.77,58.06 93.77,58.05 93.77,57.79 93.77,57.78 93.74,57.67 93.77,57.56 93.77,57.55 93.77,57.38 93.71,57.31 93.71,56.62 93.65,56.56 92.78,56.56 92.66,56.68 92.66,57.77 92.43,58 91.89,58 91.87,57.98 91.77,57.98 91.62,58.13 91.62,58.33 91.69,58.41 92.02,58.41 92.45,58.84 92.45,60.09 92.89,60.52 93.7,60.52
GND on TOP (solid shape): 138.78,117.37 140.61,117.37 140.89,117.09 140.89,115.02 140.79,114.92 140.17,114.92 139.74,115.34 138.26,115.34 138.02,115.11 136.9,115.11 136.41,114.62 136.41,113.68 136.39,113.65 136.39,112.02 135.96,111.59 135.96,110.55 135.91,110.51 135.91,109.62 135.78,109.49 135.2,109.49 135.07,109.62 135.07,110.02 135.33,110.28 135.48,110.28 135.67,110.47 135.67,111.36 135.25,111.78 135.25,113 135.27,113 135.67,113.4 135.67,115.43 135.67,115.43 135.67,118.06 136.23,118.62 137.53,118.62
GND on TOP (solid shape): 139.76,16.06 139.76,13.97 139.96,13.78 140.92,13.78 141.17,13.53 141.97,13.53 142.01,13.57 142.01,14.27 142.09,14.35 143.02,14.35 143.51,13.87 143.51,12.77 143.15,12.41 139.22,12.41 138.96,12.67 139.15,13.1 138.75,13.35 138.72,13.35 138.72,16.06 138.78,16.12 139.7,16.12
GND on TOP (solid shape): 291.92,52.03 291.92,51.6 291.69,51.37 291.1,51.37 290.27,50.54 287.29,50.54 287.09,50.34 287.09,49.27 287.88,48.48 287.88,46.14 288.1,45.92 289.21,45.92 289.41,45.73 289.41,44.44 289.2,44.24 288.14,44.24 287.73,44.64 287.73,44.94 287.58,45.1 287.16,45.1 286.99,44.93 286.99,44.44 286.92,44.36 285.9,44.36 285.77,44.49 285.77,47.97 284.88,48.86 284.25,48.86 283.82,49.29 280.24,49.29 279.98,49.54 279.98,51.23 280.6,51.85 286.25,51.85 286.55,52.15 288.56,52.15 288.81,51.9 289.27,51.9 289.86,52.49 291.46,52.49
GND on TOP (solid shape): 144.82,60.31 144.82,59.03 144.75,58.97 143.6,58.97 143.22,58.59 143.22,51.92 143.13,51.83 141.96,51.83 141.84,51.94 141.74,51.94 141.6,51.97 141.47,51.94 140.67,51.94 140.4,52.21 140.4,52.66 140.55,52.81 141.3,52.81 141.68,53.19 141.68,59.68 141.43,59.94 137.6,59.94 137.34,59.68 137.34,55.16 137.58,54.92 138.11,54.92 138.32,54.71 138.32,53.13 138.65,52.8 139.47,52.8 139.47,51.97 139.32,51.81 136.13,51.81 135.56,52.38 135.56,58.73 135.24,59.05 135.24,61.03 135.44,61.23 143.9,61.23
GND on TOP (solid shape): 128.96,86.05 128.96,85.3 129.3,84.96 129.65,84.96 130.08,84.53 130.08,83.93 130.04,83.93 130.04,83.2 130,83.16 129.29,83.16 129.26,83.14 129.12,83.14 129.12,82.83 128.82,82.52 127.69,82.52 127.68,82.53 127.58,82.54 127.48,82.53 127.47,82.52 127.01,82.52 126.3,83.24 126.32,83.28 126.25,83.68 125.84,83.75 125.8,83.73 125.72,83.82 125.72,86.85 128.15,86.85
GND on TOP (solid shape): 179.6,45.05 179.6,44.71 179.92,44.39 180.06,44.39 180.18,44.31 180.15,44.17 179.96,43.98 179.33,43.98 179.23,44.04 179.22,44.17 179.19,44.51 178.87,44.62 178.84,44.61 178.61,44.84 178.61,44.89 178.65,44.93 179.06,44.93 179.23,45.1 179.55,45.1
GND on TOP (solid shape): 320.67,7.08 320.75,7 321.5,7 321.59,6.91 323.41,6.91 323.78,6.53 324.64,6.53 324.73,6.44 324.73,6.24 324.68,6.19 323.84,6.19 323.43,5.78 321.92,5.78 321.73,5.97 321.73,5.98 321.66,6.08 321.56,6.15 321.55,6.15 321.46,6.24 320.49,6.24 319.93,5.67 319.93,5.64 319.49,5.2 317.77,5.2 317.24,4.68 317.24,3.13 316.4,2.28 313.08,2.28 312.77,2.59 312.77,6.65 313.11,6.99 313.91,6.99 313.91,6.98 314.58,6.98 314.6,7 316.55,7 316.55,6.99 316.68,7.13 320.62,7.13
GND on TOP (solid shape): 287.53,33.35 287.53,33.3 287.56,32.97 287.86,32.81 287.86,32.4 288.24,32.02 288.24,28.59 287.86,28.21 287.86,25.36 288.08,25.14 289.08,25.14 289.09,25.14 289.23,25.14 289.37,25 289.37,23.6 289.3,23.53 288.1,23.53 287.85,23.78 287.85,24.27 287.74,24.37 287.04,24.37 286.97,24.3 286.97,23.79 286.81,23.64 285.9,23.64 285.67,23.87 285.67,28.01 284.71,28.97 280.74,28.97 280.49,29.22 280.49,31.64 280.74,31.89 285.65,31.89 287.16,33.4 287.48,33.4
GND on TOP (solid shape): 180.02,41.33 180.02,40.88 180.27,40.62 180.3,40.62 180.42,40.55 180.39,40.41 179.75,39.77 179.44,39.77 179.34,39.82 179.32,39.93 179.26,40.23 178.97,40.34 178.94,40.34 178.63,40.65 178.63,40.72 178.81,40.9 178.88,40.9 179.17,40.62 179.52,40.62 179.77,40.86 179.77,41.34 179.79,41.36 179.99,41.36
GND on TOP (solid shape): 57.73,26.43 57.73,25.67 57.4,25.33 56.84,25.33 56.83,25.34 56.69,25.36 56.56,25.34 56.54,25.33 55.2,25.33 55.19,25.34 55.03,25.38 54.87,25.34 54.85,25.33 54.79,25.33 54.77,25.38 54.75,25.44 54.7,25.5 54.47,25.73 54.43,25.73 54.43,25.88 54.45,25.89 54.51,26.01 54.53,26.14 54.58,26.38 54.47,26.59 54.56,26.68 57.48,26.68
GND on TOP (solid shape): 179.83,28.22 179.97,28.25 180.05,28.13 180.05,27.83 179.04,26.82 178.6,26.82 178.45,26.97 178.45,27.23 178.53,27.31 178.58,27.27 179.01,27.25 179.05,27.69 179.04,27.82 179.15,27.89 179.5,27.89
GND on TOP (solid shape): 193.5,48.59 193.5,48.53 193.48,48.51 193.39,48.37 193.39,48.2 193.37,48.09 193.27,48.04 192.92,48.04 192.13,47.24 192.03,47.24 191.94,47.34 191.94,47.47 192.39,47.93 192.42,47.93 192.73,48.12 192.66,48.47 192.63,48.61 192.75,48.69 193.41,48.69
GND on TOP (solid shape): 180.11,42.38 180.21,42.33 180.23,42.21 180.37,41.82 180.78,41.91 180.87,41.82 180.87,41.72 180.55,41.4 180.55,41.01 180.49,40.95 180.41,40.95 180.35,41.01 180.35,41.47 180.13,41.69 179.66,41.69 179.44,41.48 179.44,41 179.38,40.95 179.3,40.95 179.02,41.23 178.8,41.23 178.69,41.31 178.71,41.45 179.65,42.38
GND on TOP (solid shape): 190.36,40.36 190.47,40.29 190.45,40.15 190.38,39.9 190.53,39.67 190.53,39.14 190.44,39.06 190.3,39.03 190.22,39.15 190.22,39.39 189.98,39.63 189.87,39.63 189.76,39.69 189.75,39.82 189.78,40.05 189.64,40.24 189.64,40.36
GND on TOP (solid shape): 172.46,53.97 172.59,54.01 172.68,53.92 172.77,53.76 172.95,53.7 174.01,53.7 174.02,53.69 174.02,53.56 173.93,53.46 173.6,53.46 173.27,53.13 173.27,52.68 173.6,52.35 174.13,52.35 174.18,52.4 174.25,52.41 174.29,52.35 174.29,51.86 174.19,51.76 172.95,51.76 172.72,51.65 172.66,51.28 172.56,51.23 172.39,51.23 172.39,53.9
GND on TOP (solid shape): 175.52,48.36 175.62,48.31 175.65,48.2 175.82,47.83 176.21,47.93 176.31,47.99 176.42,47.94 176.53,47.84 176.68,47.81 176.71,47.81 176.93,47.59 177.19,47.59 177.21,47.57 177.21,47.38 177.13,47.3 176.97,47.3 176.67,47.6 176.18,47.6 175.88,47.3 175.75,47.3 175.46,47.6 174.93,47.6 174.87,47.63 174.88,47.7 174.94,47.77 174.94,48.09 175.22,48.36
GND on TOP (solid shape): 289.94,72.94 289.94,72.38 289.81,72.24 289.1,72.24 288.99,72.13 288.33,71.47 285.28,71.47 285.28,70.05 285.57,69.76 285.82,69.76 285.84,69.75 285.96,69.63 285.96,67.04 286.05,66.95 286.05,66.94 286.25,66.74 286.26,66.74 286.34,66.66 287.38,66.66 287.53,66.52 287.53,65.15 287.36,64.99 286.34,64.99 286.16,64.8 286.16,64.73 286.14,64.69 286.14,64.65 286.14,64.1 286.07,64.03 285.81,64.03 285.7,64.13 285.7,64.24 285.7,64.65 285.7,64.72 285.78,64.8 285.78,65.68 285.74,65.73 285.15,65.73 285.12,65.69 285.12,64.99 285.05,64.93 284.08,64.93 283.88,65.12 283.88,68.84 283.64,69.08 279.27,69.08 279.14,69.2 279.14,71.02 280.25,72.12 280.41,72.22 280.5,72.38 280.58,72.45 283.8,72.45 284.5,73.15 289.73,73.15
GND on TOP (solid shape): 193.4,72.03 193.34,71.98 193.33,71.97 193.12,71.7 193.27,71.4 193.27,70.76 193.21,70.65 193.08,70.65 193.05,70.66 193,70.68 192.71,70.97 192.06,70.97 191.94,71.05 191.97,71.19 192.14,71.36 192.17,71.36 192.5,71.52 192.45,71.89 192.43,72.02 192.54,72.1 193.33,72.1
GND on TOP (solid shape): 129.88,72.35 129.88,71.41 130.08,71.2 130.08,70.45 130.02,70.39 128.32,70.39 128.32,70.45 128.12,70.77 127.75,70.73 127.7,70.7 127.66,70.74 127.58,70.74 127.45,70.87 127.45,71.02 127.56,71.06 128.16,71.26 127.64,71.63 127.51,71.63 127.45,71.74 127.45,72.36 127.53,72.44 129.79,72.44
GND on TOP (solid shape): 135.76,15.91 135.81,15.84 135.88,15.79 135.91,15.77 135.91,15.46 135.91,15.46 135.91,15.28 135.79,15.15 135.45,15.15 135.23,15.23 135.01,15.15 134.74,15.15 134.21,15.06 134.38,14.55 134.38,13.51 134.47,13.07 134.92,13.07 134.96,13.11 135.55,12.52 136.24,12.52 136.73,12.03 136.73,9.13 136.25,8.65 132.94,8.65 132.68,8.92 132.68,15.84 132.75,15.91
GND on TOP (solid shape): 157.88,80.37 157.99,80.31 158,80.18 158.32,79.67 158.64,80.18 158.64,80.31 158.75,80.37 160.21,80.37 160.29,80.29 160.27,80.25 160.29,79.93 160.56,79.76 160.64,79.72 160.67,79.63 160.67,78.81 160.53,78.68 157.77,78.68 157.56,78.89 157.56,80.08 157.84,80.37
GND on TOP (solid shape): 143.48,95.07 143.48,91.39 142,89.91 137.34,89.91 137.28,89.96 137.28,92.23 139.23,92.23 139.24,92.15 139.25,92.07 139.28,92 139.31,91.92 139.34,91.85 139.38,91.78 139.43,91.72 139.49,91.66 139.55,91.61 139.62,91.57 139.69,91.53 139.76,91.5 139.84,91.47 139.92,91.46 140,91.45 140.07,91.45 140.15,91.46 140.23,91.47 140.31,91.5 140.38,91.53 140.45,91.57 140.52,91.61 140.58,91.66 140.64,91.72 140.69,91.78 140.73,91.85 140.77,91.92 140.79,92 140.82,92.07 140.83,92.15 140.84,92.23 140.83,92.31 140.82,92.39 140.81,92.47 140.78,92.54 140.75,92.62 140.71,92.68 140.66,92.75 140.61,92.81 140.55,92.86 140.49,92.91 140.42,92.95 140.35,92.99 140.27,93.02 140.19,93.04 140.11,93.05 140.04,93.05 139.96,93.05 139.88,93.04 139.8,93.02 139.72,92.99 139.65,92.95 139.58,92.91 139.52,92.86 139.46,92.81 139.41,92.75 139.36,92.68 139.32,92.62 139.29,92.54 139.26,92.47 139.25,92.39 139.24,92.31 139.23,92.23 137.28,92.23 137.28,94.14 137.44,94.29 139.06,94.29 140.87,96.1 142.45,96.1
GND on TOP (solid shape): 175.81,41.95 175.91,41.92 176.02,41.85 176.15,41.82 176.17,41.83 176.59,41.41 177.08,41.41 177.18,41.35 177.2,41.24 177.18,41.11 177.22,40.99 177.21,40.87 177.1,40.81 176.83,40.81 176.48,41.16 176.47,41.18 176.15,41.4 175.86,41.13 175.85,41.08 175.49,41.08 175.15,40.73 175.05,40.73 174.98,40.8 174.98,40.88 175.46,41.36 175.46,41.77 175.51,41.78 175.63,41.82 175.72,41.9
GND on TOP (solid shape): 44.72,21.43 44.74,21.41 44.78,21.37 44.82,21.34 44.87,21.31 44.91,21.3 45.06,21.15 45.06,19.91 44.54,19.4 43.9,19.4 43.75,19.24 43.24,19.24 43.08,19.08 43.08,18.11 43.23,17.96 43.39,17.96 43.63,17.72 43.63,17.34 42.81,17.34 42.77,17.38 42.77,17.53 42.7,17.6 41.57,17.6 41.32,17.85 41.32,19.38 41.25,19.46 40.7,19.46 40.59,19.57 40.59,20.08 40.66,20.16 43.43,20.16 43.43,20.13 43.44,20.08 43.46,20.03 43.48,19.98 43.51,19.93 43.54,19.9 43.59,19.86 43.63,19.84 43.68,19.82 43.73,19.8 43.79,19.8 43.84,19.8 43.89,19.82 43.94,19.84 43.99,19.86 44.03,19.9 44.07,19.93 44.1,19.98 44.12,20.03 44.14,20.08 44.14,20.13 44.14,20.18 44.14,20.24 44.12,20.29 44.1,20.34 44.07,20.38 44.03,20.42 43.99,20.45 43.94,20.48 43.89,20.5 43.84,20.51 43.79,20.51 43.73,20.51 43.68,20.5 43.63,20.48 43.59,20.45 43.54,20.42 43.51,20.38 43.48,20.34 43.46,20.29 43.44,20.24 43.43,20.18 43.43,20.16 40.66,20.16 41.37,20.87 42.26,20.87 42.57,21.17 44.07,21.17 44.32,21.43
GND on TOP (solid shape): 191.94,41.45 192.04,41.4 192.05,41.28 192.05,41.07 192.19,40.9 192.19,40.86 192.24,40.8 192.25,40.74 192.2,40.7 189.83,40.7 189.7,40.83 189.76,40.89 189.79,40.89 189.91,40.92 190.01,40.99 190.11,41.03 190.2,40.99 190.43,40.88 190.66,40.97 190.75,41.01 190.84,40.97 191.21,40.9 191.39,41.23 191.39,41.26 191.58,41.45
GND on TOP (solid shape): 141.89,22.38 142.02,22.35 142.15,22.38 142.61,22.38 142.62,22.37 142.74,22.35 142.85,22.37 142.86,22.38 143.2,22.38 143.21,22.33 143.38,22.15 143.64,22.14 143.67,22.16 143.94,21.9 143.94,21.2 143.93,21.19 143.9,21.03 143.93,20.88 143.94,20.87 143.94,20.74 143.86,20.74 143.85,20.75 143.39,20.5 143.78,20.15 143.81,20.16 143.84,20.15 143.84,18.81 143.71,18.68 142.58,18.68 142.45,18.81 142.45,19.88 142,20.33 140.47,20.33 140.38,20.42 140.38,20.9 140.5,21.02 141.01,21.02 141.01,21.24 141.13,21.24 141.52,21.62 141.52,22.25 141.65,22.38
GND on TOP (solid shape): outline of 100 points within 64.79,42.68 69.66,45.03
GND on TOP (solid shape): 291.45,63.06 291.46,63.06 291.5,63.02 291.5,62.41 291.38,62.28 290.4,62.28 290.39,62.27 290.37,62.27 290.14,62.04 287.13,62.04 286.56,61.47 286.56,61.25 286.51,61.21 286.51,60.26 286.56,60.21 286.56,60.05 286.86,59.75 287.49,59.75 287.83,59.41 287.83,57 287.86,56.97 287.86,56.93 288.06,56.73 288.09,56.73 288.16,56.67 289.22,56.67 289.34,56.54 289.34,55.1 289.13,54.89 289.09,54.87 288.91,54.87 288.75,54.92 288.59,54.87 288.41,54.87 288.26,54.92 288.1,54.87 288.09,54.87 288.02,54.87 288.02,54.8 288.02,54.79 287.98,54.72 287.97,54.64 287.97,54.07 287.97,53.5 287.78,53.3 287.29,53.3 287.22,53.37 287.22,53.89 287.29,53.95 287.31,53.96 287.45,54.03 287.52,54.18 287.53,54.19 287.53,54.76 287.57,54.81 287.58,54.81 287.64,54.87 287.64,55.65 287.57,55.72 286.98,55.72 286.94,55.68 286.94,55.1 286.85,55.02 286.82,55.06 285.79,55.06 285.67,55.18 285.67,58.85 285.18,59.35 278.81,59.35 278.46,59.7 278.46,62.17 278.74,62.45 286.27,62.45 286.99,63.16 291.35,63.16
GND on TOP (solid shape): outline of 108 points within 125.73,6.92 132.4,13.9
GND on TOP (solid shape): 190.43,65.36 190.53,65.43 190.64,65.38 190.7,65.33 190.77,65.28 191.43,64.62 193.22,64.62 193.58,64.26 193.6,64.12 193.49,64.04 193.22,64.04 192.82,63.63 192.72,63.63 192.53,63.83 192.52,63.83 192.47,63.86 192.47,63.93 192.45,64.32 192.07,64.4 192.05,64.39 191.84,64.39 191.78,64.33 191.69,64.29 191.6,64.33 191.1,64.27 191.29,63.8 191.34,63.79 191.34,63.6 191.58,63.36 191.61,63.22 191.49,63.14 191.13,63.14 190.25,64.02 190.25,64.05 190.21,64.27 190.03,64.4 189.95,64.49 189.98,64.61 190.11,64.75
GND on TOP (solid shape): 408.12,15.76 408.15,15.76 408.15,10.3 408.13,10.1 408.1,9.9 407.47,8.89 406.35,8.5 398.86,8.5 397.3,7.86 396.66,6.3 396.66,2 396.13,0.73 394.86,0.2 391.36,0.2 390.95,0.37 390.5,0.57 389.96,1.08 389.61,1.77 389.41,2.07 389.33,2.12 388.54,2.28 388.03,2.12 387.53,1.56 385.81,1.54 385.81,5.61 386.44,5.61 386.96,5.09 391.01,5.09 392.25,4.73 393.49,5.09 394.94,5.09 396.15,6.3 396.94,8.22 398.86,9.01 406.1,9.01 407.65,10.56 407.65,15.79 408.12,15.79
GND on TOP (solid shape): 189.07,54.56 190.7,54.56 190.92,54.34 191.15,54.34 191.29,54.21 191.28,54.18 191.55,53.85 191.9,54.07 192,54.15 192.12,54.12 192.25,53.98 194.37,53.98 194.46,54.07 194.56,54.11 194.65,54.06 194.68,53.98 194.65,53.9 194.61,53.83 194.59,53.75 194.59,53.72 194.47,53.6 194.47,53.04 194.78,52.73 194.92,52.73 194.92,52.36 194.13,52.36 194.02,52.47 194.02,53.06 193.83,53.63 193.64,53.06 193.64,52.32 193.97,51.98 194.92,51.98 194.92,51.74 194.84,51.62 194.7,51.65 194.5,51.85 192.83,51.85 191.94,52.74 189.59,52.74 189.47,52.82 189.5,52.96 189.63,53.1 192.32,53.1 192.89,53.29 192.32,53.49 189.47,53.49 188.31,52.33 188.31,52.07 188,51.75 187.28,51.75 187.17,51.81 187.16,51.93 187.18,52.09 187.12,52.24 187.12,53.04 188.1,53.04 188.94,53.88 190.12,53.88 190.69,54.07 190.12,54.27 188.78,54.27 188.57,54.07 188.46,54.03 188.37,54.1 188.34,54.15 188.47,54.27 188.47,54.63 188.43,54.67 188.41,54.74 188.47,54.78 188.85,54.78
GND on TOP (solid shape): outline of 113 points within 176.18,51.07 185.27,56.25
GND on TOP (solid shape): outline of 112 points within 189.39,41.38 193.27,47.45
GND on TOP (solid shape): outline of 130 points within 188.31,47.55 194.68,52.36
GND on TOP (solid shape): outline of 97 points within 152.9,28.32 408.16,176.9
GND on TOP (solid shape): outline of 545 points within 174.57,41.8 180.95,53.83
GND on TOP (solid shape): outline of 240 points within 0.2,0.2 364.2,177.9
GND on TOP (solid shape): outline of 2075 points within 130.27,30.88 142.09,41.77
GND on TOP (solid shape): outline of 7585 points within 172.39,55.49 199.22,84.47
GND on TOP (solid shape): outline of 7763 points within 172.39,15.07 199.22,43.39
GND on BOTTOM (solid shape): 105.79,19.19 105.79,18.16 105.14,17.51 102.13,17.51 101.84,17.8 101.84,19.59 105.39,19.59
GND on BOTTOM (solid shape): 28.45,33.15 34.1,33.15 34.1,41.25 34.7,41.25 34.7,32.55 27.85,32.55 27.85,41.25 28.45,41.25
GND on BOTTOM (solid shape): 44.68,2.91 44.68,1.97 44.17,1.46 39.77,1.46 39.32,1.92 39.32,3.09 39.77,3.55 44.04,3.55
GND on BOTTOM (solid shape): 51.71,40.88 51.71,39.36 51.46,39.11 49.02,39.11 48.77,39.36 48.77,40.96 48.84,41.04 51.56,41.04
GND on BOTTOM (solid shape): 52.27,56.15 52.27,55.26 52.14,55.13 50.49,55.13 50.2,55.42 50.2,56.21 50.4,56.4 52.02,56.4
GND on BOTTOM (solid shape): 122,98.24 122,95.95 121.43,95.38 118.98,95.38 118.89,95.47 118.89,98.08 119.21,98.41 121.84,98.41
GND on BOTTOM (solid shape): 168.73,156.73 168.73,154.27 168.35,153.89 167,153.89 166.44,154.45 166.44,156.73 166.57,156.86 168.6,156.86
GND on BOTTOM (solid shape): 191.34,91.29 191.34,89.84 191.04,89.54 186.06,89.54 185.58,90.03 185.58,91.29 185.75,91.46 191.17,91.46
GND on BOTTOM (solid shape): 270.33,44.08 270.33,42.96 270.05,42.68 267.71,42.68 267.58,42.81 267.58,44.23 267.69,44.34 270.07,44.34
GND on BOTTOM (solid shape): 270.45,48.63 270.45,47.56 270.05,47.16 267.96,47.16 267.67,47.44 267.67,48.72 267.82,48.87 270.22,48.87
GND on BOTTOM (solid shape): 272.37,28.87 272.37,27.38 271.68,26.69 271.07,26.69 266.4,31.36 266.4,32.15 267.16,32.91 268.33,32.91
GND on BOTTOM (solid shape): 307.07,16.66 307.07,13.31 306.88,13.12 304.06,13.12 303.94,13.24 303.94,16.94 304.09,17.08 306.65,17.08
GND on BOTTOM (solid shape): 317.95,72.02 317.95,69.61 317.32,68.98 313.38,68.98 312.87,69.48 312.87,72.4 313.76,73.29 316.68,73.29
GND on BOTTOM (solid shape): 354.97,6.34 354.97,3.6 354.21,2.84 351.7,2.84 351.49,3.05 351.49,6.8 351.81,7.13 354.19,7.13
GND on BOTTOM (solid shape): 67.25,0 59.25,0 59.25,2.1 59.25,6.6 67.25,6.6
GND on BOTTOM (solid shape): 159.08,91.71 159.08,89.56 158.69,89.17 155.01,89.17 154.89,89.3 154.89,92.09 155.27,92.47 158.32,92.47
GND on BOTTOM (solid shape): 161.44,80.08 161.44,79.04 161.23,78.84 158.79,78.84 158.72,78.9 158.72,79.59 158.71,79.59 158.71,80.35 159.03,80.67 160.84,80.67
GND on BOTTOM (solid shape): 162.51,37.43 162.51,36.2 162.22,35.91 162.22,35.21 162.03,35.01 161.28,35.01 160.98,35.31 160.98,37.36 161.13,37.51 162.43,37.51
GND on BOTTOM (solid shape): 201.45,17.44 205.66,17.44 207.13,15.97 207.13,13.05 206.68,12.59 200.71,12.59 200.63,12.66 200.63,17.19 200.91,17.46 201.42,17.46
GND on BOTTOM (solid shape): 253.31,56.45 253.31,56.17 253.06,55.92 251.23,55.92 251.17,55.98 251.17,56.39 251.26,56.48 252.93,56.48 252.98,56.53 253.24,56.53
GND on BOTTOM (solid shape): 270.33,53.15 270.33,51.83 270.25,51.75 267,51.75 266.74,52.01 266.74,53.18 266.82,53.27 270.22,53.27
GND on BOTTOM (solid shape): 271.09,17.29 271.09,12.84 270.71,12.46 268.35,12.46 268.2,12.61 268.2,16.22 268.3,16.32 268.3,17.29 268.81,17.79 270.58,17.79
GND on BOTTOM (solid shape): 280.23,58.4 280.23,54.6 279.81,54.18 278.17,54.18 277.6,54.74 277.6,58.42 277.98,58.8 279.84,58.8
GND on BOTTOM (solid shape): 332.05,39.51 332.05,37.73 331.42,37.1 329.56,37.1 329.26,37.4 329.26,39.77 329.64,40.15 331.42,40.15
GND on BOTTOM (solid shape): 332.3,53.27 332.3,50.96 332.19,50.85 330.34,50.85 330.3,50.88 330.3,53.32 330.49,53.51 332.06,53.51
GND on BOTTOM (solid shape): 57.67,53.99 57.67,45.45 57.63,45.41 53.92,45.41 53.88,45.45 53.88,46.75 53.88,46.9 53.88,53.98 53.96,54.06 57.61,54.06
GND on BOTTOM (solid shape): 179.02,90.79 179.02,87.12 178.89,86.98 178.05,86.98 177.79,87.24 177.79,90.89 177.85,90.95 178.86,90.95
GND on BOTTOM (solid shape): 315.97,59.04 315.97,57.47 315.69,57.19 314.27,57.19 314.08,57.39 312.32,57.39 311.78,57.93 311.78,59.22 312.52,59.96 315.06,59.96
GND on BOTTOM (solid shape): 14.9,18.28 14.9,17.77 14.85,17.72 13.84,17.72 13.5,18.06 13.5,18.43 13.23,18.69 12.95,18.69 12.83,18.82 12.83,19.09 12.89,19.15 14.03,19.15
GND on BOTTOM (solid shape): 78.15,13.48 78.15,12.16 77.62,11.62 77.62,9.68 76.72,8.78 71.37,8.78 71.17,8.98 71.17,10 72.16,10.99 72.16,13.55 72.84,14.24 77.39,14.24
GND on BOTTOM (solid shape): 270.38,56.98 270.38,55.73 270.25,55.6 267.09,55.6 266.74,55.96 266.74,57.1 266.86,57.23 270.14,57.23
GND on BOTTOM (solid shape): 274,72.28 274.83,72.28 274.96,72.15 274.96,71.41 274.75,71.2 272.09,71.2 271.52,71.76 271.52,72.48 271.71,72.67 273.61,72.67
GND on BOTTOM (solid shape): 333.42,31.25 333.42,30.35 332.98,29.91 332.46,29.91 331.93,30.45 330.6,30.45 330.43,30.62 330.43,32.86 330.32,32.96 330.32,33.61 330.37,33.65 331.02,33.65
GND on BOTTOM (solid shape): 96.23,51.18 96.23,46.51 95.83,46.12 95.07,46.12 94.84,46.34 85.72,46.34 85.42,46.65 85.42,47.79 86.43,48.81 86.43,51.7 86.55,51.82 95.59,51.82
GND on BOTTOM (solid shape): 121.61,87.07 122,87.07 122,86.66 122.04,86.62 122.04,85.63 121.14,84.73 118.96,84.73 118.67,85.02 118.67,86.78 118.77,86.88 121.31,86.88 121.51,87.07 121.6,87.07
GND on BOTTOM (solid shape): 332.13,59.13 332.13,56.67 332.02,56.56 330.56,56.56 330.41,56.42 330.41,56 330.34,55.92 329.71,55.92 329.64,56 329.64,59.09 329.88,59.33 331.94,59.33
GND on BOTTOM (solid shape): 72.99,53.25 76.33,53.25 76.38,53.31 77.81,53.31 78.27,52.84 78.27,52.12 78.01,51.86 69.4,51.86 68.31,52.95 68.31,53.93 68.41,54.03 69.53,54.03 69.67,54.17 72.07,54.17
GND on BOTTOM (solid shape): 129.95,117.46 129.95,115.86 129.74,115.64 128.08,115.64 127.99,115.55 127.99,115.44 127.87,115.32 127.43,115.32 127.39,115.37 127.39,116.55 128.52,117.69 129.73,117.69
GND on BOTTOM (solid shape): 147.3,20.66 147.3,18.81 146.99,18.5 144.61,18.5 144.54,18.57 144.54,19.14 144.64,19.24 145.32,19.24 145.37,19.3 145.37,20.26 145.25,20.39 145.25,20.82 145.46,21.03 146.93,21.03
GND on BOTTOM (solid shape): 172.49,92.04 172.49,89.33 172.11,88.95 168.97,88.95 168.79,88.95 168.73,89.01 168.73,91.15 170.2,92.62 171.9,92.62
GND on BOTTOM (solid shape): 279.64,48.87 279.91,48.87 280.53,48.26 280.53,46.5 280.99,46.03 280.99,44.04 280.31,43.35 280.31,40.73 279.88,40.31 277.96,40.31 277.7,40.56 277.7,48.61 277.99,48.89 279.62,48.89
GND on BOTTOM (solid shape): 11.07,18.21 11.07,17.56 11.03,17.52 11.03,16.33 11.03,16.33 11.03,13.96 10.93,13.86 9.47,13.86 9.4,13.93 9.4,16.32 9.75,16.68 9.75,17.48 10.51,18.23 11.05,18.23
GND on BOTTOM (solid shape): 14.68,41.14 14.68,40.55 14.42,40.3 13.94,40.3 13.26,39.61 11.66,39.61 11.83,40.43 11.86,41.26 14.55,41.26
GND on BOTTOM (solid shape): 153.62,70.74 154.01,70.74 154.25,70.5 154.25,68.61 153.78,68.13 153.78,67.72 153.77,67.72 153.77,67.18 153.66,67.07 152.85,67.07 152.7,67.23 152.7,67.99 152.47,68.21 152.47,70.5 152.73,70.75 153.62,70.75
GND on BOTTOM (solid shape): 310.39,26.39 310.39,24.73 310.27,24.62 309.66,24.62 309.66,24.61 308.38,24.61 307.79,24.02 307.51,24.02 307.32,24.22 307.32,25.34 307.23,25.43 305.55,25.43 305.44,25.55 305.44,26.23 305.91,26.7 310.08,26.7
GND on BOTTOM (solid shape): 145.8,88.99 145.8,87.81 144.16,86.18 139.65,86.18 139.07,86.75 139.07,87.28 139.11,87.31 139.45,87.31 139.62,87.14 141.52,87.14 141.69,87.32 141.69,89.18 141.73,89.22 145.57,89.22
GND on BOTTOM (solid shape): 207.29,89.32 207.29,86.5 205.82,85.03 205.82,85.02 205.82,81.15 205.76,81.09 201.25,81.09 201.19,81.15 201.19,85.2 201.71,85.72 201.98,85.72 204.66,88.41 204.66,88.98 205.43,89.75 206.86,89.75
GND on BOTTOM (solid shape): 275.01,60.44 275.01,59.49 274.85,59.34 273.67,59.34 273.57,59.24 265.53,59.24 265.4,59.37 265.4,60.16 265.45,60.2 267.87,60.2 268.29,60.62 274.83,60.62
GND on BOTTOM (solid shape): 204.71,78.31 204.71,77.73 203.99,77.01 203.99,76.45 203.79,76.24 202.41,76.24 202.17,76.49 202.17,76.97 201.73,77.4 201.12,77.4 200.93,77.58 200.93,78.23 201.13,78.43 202.57,78.43 202.68,78.31 203.82,78.31 203.94,78.43 204.59,78.43
GND on BOTTOM (solid shape): 104.6,23.4 105.12,23.4 105.21,23.3 105.33,23.24 106.91,21.66 106.91,20.83 106.59,20.51 106.07,20.51 106.07,20.51 101.24,20.51 101.08,20.67 101.08,23.06 101.49,23.47 104.52,23.47
GND on BOTTOM (solid shape): 139.15,117.44 140.61,117.44 140.61,117.44 141.04,117.44 141.32,117.16 141.32,115.13 141.04,114.85 138.72,114.85 138.34,114.47 136.12,114.47 135.79,114.8 135.79,115.34 135.79,115.35 135.79,117.93 136.34,118.48 138.11,118.48
GND on BOTTOM (solid shape): 321.64,58.45 321.64,57.57 321.43,57.36 320.01,57.36 319.66,57.71 319.46,57.71 319.44,57.69 318.06,57.69 317.86,57.89 317.29,57.89 317.28,57.89 317.08,58.09 317.08,58.83 317.32,59.06 317.9,59.06 317.92,59.08 317.97,59.13 320.96,59.13
GND on BOTTOM (solid shape): 322.03,14.49 322.03,12.05 321.67,11.7 320.23,11.7 320.17,11.76 319.39,11.76 319.38,11.77 319.22,11.8 319.07,11.77 319.06,11.76 317.84,11.76 317.39,12.21 317.39,14.46 317.67,14.73 321.78,14.73
GND on BOTTOM (solid shape): 251.68,54.86 251.68,54.67 251.71,54.64 251.8,54.55 252.72,54.55 252.76,54.51 252.76,54.38 252.96,54.18 253.22,54.18 253.35,54.05 253.35,53.77 253.24,53.66 252.99,53.66 252.6,53.28 251.85,53.28 251.21,53.92 251.21,54.86 251.25,54.9 251.65,54.9
GND on BOTTOM (solid shape): 252.92,51.78 253.25,51.78 253.32,51.71 253.32,51.48 252.88,51.05 252.67,51.05 252.67,51.05 251.57,51.05 251.05,50.53 251.05,49.92 250.86,49.73 247.22,49.73 246.99,49.49 241.08,49.49 240.79,49.78 240.79,51.27 240.99,51.47 251.15,51.47 251.25,51.56 251.25,51.8 251.37,51.93 252.77,51.93
GND on BOTTOM (solid shape): 27.19,17.22 27.19,15.41 27.18,15.41 27.18,14.91 27.19,14.9 27.19,14.72 27.06,14.6 25.43,14.6 25.18,14.85 25.18,15.49 25.21,15.52 26.24,15.52 26.29,15.58 26.3,15.59 26.32,15.61 26.32,16.75 26.21,16.86 25.63,16.86 25.6,16.88 25.6,17.54 25.74,17.68 26.73,17.68
GND on BOTTOM (solid shape): 43.41,20.03 43.41,20 43.63,19.78 43.95,19.78 44.18,20.01 44.56,20.01 44.75,19.82 44.75,19.62 44.22,19.09 44.22,18.56 43.97,18.3 42.62,18.3 42.44,18.48 42.44,19.35 42.45,19.36 42.47,19.44 42.48,19.51 42.48,20.09 42.71,20.32 43.12,20.32
GND on BOTTOM (solid shape): 331,26.74 331,26.57 330.98,26.55 330.98,25.42 331,25.4 331,24.8 330.95,24.75 330.95,22.49 330.71,22.24 329.81,22.24 329.72,22.34 329.72,23.65 329.79,23.73 329.79,23.75 329.99,23.95 329.99,24.69 329.81,24.88 329.81,26.29 329.8,26.3 329.8,26.32 329.73,26.39 329.73,26.45 329.67,26.45 329.61,26.51 329.61,27.16 329.72,27.27 330.47,27.27
GND on BOTTOM (solid shape): 251.93,46.62 252.28,46.62 252.3,46.64 252.79,46.64 253.34,46.09 253.34,45.88 253.24,45.78 251.38,45.78 251.37,45.77 251.03,46.11 251.03,46.13 251.01,46.13 250.99,46.15 247.4,46.15 247.29,46.04 247.29,45.93 247.22,45.87 247.09,45.87 247.09,45.86 240.89,45.86 240.76,45.98 240.76,47.31 240.83,47.38 247.23,47.38 247.38,47.53 247.38,47.72 247.45,47.78 250.77,47.78
GND on BOTTOM (solid shape): 330.5,15.47 330.5,13.91 330.4,13.7 330.46,13.47 330.47,13.46 330.47,13.34 330.7,13.11 330.95,13.11 331.24,12.82 331.24,12 331.17,11.93 329.92,11.93 329.85,12 329.85,13.56 329.91,13.61 329.91,14.92 329.79,15.04 329.79,15.5 329.84,15.55 330.42,15.55
GND on BOTTOM (solid shape): 199.01,79.68 199.11,79.65 199.2,79.6 199.29,79.58 199.32,79.58 199.51,79.39 199.51,79.28 199.28,79.28 199.28,78.52 199.88,78.52 199.88,76.38 199.57,76.38 198.59,77.36 198.59,79.14 198.79,79.33 198.79,79.48 198.86,79.53 198.92,79.61
GND on BOTTOM (solid shape): 62.51,8.69 62.51,8.25 62.68,8.07 65.07,8.07 65.86,7.28 65.86,5.96 65.22,5.32 60.04,5.32 58.6,6.77 57.88,6.77 57.3,7.34 55.47,7.34 55.35,7.46 54.08,7.46 53.6,6.98 52.54,6.98 52.03,7.49 51.09,7.49 51.01,7.56 51.01,7.72 51.09,7.8 52.13,7.8 52.49,8.17 54.95,8.17 55.33,8.56 56.79,8.56 57.22,8.12 58.14,8.12 58.86,8.84 62.35,8.84
GND on BOTTOM (solid shape): 176.25,80.86 174.4,79.01 172.95,79.01 172.94,79.01 172.85,79.05 172.81,79.14 172.81,79.33 172.85,79.42 172.94,79.46 172.95,79.46 174.39,79.46 174.6,79.55 174.67,79.77 174.67,79.8 176.09,81.22 176.17,81.26 176.25,81.26
GND on BOTTOM (solid shape): 29.22,20.87 29.22,19.92 28.87,19.57 28.83,19.57 28.83,19.57 27.53,19.57 27.26,19.7 26.99,19.57 24.82,19.57 24.71,19.57 24.54,19.4 24.54,19.14 24.39,18.98 23.74,18.98 23.74,19.43 23.74,19.59 23.79,19.64 24.24,19.64 24.36,19.76 24.36,20.17 24.4,20.21 24.59,20.21 24.6,20.22 24.75,20.22 24.93,20.4 24.93,20.88 25.09,21.04 29.05,21.04
GND on BOTTOM (solid shape): 176.23,67.66 176.34,67.58 176.32,67.44 174.39,65.51 172.94,65.51 172.85,65.55 172.81,65.64 172.81,65.83 172.85,65.92 172.94,65.96 172.95,65.95 174.39,65.95 174.57,66.02 174.67,66.19 174.67,66.21 176.12,67.66
GND on BOTTOM (solid shape): 175.09,63.48 175.23,63.51 175.31,63.39 175.31,63.32 174.49,62.5 174.43,62.51 174.39,62.51 172.95,62.51 172.94,62.51 172.85,62.55 172.81,62.64 172.81,62.83 172.85,62.92 172.94,62.96 174.39,62.96 174.52,62.99 174.62,63.07 174.68,63.07
GND on BOTTOM (solid shape): 175.66,71.94 175.77,71.86 175.75,71.72 174.52,70.49 174.48,70.5 174.44,70.51 174.39,70.51 172.95,70.51 172.94,70.51 172.85,70.55 172.81,70.64 172.81,70.83 172.85,70.92 172.94,70.96 174.39,70.96 174.51,70.98 174.6,71.05 174.62,71.07 174.63,71.07 175.5,71.94
GND on BOTTOM (solid shape): 176.29,39.67 176.31,39.53 176.2,39.46 176.08,39.46 174.63,40.9 174.62,40.9 174.6,40.92 174.51,40.99 174.39,41.01 172.95,41.01 172.94,41.01 172.85,41.05 172.81,41.14 172.81,41.33 172.85,41.42 172.94,41.46 174.39,41.46 174.43,41.46 174.49,41.47
GND on BOTTOM (solid shape): 129.46,175.35 138.44,175.35 138.44,169.09 137.88,168.53 137.17,168.53 136.77,168.92 130.24,168.92 128.95,167.63 128.95,164.98 127.08,163.12 125.57,163.12 124.39,164.3 124.39,165.7 126.53,165.7 127.22,166.28 126.77,167.06 126.73,167.07 126.73,177.9 129.46,177.9
GND on BOTTOM (solid shape): 174.71,64.12 174.85,64.15 174.93,64.03 174.93,63.79 174.59,63.44 174.54,63.47 174.47,63.5 174.39,63.51 172.94,63.51 172.85,63.55 172.81,63.64 172.81,63.83 172.85,63.92 172.94,63.96 172.95,63.95 174.39,63.95 174.52,63.99 174.62,64.07 174.66,64.07
GND on BOTTOM (solid shape): 175.34,21.12 175.37,20.98 175.25,20.9 174.62,20.9 174.52,20.98 174.39,21.01 172.95,21.01 172.94,21.01 172.85,21.05 172.81,21.14 172.81,21.33 172.85,21.42 172.94,21.46 174.39,21.46 174.52,21.49 174.62,21.57 174.89,21.57
GND on BOTTOM (solid shape): 175.87,30.62 175.9,30.48 175.78,30.4 174.62,30.4 174.52,30.48 174.39,30.51 172.95,30.51 172.94,30.51 172.85,30.55 172.81,30.64 172.81,30.83 172.85,30.92 172.94,30.96 174.39,30.96 174.52,30.99 174.62,31.07 175.42,31.07
GND on BOTTOM (solid shape): 176.1,70.59 176.14,70.54 176.19,70.5 176.24,70.41 176.2,70.31 174.41,68.51 172.95,68.51 172.94,68.51 172.85,68.55 172.81,68.64 172.81,68.83 172.85,68.92 172.94,68.96 174.39,68.96 174.61,69.05 174.67,69.27 174.67,69.31 175.95,70.59
GND on BOTTOM (solid shape): 175.03,38.54 175.03,38.24 174.95,38.12 174.81,38.15 174.67,38.3 174.66,38.31 174.56,38.46 174.39,38.51 172.95,38.51 172.94,38.51 172.85,38.55 172.81,38.64 172.81,38.83 172.85,38.92 172.94,38.96 174.39,38.96 174.46,38.96 174.52,38.99 174.56,39.01
GND on BOTTOM (solid shape): 175.48,31.62 175.5,31.48 175.39,31.4 174.62,31.4 174.52,31.48 174.39,31.51 172.94,31.51 172.85,31.55 172.81,31.64 172.81,31.83 172.85,31.92 172.94,31.96 172.95,31.95 174.39,31.95 174.52,31.99 174.62,32.07 175.02,32.07
GND on BOTTOM (solid shape): 175.71,61.83 175.83,61.86 175.92,61.78 175.94,61.72 175.98,61.67 176.01,61.63 174.4,60.01 172.94,60.01 172.85,60.05 172.81,60.14 172.81,60.33 172.85,60.42 172.94,60.46 172.95,60.45 174.39,60.45 174.6,60.55 174.67,60.76 174.67,60.79
GND on BOTTOM (solid shape): 251.39,59.72 251.74,59.72 251.93,59.53 251.93,57.96 251.88,57.9 251.14,57.9 251.12,57.92 251.12,58.84 250.71,59.25 249.45,59.25 248.76,58.55 248.76,58.29 248.64,58.17 240.71,58.17 240.63,58.26 240.63,58.94 241.07,59.39 241.43,59.39 241.6,59.56 243.55,59.56 243.71,59.43 243.92,59.38 244.1,59.38 244.31,59.43 244.47,59.56 245.5,59.56 245.52,59.59 245.55,59.59 245.55,59.62 245.62,59.69 245.62,60.22 245.69,60.29 250.82,60.29
GND on BOTTOM (solid shape): 174.9,15.53 175.17,15.53 175.18,15.53 175.4,15.52 175.57,15.65 175.67,15.71 175.77,15.68 175.92,15.52 175.95,15.38 175.83,15.31 175.13,15.31 175.09,15.27 172.81,15.27 172.81,15.83 172.85,15.92 172.94,15.96 172.95,15.96 174.39,15.96 174.47,15.96
GND on BOTTOM (solid shape): 175.63,77.28 175.65,77.22 175.69,77.17 175.7,77.04 175.59,76.97 175.43,76.97 174.47,76.01 174.39,76.01 172.94,76.01 172.85,76.05 172.81,76.14 172.81,76.33 172.85,76.42 172.94,76.46 172.95,76.45 174.39,76.45 174.52,76.48 174.62,76.57 174.65,76.57 175.41,77.33 175.62,77.33
GND on BOTTOM (solid shape): 174.79,73.84 174.93,73.86 175.01,73.75 175.01,72.96 174.95,72.9 174.62,72.9 174.52,72.98 174.39,73.01 172.95,73.01 172.94,73.01 172.85,73.05 172.81,73.14 172.81,73.33 172.85,73.42 172.94,73.46 174.39,73.46 174.58,73.52 174.67,73.7 174.67,73.72
GND on BOTTOM (solid shape): 175.11,16.26 175.15,16.16 175.1,16.07 175.06,16.03 174.97,15.98 174.88,16.02 174.67,16.22 174.67,16.25 174.59,16.44 174.39,16.51 172.95,16.51 172.94,16.51 172.85,16.55 172.81,16.64 172.81,16.83 172.85,16.92 172.94,16.96 174.41,16.96
GND on BOTTOM (solid shape): 199.88,53.53 199.86,53.51 197.01,53.51 196.95,53.59 196.95,54.3 196.5,54.76 196.54,54.8 196.6,54.97 196.51,55.22 196.54,55.3 196.59,55.42 196.59,55.54 196.61,55.65 196.71,55.7 196.86,55.7 196.94,55.62 198.24,55.62 198.24,55.48 199.01,55.48 199.01,55.74 199.07,55.8 199.07,57.51 199.01,57.58 199.01,57.8 199.88,57.8
GND on BOTTOM (solid shape): 192.42,78.87 192.52,78.82 192.55,78.71 192.66,78.38 193.02,78.36 193.06,78.39 193.6,77.85 193.6,77.82 193.56,77.77 193.49,77.78 193.32,77.95 192.44,77.95 191.84,78.55 191.85,78.59 191.85,78.65 191.84,78.71 191.86,78.82 191.96,78.87
GND on BOTTOM (solid shape): 175.21,18.05 175.21,17.9 175.04,17.72 175.04,17 175.54,16.5 175.55,16.44 175.49,16.4 175.44,16.4 174.67,17.17 174.67,17.2 174.6,17.42 174.39,17.51 172.94,17.51 172.85,17.55 172.81,17.64 172.81,17.83 172.85,17.92 172.94,17.96 172.95,17.96 174.39,17.96 174.52,17.99 174.62,18.07 175.2,18.07
GND on BOTTOM (solid shape): 175.82,66.47 175.92,66.51 176.02,66.44 176.07,66.38 176.13,66.32 176.13,66.15 175.91,65.93 175.68,65.93 174.64,64.89 174.64,64.51 174.58,64.45 174.53,64.48 174.47,64.5 174.39,64.51 172.95,64.51 172.94,64.51 172.85,64.55 172.81,64.64 172.81,64.83 172.85,64.92 172.94,64.96 174.39,64.96 174.61,65.06 174.67,65.29 174.66,65.32
GND on BOTTOM (solid shape): 64.03,58.84 64.14,58.78 64.13,58.26 64.46,58.06 64.79,58.06 64.96,58.23 65.34,58.23 65.39,58.18 66.72,58.18 66.74,58.16 66.74,57.57 66.52,57.35 66.52,57.01 66.52,56.23 66.33,56.03 64.76,56.03 64.44,56.35 64.44,57.02 64.28,57.19 63.3,57.19 63.06,56.95 60.48,56.95 60.35,56.82 60.35,56.05 60.02,55.72 58.95,55.72 58.82,55.84 58.82,57.37 59.03,57.57 59.03,58.28 59.59,58.84
GND on BOTTOM (solid shape): 176.24,34.64 176.28,34.56 176.25,34.47 176.22,34.44 176.2,34.41 176.11,34.34 176,34.38 174.98,35.4 174.62,35.4 174.52,35.48 174.39,35.51 172.94,35.51 172.85,35.55 172.81,35.64 172.81,35.83 172.85,35.92 172.94,35.96 172.95,35.95 174.39,35.95 174.52,35.99 174.62,36.07 174.82,36.07
GND on BOTTOM (solid shape): 180.72,45.22 180.79,45.24 180.83,45.18 180.83,44.8 180.83,44.79 180.85,44.72 180.79,44.68 180.44,44.68 179.82,44.06 179.37,44.06 179.27,44.11 179.25,44.22 179.19,44.51 178.93,44.63 178.9,44.63 178.56,44.97 178.54,45.1 178.65,45.18 180.68,45.18
GND on BOTTOM (solid shape): 179.49,57.16 179.65,57.16 179.75,57.1 179.76,56.97 179.73,56.79 179.81,56.62 179.83,56.49 179.71,56.41 179.1,56.41 179.07,56.44 179.03,56.53 179.07,56.63 179.17,56.87 179.05,57.11 179.05,57.17 178.61,57.61 178.27,57.61 178.22,57.66 178.22,57.76 178.26,57.79 178.85,57.79
GND on BOTTOM (solid shape): 408.15,10.3 407.62,9.03 406.35,8.5 397.95,8.5 397.95,12.42 402.45,12.42 402.45,14.81 403.05,16.21 404.45,16.79 408.15,16.79
GND on BOTTOM (solid shape): 175.94,39.13 177.48,39.13 177.54,39.07 177.54,38.96 177.48,38.9 176.17,38.9 175.92,38.65 175.89,38.65 175.81,38.65 175.73,38.63 175.62,38.65 175.56,38.75 175.56,38.76 174.66,39.66 174.67,39.69 174.61,39.92 174.39,40.01 172.94,40.01 172.85,40.05 172.81,40.14 172.81,40.33 172.85,40.42 172.94,40.46 172.95,40.45 174.39,40.45 174.46,40.46 174.52,40.48 174.56,40.5
GND on BOTTOM (solid shape): 176.45,44.67 176.56,44.67 176.62,44.63 176.6,44.56 176.48,44.44 176.46,44.44 176.2,44.32 176.14,44.04 176.11,43.93 176.01,43.88 175.57,43.88 175.02,44.43 174.76,44.43 174.65,44.49 174.65,44.61 174.67,44.73 174.65,44.86 174.65,44.98 174.76,45.04 176.08,45.04
GND on BOTTOM (solid shape): 144.3,109.32 144.91,109.32 144.92,109.33 144.98,109.33 145.07,109.29 145.11,109.2 145.31,108.88 145.68,108.92 145.72,108.95 146.4,108.27 146.4,106.28 146.34,106.23 145.58,106.23 145.51,106.3 145.52,106.39 145.52,107.64 145.37,107.88 145.09,107.87 145.07,107.86 145.02,107.86 144.89,107.73 144.89,106.08 144.65,105.84 143.4,105.84 142.84,106.4 142.84,109.05 143.12,109.33 144.28,109.33
GND on BOTTOM (solid shape): 29.9,41.52 29.9,40.31 29.66,40.06 29.43,40.06 29.03,39.67 29.03,37.31 28.97,37.26 28.97,33.78 29.08,33.67 32.94,33.67 33.44,34.17 33.44,40.71 33.98,41.25 34.69,41.25 35.01,40.93 35.01,36.87 35.91,35.97 35.91,34.17 35.01,33.27 35.01,32.13 34.9,32.02 28.62,32.02 27.57,30.97 26.94,30.97 26.86,31.05 26.86,32.74 27.05,32.93 27.05,32.96 27.22,33.12 27.22,35.5 27.46,35.73 27.46,38.84 27.46,41.14 27.57,41.25 28.52,41.25 28.74,41.47 29.17,41.13 29.42,41.62 29.8,41.62
GND on BOTTOM (solid shape): 172.57,22.11 172.44,21.98 172.44,21.53 172.57,21.41 172.57,21.09 172.44,20.96 172.44,20.52 172.57,20.39 172.57,20.07 172.44,19.95 172.44,19.5 172.57,19.38 172.57,19.06 172.44,18.93 172.44,18.04 172.57,17.92 172.57,17.6 172.44,17.47 172.44,17.03 172.57,16.9 172.57,16.58 172.44,16.45 172.44,16.01 172.57,15.88 172.57,15.57 172.19,15.57 169.55,12.93 164.09,12.93 163.45,13.58 163.45,17.06 163.57,17.19 168.12,17.19 168.72,17.78 168.72,19.81 168.84,19.94 170.15,19.94 170.15,18.8 171.04,18.8 171.05,18.81 171.07,18.84 171.09,18.87 171.12,18.89 171.15,18.89 171.18,18.9 171.22,18.89 171.25,18.87 171.29,18.82 171.58,18.82 171.78,19.02 171.78,19.31 171.57,19.51 171.56,19.53 171.12,19.97 171.12,20.36 170.92,20.56 170.63,20.56 170.25,20.19 170.25,19.94 168.84,19.94 169.12,20.22 169.43,20.22 171.57,22.36 172.57,22.36
GND on BOTTOM (solid shape): 175.4,37.1 177.54,37.1 177.66,37.02 177.63,36.88 177.4,36.65 177.37,36.66 177.08,36.55 177.02,36.25 177,36.14 176.9,36.08 176.17,36.08 174.86,37.4 174.62,37.4 174.52,37.48 174.39,37.51 172.94,37.51 172.85,37.55 172.81,37.64 172.81,37.83 172.85,37.92 172.94,37.96 172.95,37.95 174.39,37.95 174.44,37.96 174.48,37.97 174.52,37.98
GND on BOTTOM (solid shape): 186.64,53.45 186.67,53.44 187.57,53.44 187.69,53.37 187.66,53.23 187.57,53.13 187.57,52.59 188.05,52.11 188.05,51.52 188.04,51.5 186.65,51.5 186.65,51.61 186.69,51.71 186.8,51.74 187.18,52.09 186.72,52.33 186.6,52.33 186.53,52.44 186.53,52.72 186.44,52.81 186.44,53.33 186.49,53.43 186.6,53.45
GND on BOTTOM (solid shape): 178.69,38.53 178.83,38.39 178.82,38.36 178.87,38.15 179.05,38.01 179.13,37.92 179.1,37.8 178.73,37.43 177.72,37.43 177.61,37.51 177.63,37.65 177.87,37.88 177.87,37.95 177.88,38 177.92,38.02 178.21,38.37 177.86,38.65 177.83,38.64 177.76,38.71 177.87,38.82 177.87,39.21 177.84,39.35 177.96,39.43 178.69,39.43
GND on BOTTOM (solid shape): 177.24,20.62 177.23,20.58 177.24,20.49 177.27,20.39 177.26,20.27 177.15,20.21 176.61,20.21 176.51,20.27 176.5,20.39 176.47,20.75 176.13,20.85 176.09,20.84 175.03,21.9 174.62,21.9 174.52,21.98 174.39,22.01 172.94,22.01 172.85,22.05 172.81,22.14 172.81,22.33 172.85,22.42 172.94,22.46 172.95,22.45 174.39,22.45 174.52,22.49 174.62,22.57 175.28,22.57
GND on BOTTOM (solid shape): 175.52,48.34 175.62,48.3 175.65,48.19 175.83,47.83 176.21,47.93 176.31,47.99 176.42,47.94 176.53,47.84 176.68,47.81 176.71,47.81 177.06,47.47 177.08,47.33 176.97,47.25 175.24,47.25 175.06,47.43 174.76,47.43 174.65,47.49 174.65,47.61 174.67,47.73 174.65,47.86 174.65,47.98 174.76,48.04 174.86,48.04 175.16,48.34
GND on BOTTOM (solid shape): 175.95,19.88 177.29,19.88 178.5,18.66 178.49,18.62 178.46,18.48 178.51,18.34 178.51,18.21 178.4,18.15 177.98,18.15 177.87,18.22 177.88,18.35 177.88,18.69 177.57,18.84 177.54,18.83 176.96,19.41 175.93,19.41 175.44,19.9 174.62,19.9 174.52,19.98 174.39,20.01 172.94,20.01 172.85,20.05 172.81,20.14 172.81,20.33 172.85,20.42 172.94,20.46 172.95,20.45 174.39,20.45 174.52,20.49 174.62,20.57 175.26,20.57
GND on BOTTOM (solid shape): 176.1,23.23 176.1,22.78 176.02,22.71 175.97,22.61 175.88,22.53 175.76,22.56 175.42,22.9 174.62,22.9 174.52,22.98 174.39,23.01 172.95,23.01 172.94,23.01 172.85,23.05 172.81,23.14 172.81,23.33 172.85,23.42 172.94,23.46 174.39,23.46 174.67,23.73 174.39,24.01 172.94,24.01 172.85,24.05 172.81,24.14 172.81,24.33 172.85,24.42 172.94,24.46 172.95,24.45 174.39,24.45 174.52,24.49 174.62,24.57 174.77,24.57
GND on BOTTOM (solid shape): 175.74,60.89 175.85,60.92 175.94,60.85 176.03,60.74 176.15,60.68 176.24,60.59 176.21,60.47 174.84,59.1 174.84,58.45 174.8,58.4 174.7,58.37 174.61,58.41 174.59,58.44 174.57,58.48 174.59,58.53 174.65,58.84 174.39,59.01 172.95,59.01 172.94,59.01 172.85,59.05 172.81,59.14 172.81,59.33 172.85,59.42 172.94,59.46 174.39,59.46 174.61,59.55 174.67,59.78 174.66,59.81
GND on BOTTOM (solid shape): 180.71,48.29 180.78,48.29 180.84,48.25 180.83,48.18 180.79,48.14 180.79,47.68 179.1,47.68 178.88,47.9 178.79,47.96 178.78,48.06 178.71,48.33 178.45,48.45 178.43,48.44 178.05,48.82 178.02,48.96 178.14,49.04 178.6,49.04 179.44,48.2 179.43,48.17 179.98,47.93 179.74,48.47 179.71,48.47 179.01,49.17 178.99,49.31 179.1,49.39 179.61,49.39
