# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3.3V_VDD_PICP: length 15.6
  TOP w0.381: v2(39.37,16.37) 38.75,16.37 38.29,16.83 RT542.2 ; QT2.1 47.54,14.18 48.28,14.18 48.66,14.56 v2(48.66,14.7)
  IN3 w0.508: v2(48.66,14.7) 48.74,14.77 48.74,15.59 48.03,16.3 42.43,16.3 41.89,15.75 39.99,15.75 v2(39.37,16.37)
  BOTTOM w0.127: v2(48.66,14.7) 48.66,14.29 v4(48.33,13.96)
+3.3V_WLAN:
  vias: v2(111.59,114.11) v2(111.58,113.51) v2(112.15,114.33) v2(112.15,113.69) v2(129.11,113.78) v2(129.28,114.34) v2(145.44,110.42) v2(145.45,109.83) v2(145.47,109.2) v2(146.05,110.41) v2(146.06,109.82) v2(146.08,109.19) v4(112.37,115)
+3.3V_WLAN_PWR: length 1.4
  TOP w0.109: C190.1 144.17,103.48 v1(144.04,103.35)
+3.3V_WWAN:
  vias: v2(143.97,116.16) v2(144.75,116.15) v2(145.5,116.14) v2(150.27,108.9) v2(150.38,108.32) v2(150.86,108.88) v2(150.96,108.22) v2(151.46,108.84) v2(151.55,108.21) v2(164.51,115.87) v2(165.28,115.84) v2(165.97,115.86) v4(142.01,116.68)
+3.3V_WWAN_PWR:
  vias: v1(150.26,104.59)
+3.3VB_1.8V:
  vias: v1(97.48,16.12)
+3.3VB_2.5V: length 4.3
  TOP w0.109: v1(150.93,90.67) 150.93,90.4 151.8,89.54 153.73,89.54 154.21,90.02 154.21,90.22
+5V_ALW: length 486.3
  TOP w0.203: UI3.1 114.82,149.23 v2(114.54,148.95) ; UZ44.4 148.03,102.02 148.18,101.87 148.18,101.18 148.77,100.6 v2(149.15,100.6) ; v2(138.2,13.01) 137.95,13.01 137.65,13.31 137.65,13.52 137.74,13.61 UZ42.4
  TOP w0.254: PC805.1 107.58,33.29 107.9,32.97 107.9,31.96 107.67,31.73 PU800.7 ; 94.8,58.43 94.54,58.17 UZ43.4
  TOP w0.508: v2(16.77,34.62) 16.57,34.82 16.57,37.18 18.49,39.1 18.49,43.14 19.25,43.91 v2(19.56,43.91) ; PR204.2 v2(113.85,7.77) ; PR203.1 110.61,7.72 111.41,6.92 v2(111.74,6.92) ; PC805.1 108.01,33.53 v2(108.28,33.8) ; 94.8,58.43 94.8,60.54 93.24,62.11 93.24,66.65 96.81,70.22 97.8,70.22 99.68,72.1 v2(109.93,72.1) ; PR19.1 95.25,32.68 95.25,36.95 v2(94.84,37.35) ; v2(119.07,148.35) 119.02,148.3 RI82.2
  IN1 w0.508: v2(104.78,25.92) 105.44,26.58 105.44,30.51 105.92,30.99 107.08,30.99 107.92,31.83 107.92,33.44 v2(108.28,33.8) ; v2(48.91,35.96) 44.92,39.94 37.77,39.94 36.15,41.56 33.99,41.56 31.78,39.35 26.25,39.35 25.53,40.06 24.9,40.06 24.35,40.61 24.35,40.82 v2(24.08,41.1) 23.86,41.1 23.45,41.51 23.45,42.46 22.01,43.91 v2(19.56,43.91) 17.98,42.33 17.47,42.33 15.72,40.58 11.7,40.58 7.82,36.7 7.82,33.31 8.96,32.16 8.96,30.45 9.63,29.78 10.16,29.78 11.31,28.63 11.31,25.77 12.04,25.03 13.94,25.03 14.61,24.36 14.61,23.29 15.61,22.29 16.89,22.29 19.58,19.6 23.95,19.6 26.14,17.41 28.9,17.41 29.13,17.64 v2(29.13,18.23) ; v2(146.45,83.71) 147.57,84.83 147.57,98.9 149.15,100.47 v2(149.15,100.6) ; v2(18.57,34.28) 18.54,34.25 17.13,34.25 v2(16.77,34.62)
  IN2 w0.508: 120.3,150.33 121,151.03 126.32,151.03 127.54,149.81 131.99,149.81 133.7,151.53 136.29,151.53 137.03,150.79 137.03,147.86 137.74,147.15 137.74,145.24 138.45,144.53 145.53,144.53 146.1,145.1 155.98,145.1 156.3,144.78 156.3,140.58 156.71,140.16 157.64,140.16 159.94,137.86 162.46,137.86 165.4,140.81 167.87,140.81 169.05,139.63 v2(169.71,139.63)
  IN3 w0.508: v2(111.74,6.92) 111.28,6.92 110.44,7.76 110.44,9.29 109.93,9.79 109.93,11.7 109.45,12.18 109.45,15.43 108.07,16.8 108.07,19.81 107.08,20.8 107.08,21.92 106.36,22.65 104.82,22.65 104.19,23.28 104.19,25.55 104.56,25.92 v2(104.78,25.92) ; v2(59.95,45.23) 59.95,44.46 61.41,43 62.75,43 66.13,39.63 88.54,39.63 90.38,37.78 94.41,37.78 v2(94.84,37.35) 94.89,37.3 94.89,35.77 95.37,35.28 95.37,32.13 97.8,29.71 99.9,29.71 100.53,30.34 102.72,30.34 103.63,31.26 105.06,31.26 105.26,31.07 107.15,31.07 108.12,32.04 108.12,33.64 v2(108.28,33.8)
  IN4 w0.508: v2(146.45,83.71) 146.14,84.03 144.28,84.03 143.63,83.38 142.59,83.38 140.82,85.16 133.1,85.16 132.55,85.71 125.16,85.71 120.43,80.98 119.16,80.98 118.53,80.34 118.53,79.94 118.9,79.57 118.9,78.98 ; v2(169.71,139.63) 169.75,139.59 169.75,129.94 162.89,123.08 162.89,120.82 163.68,120.03 166.75,120.03 167.51,119.27 167.51,111.98 166.09,110.56 159.97,110.56 159.38,111.14 157.27,111.14 156.39,112.03 154.89,112.03 153.07,110.21 153.07,106.43 152.64,106 152.64,103.03 150.72,101.11 150.72,100.24 150.24,99.76 149.53,99.76 149.15,100.14 v2(149.15,100.6) ; 118.9,78.98 117.67,78.98 116.49,77.8 115.13,77.8 114.35,77.02 114.35,76.09 114.02,75.76 v2(114.02,75.05) ; 118.9,78.98 119.48,78.4 123.7,78.4 124.67,79.38 124.67,80.22 125.19,80.73 125.28,80.73 v2(126.16,81.6) ; v2(111.74,6.92) 112.69,6.92 113.54,7.77 v2(113.85,7.77) 113.89,7.81 114.58,7.81 116.71,5.68 122.78,5.68 123.44,6.34 131.72,6.34 133.15,7.76 133.41,7.76 138.2,12.55 v2(138.2,13.01)
  BOTTOM w0.127: v2(36.78,7.25) v4(36.18,7.25) ; v2(38.05,7.25) v4(38.05,6.5) ; v2(39.32,7.25) v4(39.96,7.25)
  BOTTOM w0.254: v2(169.71,139.63) 169.32,139.63 169.21,139.73 168.85,139.73 168.63,139.52 UZ7.4 ; 21.99,36.31 21.54,35.86 UT5.L9 ; UT5.J2 18.04,34.68 18.44,34.28 v2(18.57,34.28) ; UR4.3 29.08,18.18 v2(29.13,18.23) ; UZ59.4 126.83,81.34 126.55,81.63 126.18,81.63 v2(126.16,81.6)
  BOTTOM w0.356: CT343.1 15.23,35.2 16.28,35.2 16.77,34.7 v2(16.77,34.62) ; 23.38,38.19 23.21,38.36 CT342.1 23.2,38.64 23.2,39.5 24.08,40.38 v2(24.08,41.1)
  BOTTOM w0.381: 21.99,36.31 22.13,36.45 22.26,36.45 23,37.19 23,37.38 23.38,37.76 23.38,38.19
  BOTTOM w0.508: v2(114.02,75.05) 113.76,75.3 113.18,75.3 109.98,72.1 v2(109.93,72.1)
  vias: v2(33.37,22.67) v2(33.52,18.37) v2(33.88,20.56) v2(34.06,20) v2(34.21,21.86) v2(34.54,20.54) v2(34.67,22.62) v2(34.82,21.91) v2(34.82,20) v2(35.71,21.96) v2(36.04,22.49) v2(36.29,21.78) v2(36.62,24.5) v2(36.78,8.52) v2(36.78,7.89) v2(37.41,8.52) v2(37.41,7.89) v2(37.41,7.25) v2(38.05,8.52) v2(38.05,7.89) v2(38.68,8.52) v2(38.68,7.89) v2(38.68,7.25) v2(38.96,20.84) v2(39.32,8.52) v2(39.32,7.89) v2(39.95,7.89) v2(40.59,21.48) v2(40.89,20.97) v2(40.97,21.96) v2(48.71,46.27) v2(49.3,45.2) v2(49.35,46.32) v2(49.6,46.88) v2(50.04,47.34) v2(51.51,44.97) v2(118.69,151.4) v2(119.08,151.87) v2(119.23,151.08) v2(119.71,151.6) v2(119.85,151.02)
+5V_ALW2: length 4.6
  BOTTOM w0.109: PC127.1 50.94,4.41 50.37,3.84 v1(50.37,2.47)
  BOTTOM w0.254: PU101.15 52.12,5.73 51.93,5.54 51.83,5.5 51.51,5.5 50.94,4.93 PC127.1
+5V_ALW_R: length 358.8
  TOP w0.203: v2(365.89,34.59) 365.92,34.56 UZ40.4 ; PR1170.1 v2(296.24,38.11) ; v2(335.73,18.89) 335.49,19.13 335.49,19.28 335.18,19.6 335,19.6 334.77,19.83 UZ9.4 ; UZ45.4 333.64,12.69 334.29,12.04 v2(334.62,12.04)
  TOP w0.254: UI1.7 385.78,60.35 v2(386.03,60.59) 385.77,60.85 UI1.8 ; PU1202.15 288.35,33.67 v2(287.86,33.17) ; PU1200.15 288.25,53.29 288,53.04 287.09,53.04 286.78,53.35 v2(286.78,53.74) ; v2(362.43,11.72) 362.52,11.81 UZ23.4 ; UI2.8 382.99,34.06 v2(382.72,33.8) 382.49,34.03 UI2.7
  TOP w0.305: PC1245.1 291.68,22.79 291.42,23.05 291.42,23.16 291.14,23.27 v2(291.09,23.38) ; PC1245.1 291.92,22.92 PR1212.1 291.68,24.11 PU1203.2 ; PC1245.1 291.49,22.49 v2(291.03,22.49) ; JPB1.2 v2(372.4,46.98) ; v2(285.97,63.58) 286.02,63.58 286.42,63.98 PU1800.15 ; PU1700.15 288.35,12.47 v2(288.36,12.46) ; PU1201.15 288.35,42.92 v2(288.36,42.92) ; UZ19.3 272.05,77.58 ; v2(291.28,43.68) 291.31,43.65 PC1225.1 292.11,43.77 PR1205.1 291.96,44.89 PU1201.2 ; PR1700.1 291.56,14.41 PU1700.2 ; PU1200.2 290.59,55.64 290.73,55.77 291.88,55.77 PR1200.1 ; CZ64.1 336.69,50.88 336.36,50.55 JUSH1.9 334.92,50.55 334.78,50.69 334.78,50.88 334.95,51.05 JUSH1.10 ; PU1203.15 v2(288.33,22.2)
  TOP w0.356: CZ64.1 338.27,50.88
  TOP w0.508: PR1151.1 295.59,45.02 v2(295.09,45.02) ; v2(339.47,52.01) 339.17,51.71 CZ69.1 338.75,50.88 338.27,50.88 ; PC1708.1 292.05,12.78 PR1700.1 ; v2(277.86,71.54) 277.61,71.79 275.69,71.79 274.85,72.63 272.79,72.63 271.24,74.18 271.24,76.3 272.05,77.11 272.05,77.58 ; v2(378.08,36.16) RI67.2 ; v2(396.5,13.15) 397.7,13.15 398.27,12.58 400.1,12.58 400.5,12.17 JLED1.1 ; RI13.2 v2(387.02,56.45)
  VCC w0.508: v2(162.45,31.8) 163.16,31.09 163.16,28.28 164.02,27.43 164.02,25.12 158.63,19.73 158.63,19.03 165.71,11.95 170.57,11.95 171.08,12.46 174.32,12.46 174.83,11.95 230.7,11.95 236.35,17.6 238.07,17.6 239.09,18.62 240.29,18.62 240.87,18.05 242.26,18.05 243.28,19.06 247.47,19.06 248.02,18.51 257.08,18.51 257.88,19.32 259.41,19.32 262.46,16.27 266.31,16.27 270.19,12.4 286.01,12.4 287.22,13.6 287.98,13.6 288.36,13.22 v2(288.36,12.46)
  IN3 w0.254: v2(288.36,12.46) 288.36,13.3 288.9,13.83 290.93,13.83 ; v2(288.33,22.2) 288.33,22.12 288.9,21.54 290.93,21.54 290.99,21.61 ; v2(285.97,63.58) 285.97,63.66 286.58,64.28 v2(290.45,64.28)
  IN3 w0.508: v2(286.78,53.74) 286.78,53.48 287.16,53.1 290.46,53.1
  IN4 w0.508: v2(335.73,18.89) 341.98,18.89 342.72,18.15 342.72,16.22 343.75,15.19 349.3,15.19 350.59,13.9 v2(351.74,13.9) 352.38,14.54 356.39,14.54 357.32,13.6 360.11,13.6 360.56,14.06 361.64,14.06 ; v2(396.5,13.15) 396.5,12.54 394.4,10.44 390.1,10.44 389.61,9.95 384.48,9.95 383.55,10.88 382.3,10.88 380,13.17 372.37,13.17 369.81,15.73 365.8,15.73 v2(365.61,15.53) ; v2(287.86,33.17) 288.29,33.17 288.94,32.53 291.51,32.53 v2(292.58,33.59) ; 306.58,69.36 305.89,70.05 302.46,70.05 300.99,71.52 298.57,71.52 297.1,70.05 291.78,70.05 288.73,73.1 278.93,73.1 277.86,72.04 v2(277.86,71.54) ; v2(291.28,43.68) 288.66,43.68 288.36,43.38 v2(288.36,42.92)
  BOTTOM w0.127: v2(291.18,13.58) v4(291.82,13.58)
  BOTTOM w0.254: UZ58.4 351.61,13.77 v2(351.74,13.9)
  BOTTOM w0.305: UZ26.3 162.52,31.88 v2(162.45,31.8) ; UZ21.3 277.72,72.65 277.98,72.39 277.98,71.66 v2(277.86,71.54)
  BOTTOM w0.356: v2(396.5,13.15) 396.5,13.29 396.73,13.52 CZ527.1
  BOTTOM w0.381: v2(288.36,12.46) 288.36,11.98 288.59,11.75 289.51,11.75 290.57,12.82 v2(290.57,13.27)
  BOTTOM w0.508: v2(335.73,18.89) 335.33,18.48 333.25,18.48 332,17.24 332,14.72 334.62,12.11 v2(334.62,12.04)
  vias: v2(292.53,54.47) v2(294.87,61.13) v2(294.87,60.54) v2(295.48,61.13) v2(295.5,60.52) v2(300.1,65.5) v2(300.48,66) v2(300.81,65.47) v2(301.22,65.93) v2(301.62,65.47) v2(361.95,14.26) v2(362.53,14.26) v2(362.86,13.73) v2(363.17,14.24) v2(363.85,35.86) v2(364.47,36.76) v2(364.44,35.83) v2(365.12,36.76) v2(365.19,35.87) v2(365.73,36.75) v2(365.84,35.91) v2(366.31,36.75) v2(372.18,33.49) v2(372.79,33.51) v2(373.33,44.34) v2(373.39,33.52) v2(373.97,33.58) v2(374.05,43.8) v2(374.06,43.06) v2(374.02,42.41) v2(374.02,41.67) v2(374.15,44.44) v2(374.6,42.18) v2(374.76,43.84) v2(374.72,43.19) v2(374.89,44.54) v2(374.98,45.19) v2(375.1,42.69) v2(375.36,43.32) v2(375.55,44.62) v2(375.65,43.87) v2(378.06,57.13) v2(378.57,57.54) v2(378.62,56.94) v2(379.21,56.82) v2(379.7,38.78) v2(379.73,38.18) v2(379.93,37.23) v2(380.29,38.78) v2(380.34,38.17) v2(382.59,57.44)
+5V_ALW_RP: length 20.4
  TOP w0.254: PU500.14 355.45,39.94 v2(355.17,39.66) 355.17,39.17 PR506.2
  BOTTOM w0.508: v2(371.68,40.78) 370.41,39.51 367.87,39.51 366.09,37.73 v1(359.7,37.73) 357.64,37.73 355.71,39.66 v2(355.17,39.66)
+5V_ALWP: length 16.7
  IN1 w0.508: v2(42.39,5.43) 42.39,5.02 45.86,1.55 51.48,1.55 52.27,2.34 v2(52.27,5.2)
  BOTTOM w0.254: PR114.2 51.94,4.87 v2(52.27,5.2) 52.57,5.49 PU101.14
  vias: v1(43.28,6) v2(42.44,6.8) v2(42.42,6.21)
+5V_DGFF: length 8.2
  TOP w0.254: JDGFF2.D9 249.54,92.32 249.13,92.73 249.13,93.07 249.91,93.84 249.91,93.96 v2(249.96,94.01)
  TOP w0.381: v2(250.37,93.59) 250.39,93.56 250.39,93.52 JDGFF2.D10 ; CV806.1 252.21,84.66 253.05,85.5 253.05,86.13 252.97,86.21 v2(252.96,86.21)
  TOP w0.508: CV806.1 252.6,83.66 CV957.1
  BOTTOM w0.109: v4(236.23,94.41) 235.81,93.99 v2(235.81,93.49)
  vias: v2(235.15,94.15) v2(235.18,93.56) v2(293.19,66.05) v2(293.22,65.27) v2(293.7,64.76) v2(293.8,65.62) v2(293.82,66.31)
+5V_DGFF_PWR: length 2.7
  TOP w0.109: v1(295.77,62.08) 295.77,63.03 296.92,64.19 CZ529.1
+5V_HDD: length 89
  IN3 w0.254: v2(310.32,3.23) 311.01,2.54 338.91,2.54 343.1,6.73 356.47,6.73 360.32,10.58 361.09,10.58 361.58,11.06 362.45,11.06 363.37,11.98 367.4,11.98 367.78,11.6 v2(368.15,11.6)
  BOTTOM w0.254: RN1.1 v4(303.64,19.66) 303.3,19.66 302.07,18.43 302.07,15.6 300.23,13.77 300.23,11.6 302.53,9.3 303.55,9.3 305.53,7.33 305.53,4.69 307.44,2.77 309.94,2.77 310.32,3.15 v2(310.32,3.23)
+5V_HDD_UZ23: length 1
  TOP w0.109: v1(366.35,15.12) 366.51,14.96 CZ129.1
+5V_RUN: length 400.1
  TOP w0.254: JUSH1.7 336.49,49.55 336.62,49.43 336.62,49.17 337.16,48.63 CZ66.1
  TOP w0.381: CZ66.1 337.51,48.64 337.51,49.04 337.25,49.3 v2(337.25,49.37)
  TOP w0.508: v2(273.2,94.6) 276.32,94.6 ; v2(353.34,48.75) 353.69,49.11 RZ518.1 ; 116.08,77.92 116.06,77.9 114.18,77.9 112.88,76.6 104.68,76.6 103.95,77.33 v2(103.95,77.74) ; v2(12.42,4.78) 12.43,4.79 14.16,4.79 15.34,3.61 JKBTP1.5
  TOP w1.016: 163.4,103.24 163.65,103.49 167.61,103.49 170.83,100.28 179.12,100.28 185,94.41 227.89,94.41 228.06,94.58 230.71,94.58 230.71,94.58
  IN2 w0.508: v2(27.12,10.17) 24.71,10.17 22.68,8.14 22.68,6.77 24.86,4.59 25.82,4.59 26.2,4.22 26.2,3 24.62,1.42 22.1,1.42 20.84,2.68 19.16,2.68 18.88,2.4 14.8,2.4 v2(12.42,4.78) ; v2(231.66,94.4) 231.68,94.38 v2(232.31,94.38) 232.81,94.88 272.92,94.88 v2(273.2,94.6)
  IN3 w0.508: v2(67.13,36.21) 67.13,31.38 67.24,31.28 67.24,29.01 68.47,27.78 68.47,26.69 66.43,24.65 58.05,24.65 56.11,22.71 56.11,16.65 55.45,16 55.11,16 53.46,14.34 53.46,13.49 52.85,12.89 48.18,12.89 47.34,13.73 43.94,13.73 43.74,13.93 42.64,13.93 42.06,13.35 42.06,12.44 41.76,12.13 39.9,12.13 38.99,13.05 36.93,13.05 35.77,11.89 35.54,11.89 34.72,11.07 34.72,9.67 34.16,9.11 32.84,9.11 32.66,9.29 28.01,9.29 v2(27.12,10.17) ; 232.69,94.86 232.84,95.01 272.39,95.01 ; v2(340.92,56.12) 339.87,55.07 336.49,55.07 336.1,54.68 336.1,49.52 336.25,49.37 v2(337.25,49.37)
  IN3 w1.016: 119.78,94.85 119.79,94.84 123.2,94.84 124.69,96.33 125.16,96.33 126.55,97.73 145.54,97.73 146.58,98.77 146.58,100.24 147.17,100.83 147.17,103.95 147.73,104.51 148.23,104.51 150.67,106.95 158.77,106.95 161.31,104.41
  BOTTOM w0.109: v2(304.62,72.58) v4(304.62,71.95)
  BOTTOM w0.508: v2(67.13,36.21) 68.37,37.45 69.42,37.45 74.66,42.7 81.56,42.7 82.35,43.49 82.35,46.99 83.11,47.74 83.11,53.88 84.84,55.61 84.84,59.43 90.96,65.55 94.11,67.6 98.12,71.51 99.01,72.39 100.62,73.47 103.95,76.8 v2(103.95,77.74) ; v2(337.25,49.37) 337.18,49.3 CZ71.1 ; CZ92.1 12.43,4.79 v2(12.42,4.78)
  vias: v2(119.46,93.4) v2(119.95,93.71) v2(120.84,80.28) v2(121.44,80.25) v2(161.58,103.21) v2(162.28,103.09) v2(276.77,94.38) v2(277.14,93.91) v2(277.54,93.49) v2(277.68,94.19) v2(300.97,89.02) v2(300.98,88.35) v2(301.87,89.02) v2(301.88,88.34) v2(305.43,72.71) v2(353.27,47.73) v2(354.2,48.3) v2(354.91,48.76) v2(354.94,47.73) v2(374.98,36.57) v2(376.34,35.56) v2(376.34,34.92) v2(376.98,35.56) v2(376.98,34.92)
+5V_RUN_AUDIO: length 6.2
  TOP w0.457: v2(382.04,32.76) 382.28,32.52 LA27.2
  IN1 w0.508: v2(378.13,31.68) 379.56,33.11 381.68,33.11 v2(382.04,32.76)
  BOTTOM w0.109: v2(378.13,31.68) v4(378.13,32.27)
+5V_RUN_CHG: length 1.4
  TOP w0.109: RZ518.2 353.69,53.19 v1(353.41,53.47)
+5V_RUN_PVDD_L: length 3.2
  BOTTOM w0.381: v2(382.68,27.43) 382.34,27.09 v1(382.34,26.91) CA45.1 ; CA47.1 380.23,25.83 v2(379.17,26.9)
  vias: v2(381.41,29.54)
+5V_RUN_PWR:
  vias: v1(369.09,37.21)
+5V_USB_PWR1:
  vias: v2(381.44,62.56) v2(382.06,62.47) v2(382.25,63.13) v2(382.73,62.63) v2(382.92,63.21) v2(387.18,60.58) v2(387.66,60.98) v2(387.7,60.31) v2(388.2,61.24) v2(388.22,60.64) v4(388.71,63.3)
+5V_USB_PWR2:
  vias: v2(383.56,37.86) v2(384.01,37.48) v2(384.46,37.85) v2(384.66,37.2) v2(385.05,37.76) v2(386.48,35.14) v2(386.51,34.52) v2(387.02,34.86) v2(387.59,35.13) v2(387.6,34.51) v4(385.79,34.75)
+5V_USB_PWR3: length 0.6
  BOTTOM w0.102: v2(115.01,152.78) v4(114.39,152.78)
  vias: v2(115.05,153.37) v2(115.45,153.84) v2(115.63,153.28) v2(116.13,153.83) v2(124.56,156.38) v2(124.61,157.31) v2(125.07,156.81) v2(125.55,157.31) v2(125.54,156.34)
+5V_VBUS1:
  vias: v4(35.94,27.74)
+5V_VBUS2:
  vias: v4(40.92,27.89)
+13.5VB_BATT: length 36.2
  TOP w0.508: v2(76.86,29.61) 76.86,28.33 PD701.2
  IN4 w0.508: v2(76.86,29.61) 77.59,28.87 77.59,25.59 80.92,22.27 v2(80.92,20.84)
  BOTTOM w0.508: 74.62,7.03 76.03,7.03 v4(76.34,7.33) 82.5,7.33 84.43,9.26 84.43,15.59 83.67,16.35 83.67,18.68 81.51,20.84 v2(80.92,20.84)
  vias: v2(71.47,7.1) v2(72.13,7.1) v2(72.81,7.11) v2(73.54,7.09)
+13.5VB_BATT_C:
  vias: v2(63.83,10.93) v2(63.83,10.3) v2(63.82,9.71) v2(63.82,9.07) v2(64.47,10.93) v2(64.47,10.3) v2(64.45,9.71) v2(64.45,9.07) v2(65.09,9.71) v2(65.09,9.07) v2(65.1,10.93) v2(65.1,10.3) v2(65.74,10.93) v2(65.74,10.3) v2(65.72,9.71) v2(65.72,9.07) v4(64.08,8.57) v4(66,8.55) v4(66.3,10.29)
+13.5VB_CHG: length 16
  TOP w0.508: v2(69.34,15.36) 68.83,15.86 PC725.2 68.83,16.83 PR735.2
  IN4 w0.508: v2(69.34,15.36) 69.92,14.77 75.18,14.77 76.3,13.65 80.19,13.65 81.06,12.78 v2(81.06,11.33)
  vias: v1(80.93,15.64)
+19.5V_DC_IN: length 115.8
  TOP w0.508: DT63.2 48.69,21.89 v2(48.11,22.47) ; v2(92.1,20.18) 92.1,21.11 92.87,21.88 92.87,24.44 v2(91.67,25.64) 91.67,26.22 90.85,27.03 90.39,27.03 PR3.1 90.33,26.96 PC1.1 90.33,25.76 89.64,25.07 PQ12.3 ; PQ12.3 88.75,23.43 88.75,23.17 87.99,22.41 v2(85.9,22.41) ; PQ12.3 89.65,24.3 90.83,24.3 91.18,23.94 PR1.1 ; v2(94.75,38.74) 95.35,39.33 95.35,42.31 96.57,43.53 96.57,49.16 v2(97.81,50.41)
  IN1 w0.508: v2(48.11,22.47) 48.11,21.43 49.02,20.51 49.83,20.51 50.19,20.87 53.9,20.87 54.63,20.13 54.63,18.73 54.54,18.64 54.54,16.55 54.81,16.27 54.81,15.89 55.76,14.94 58.99,14.94 60.12,13.81 60.12,11.2 61.52,9.8 62.15,9.8 63.54,8.41 69.63,8.41 69.78,8.56 77.38,8.56 81.63,12.82 84.55,12.82 88.11,16.37 88.11,17.03 91.26,20.18 92.1,20.18 v2(92.1,20.18)
  IN4 w0.508: v2(94.75,38.74) 94.23,38.22 94.23,36.53 94.87,35.89 94.87,32.55 95.67,31.75 95.67,29.54 94.28,28.16 94.28,27.8 92.13,25.64 v2(91.67,25.64)
  BOTTOM w0.508: PR2036.1 79.65,22.67 80.57,21.76 82.01,21.76 82.24,21.53 85.09,21.53 85.9,22.33 v2(85.9,22.41)
  vias: v4(97.93,52.34) v4(98.37,49.86) v4(102.69,54.18)
+19.5V_DC_IN_SS: length 43.6
  TOP w0.508: v2(80.06,28.26) 80.72,28.26 80.91,28.07 PD700.3
  IN4 w0.508: v2(75.03,33.54) 75.03,31.71 75.59,31.16 77.47,31.16 80.06,28.56 v2(80.06,28.26)
  BOTTOM w0.508: v2(75.03,33.54) 75.28,33.8 v1(75.28,36.79) 75.28,39.64 75.88,40.23 78.53,40.23 79.57,41.27 82.05,41.27 83.3,42.52 84.72,42.52 85.14,42.94 94.89,42.94 95.13,43.18 95.13,45.29 95.58,45.73 96.12,45.73 97.28,46.89 PD1.2
+19.5V_DCIN_JACK:
  vias: v4(96.14,64.82) v4(97.31,62.78) v4(97.86,64.38)
+19.5V_SDC_IN: length 40.5
  TOP w0.381: PR706.2 69.34,29.51 v2(69.31,29.53) ; PR707.1 73.06,29.31 v2(72.84,29.53)
  IN2 w0.254: v2(82.75,33.67) 79.59,33.67 77.44,31.52 73.75,31.52 73.16,30.94 73.16,29.85 v2(72.84,29.53) 72.3,30.08 69.86,30.08 v2(69.31,29.53) 66.67,32.17 58.95,32.17 v2(58.8,32.32)
  IN4 w0.254: v2(82.62,23) 82.62,32.89 v2(82.79,33.05)
  BOTTOM w0.381: PR44.1 57.81,32.75 v2(58.21,32.35)
  vias: v2(58.82,31.7) v2(82.75,35.57) v2(82.75,34.94) v2(82.75,34.3) v2(83.51,35.57) v2(83.51,34.94) v2(83.51,34.3) v2(83.51,33.67) v2(84.27,35.57) v2(84.27,34.94) v2(84.27,34.3) v2(84.27,33.67) v4(97.39,40.58)
+19.5V_SDC_IN_CR: length 9.2
  TOP w0.109: v1(92.66,33.7) 92.62,33.66 v2(91.7,33.66)
  TOP w0.508: 91.56,38.48 PQ705.3 ; 91.56,38.48 91.56,37.73 91.41,37.57 90.94,37.57 90.42,37.05 90.42,36.16 91.64,34.94 PR731.1 91.64,33.72 v2(91.7,33.66) ; 91.56,38.48 91.56,38.62 91.69,38.74 93.09,38.74 93.13,38.78 PR733.1
+19.5VB: length 198.7
  TOP w0.508: v2(132.46,116.27) 132.46,115.98 131.75,115.27 PR109.2 ; RZ85.1 338.47,59.84 v2(339,59.31) ; v2(320.17,3.05) 320.17,2.83 320.68,2.32 PR510.2
  TOP w3.048: 212.16,6.16 212.16,82.49 217.88,88.2
  IN3 w0.508: 142.81,114.65 142.8,114.67 134.65,114.67 133.04,116.27 v2(132.46,116.27)
  IN3 w2.032: 110.23,125.68 110.55,126 128.1,126 130.76,123.33 132.15,123.33 133.02,122.47 134.7,122.47 134.73,122.44 137.17,122.44 139.65,124.92 141.55,124.92 143.58,126.95 ; 110.23,125.68 110.23,115.1 108.07,112.94 108.07,106.95 110.36,104.66 110.36,104.36 111.7,103.02 111.7,100.07 113.89,97.88 113.89,95.98 113.33,95.42 113.33,90.74 112.2,89.61 ; 110.23,125.68 110.23,133.51 110.26,133.54 ; 113.93,142 110.63,138.7 110.63,137.8
  IN4 w0.508: v2(320.17,3.05) 320.17,3.74 319.22,4.69 v2(319.22,11.44)
  vias: v2(56.4,14.05) v2(56.77,13.12) v2(56.77,12.51) v2(56.98,14.06) v2(57.45,13.15) v2(57.43,12.5) v2(57.66,14.02) v2(58.14,13.46) v2(58.27,14.31) v2(89.27,15.17) v2(89.27,14.53) v2(89.27,13.92) v2(89.27,13.26) v2(89.27,12.63) v2(89.24,11.99) v2(89.29,11.38) v2(89.86,29.67) v2(89.82,15.39) v2(89.82,14.79) v2(89.82,14.2) v2(89.82,13.62) v2(89.82,13.03) v2(89.82,12.45) v2(89.82,11.86) v2(90.19,29.11) v2(90.47,30.25) v2(90.44,29.65) v2(90.41,15.42) v2(90.41,14.79) v2(90.77,29.09) v2(90.96,29.93) v2(91.11,30.5) v2(91.34,29.44) v2(91.31,28.86) v2(91.54,29.99) v2(91.7,30.55) v2(91.89,28.86) v2(91.94,29.45) v2(92.17,29.99) v2(92.29,30.56) v2(92.5,28.82) v2(92.52,29.4) v2(92.76,29.95) v2(92.87,30.54) v2(93.08,28.9) v2(93.12,29.5) v2(93.32,30.1) v2(93.43,30.72) v2(93.71,29.51) v2(93.91,30.07) v2(94.03,30.64) v2(98.66,38.54) v2(98.66,37.96) v2(98.66,37.37) v2(99.24,38.54) v2(99.24,37.96) v2(99.24,37.37) v2(108.3,5.88) v2(108.3,5.25) v2(108.3,4.61) v2(108.3,3.98) v2(108.94,5.88) v2(108.94,5.25) v2(108.94,4.61) v2(108.94,3.98) v2(109.57,5.88) v2(109.57,5.25) v2(109.57,4.61) v2(109.57,3.98) v2(110.4,85.99) v2(110.78,86.45) v2(110.74,85.49) v2(111.26,87.56) v2(111.26,86.97) v2(111.22,86.07) v2(111.33,85.49) v2(111.66,86.53) v2(111.62,84.97) v2(111.83,85.94) v2(112.09,87.57) v2(112.09,86.98) v2(112.05,85.39) v2(112.27,86.35) v2(112.48,85.79) v2(112.61,87.26) v2(115.26,143.52) v2(115.26,142.89) v2(115.85,143.52) v2(115.85,142.89) v2(116.15,3.95) v2(116.53,7.3) v2(116.79,3.95) v2(117.42,3.95) v2(117.65,7.43) v2(118.06,3.95) v2(139.65,135.78) v2(139.65,135.19) v2(140.23,135.78) v2(140.23,135.19) v2(143.55,115.29) v2(143.53,114.54) v2(144.28,115.32) v2(144.24,114.67) v2(144.85,114.41) v2(144.95,115.38) v2(158.68,8.2) v2(159.16,7.66) v2(159.28,8.4) v2(159.66,7.27) v2(159.76,7.86) v2(160.04,8.47) v2(160.12,6.89) v2(160.25,7.51) v2(160.55,8.09) v2(160.7,7.13) v2(161.03,7.63) v2(161.19,8.35) v2(161.44,7.18) v2(161.62,7.91) v2(161.77,8.55) v2(162.08,7.51) v2(162.18,8.12) v2(162.48,7.08) v2(162.66,7.66) v2(163.09,7.2) v2(166.14,111.7) v2(166.44,113.01) v2(166.45,112.23) v2(166.55,113.71) v2(166.75,114.29) v2(220.78,89.46) v2(221.19,89.05) v2(221.37,89.63) v2(221.66,88.62) v2(221.82,89.22) v2(222.23,88.8) v2(295.97,5.89) v2(295.97,5.31) v2(296.71,5.89) v2(296.71,5.31) v2(297.47,5.89) v2(297.47,5.31) v2(298.29,5.89) v2(298.29,5.31) v2(298.95,5.87) v2(298.95,5.29) v2(323.77,51.98) v2(323.77,51.35) v2(323.85,52.72) v2(324.46,52.72) v2(324.43,51.96) v2(324.43,51.32) v2(324.51,53.35) v2(325.07,51.96) v2(325.07,51.32) v2(325.12,52.62) v2(345.01,48.02) v2(345.01,47.13) v2(345.01,46.24) v2(345.01,45.35) v2(345.01,44.46) v2(345.89,47.13) v2(345.89,46.24) v2(345.89,45.35) v2(345.89,44.46) v2(346.78,47.13) v4(107.83,38.84)
+19.5VB_CHARGER:
  vias: v1(102.75,11.8)
+19.5VB_CPU: length 10.3
  TOP w0.381: PR1150.1 295.51,46.5 295.21,46.8 295.21,49.24 293.65,50.8 PC1217.1 291.35,49.93 v2(291.16,49.74)
  BOTTOM w0.381: v2(291.16,49.74) 291.35,49.93 PC1217.1
  vias: v1(295.49,18.98) v2(286,70.07) v2(286.61,70.07) v2(287.22,70.07) v2(287.83,60.06) v2(287.91,70.04) v2(287.92,49.08) v2(288.34,39.61) v2(288.42,60.05) v2(288.68,70.05) v2(288.92,39.59) v2(289.06,60.05) v2(289.51,39.59) v2(289.66,60.03) v2(289.69,30.2) v2(289.67,29.62) v2(289.66,29.03) v2(289.69,28.45) v2(289.71,30.78) v2(289.91,48.73) v2(290.09,39.61) v2(290.07,18.07) v2(290.14,18.76) v2(290.27,60.03) v2(290.52,48.73) v2(290.7,39.61) v2(290.75,27.24) v2(290.75,18.76) v2(291.13,49.15) v2(291.44,40.6) v2(292.25,18.79) v2(292.86,18.76) v2(293.44,18.76) v2(294.03,18.76) v2(296.84,20.35) v2(296.83,19.71) v2(296.81,19.1) v2(297.42,19.74) v2(297.44,19.15)
+19.5VB_DGFF: length 10.8
  TOP w0.508: QZ19.3 126.06,88.28 126.59,87.75 RZ512.1 ; CZ526.1 130.91,89.02 129.77,90.15 128.08,90.15 127.26,90.97 125.85,90.97
  vias: v1(119.53,89.59)
+19VB_1.2V: length 9.1
  TOP w0.508: PR207.1 108.83,11.79 108.43,11.39 108.43,10.53 v2(108.48,10.48)
  IN1 w0.508: v2(108.48,10.48) 108.48,9.92 109.98,8.42 112.09,8.42 113.05,7.46 113.05,6.31
  vias: v1(122.15,10.11) v2(114.17,6.06) v2(114.17,5.32)
+19VB_1V: length 1.4
  TOP w0.127: 101.57,40.31 v1(100.18,40.31)
+19VB_3V:
  vias: v1(139.24,114.28) v2(138.73,113.46) v2(139.32,113.44) v2(139.91,113.44) v2(140.58,113.46)
+19VB_3VR:
  vias: v1(314.96,9.01)
+19VB_5V:
  vias: v1(58.1,10.81) v2(54.81,10.68) v2(55.57,10.56) v2(56.31,10.56)
+19VB_5VR:
  vias: v1(350.9,45.93)
+19VB_IO:
  vias: v1(311.83,57.05) v2(312.62,55.79) v2(313.26,55.79) v2(313.84,55.82) v2(314.5,55.84)
+20V_TBTA_VBUS: length 124.5
  TOP w0.508: DT62.2 47.2,27.14 46.5,27.85 v2(46.5,28.56)
  IN2 w0.254: v2(14.2,31.05) 13.41,30.27 12.67,30.27 10.97,31.97 10.97,35.32 10.23,36.06 10.23,37.18 9.39,38.02 9.39,47.77 9.41,47.78
  IN2 w0.508: v2(46.5,28.56) 45.72,28.56 45.44,28.84 44.27,28.84 43.51,29.61 42.31,29.61 41.02,30.9 31.6,30.9 30.85,30.15 30.85,30.15 30.68,29.98 30.68,29.05 31.54,28.18 v2(31.62,28.18)
  IN3 w0.508: v2(55.03,25.02) 53.48,25.02 51.64,26.86 48.51,26.86 47.78,27.6 47.46,27.6 v2(46.5,28.56)
  IN4 w0.254: v2(14.2,31.05) 15.76,29.49 15.76,27.84 15.1,27.18 15.1,25.7 15.76,25.04 15.76,22.33 14.42,21 14.42,14.31 12.86,12.75 12.86,10.85 15.49,8.22 16.65,8.22 17.1,8.68 17.1,8.75 17.45,9.1 18.41,9.1 18.46,9.04 19.67,9.04 21.91,11.28 21.91,11.97 22.53,12.59 29.54,12.59 30.98,14.03 30.98,15.53 32.36,16.9 32.36,19.8 v2(32.74,20.18) 32.01,20.91 32.01,22.73 33.69,24.42 33.69,25.78 33.13,26.34 33.04,26.34 31.62,27.75 v2(31.62,28.18)
  BOTTOM w0.229: v2(14.2,31.05) 14.22,31.08 15.04,31.08 16.13,32.17 UT5.D1
  BOTTOM w0.508: v2(31.62,28.18) 31.24,27.8 RT565.1 ; v2(55.03,25.02) 55,25.05 PR2019.2 ; v2(32.74,20.18) 32.74,18.15 33.23,17.66 33.89,17.66 34.41,18.18 34.83,18.18 PR2047.1
  vias: v2(6.68,56.45) v2(6.68,53.52) v2(8.26,55.96) v2(8.39,53.45) v2(8.56,49.99) v2(8.59,49.4) v2(8.85,55.96) v2(8.94,53.45) v2(9.22,49.42) v2(9.43,55.96) v2(9.63,53.12) v2(9.98,49.3) v2(10.02,55.96) v2(10.03,52.69) v2(10.58,52.51) v2(10.57,49.27) v2(10.6,55.96) v2(10.65,48.69) v2(10.64,48.1) v2(10.71,47.52) v2(11.2,48.3) v2(11.28,48.87) v2(11.32,47.66) v2(11.41,49.44) v2(12.14,48.02) v2(12.77,48.02) v4(7.61,53.47)
+20V_TBTB_VBUS: length 107.2
  TOP w0.508: v2(49.25,24.79) 49.41,24.95 49.41,26.37 DT60.2
  IN1 w0.508: v2(51.03,13.68) 51.03,16.19 50,17.22 v2(47.04,17.22)
  IN2 w0.508: v2(32.53,30.16) 32.53,27.59 v2(33.05,27.07) 33.72,26.41 34.97,26.41 35.94,27.37 36.83,27.37 37.39,26.81 39.91,26.81 40.68,27.57 43,27.57 43.58,26.99 44.93,26.99 45.54,27.6 46.66,27.6 49.25,25 v2(49.25,24.79)
  IN3 w0.381: v2(47.04,17.22) 47.04,17.72 47.95,18.63 49.88,18.63 50.24,18.99 50.24,19.67 49.55,20.36 49.12,20.36 48.8,20.68 48.8,23.55 49.25,24 v2(49.25,24.79)
  IN3 w0.508: v2(18.28,37.44) 18.28,37.9 19.76,39.38 19.76,43.11 21.45,44.8 21.45,46.01 20.4,47.07 20.4,51.2 21.22,52.02 21.22,56.17 20.32,57.08 v2(20.32,65.7)
  IN4 w0.508: v2(32.53,30.16) 32.53,32.06 34.02,33.54 34.02,39.21 33.53,39.69 32.24,39.69 31.59,39.04 28.91,39.04 27.51,37.65 26.8,37.65 26.62,37.82 24.7,37.82 23.72,36.84 22.8,36.84 21.64,35.68 19.59,35.68 18.28,36.99 v2(18.28,37.44)
  BOTTOM w0.254: UT5.L3 18.54,35.91 18.28,36.16 v2(18.28,37.44)
  BOTTOM w0.406: PR2020.2 51.61,13.1 v2(51.03,13.68)
  BOTTOM w0.508: v2(47.04,17.22) 46.75,17.22 46.43,17.54 PR2051.1 ; RT566.1 32.42,27.7 v2(33.05,27.07)
  vias: v2(6.68,72.62) v2(6.68,69.69) v2(8.68,69.64) v2(9.16,72.37) v2(9.29,69.64) v2(9.74,72.38) v2(9.75,69.23) v2(10.21,68.77) v2(10.32,72.39) v2(10.61,68.34) v2(10.91,72.4) v2(11.05,67.91) v2(11.52,72.38) v2(11.59,71.78) v2(19.96,68.16) v2(19.99,67.55) v2(20.01,66.89) v2(20.01,66.23) v2(20.31,68.73) v2(20.61,68.16) v2(20.7,67.53) v2(20.65,66.84) v2(20.77,66.11) v2(21.26,67.3) v2(21.21,66.51) v2(21.69,66.87) v4(8.04,72.61)
+20V_VBUS_1: length 1.6
  TOP w0.508: PR28.1 51.18,25.72 50.95,25.49 50.95,25.1 v2(50.8,24.95)
  vias: v1(47.89,31.05) v2(11.63,44.57) v2(11.88,42.94) v2(12.22,44.57) v2(12.52,42.94) v2(12.8,44.57) v2(13.1,42.92) v2(13.15,42.33) v2(13.41,44.52) v2(13.76,42.81) v2(13.99,44.52) v2(14.63,44.49) v2(14.6,43.83) v2(14.6,43.19) v2(39.3,29.5) v2(39.33,28.84) v2(39.33,28.23) v2(39.71,30.03) v2(39.94,29.48) v2(39.99,28.87) v2(39.99,28.23) v2(46.17,29.99) v2(46.17,29.35) v2(46.81,29.99) v2(46.81,29.35) v2(67.9,32.35) v2(68.54,32.35) v2(68.53,31.76) v2(68.53,31) v2(69.17,32.35) v2(69.16,31.76) v2(69.16,31) v2(69.8,31.76) v2(69.8,31) v2(69.81,32.35) v2(70.44,32.35) v2(70.43,31.76) v2(70.43,31)
+20V_VBUS_2: length 4.6
  BOTTOM w0.381: PQ2105.3 41.86,32.45 42.11,32.45 43,33.34 v2(43,33.42)
  BOTTOM w0.508: PQ2105.3 41.02,31.61 41.02,30.93 40.51,30.42 PR2104.1
  vias: v1(69.87,33.85) v2(22.93,63.39) v2(23.44,63.9) v2(23.44,62.94) v2(23.7,62.37) v2(23.82,63.39) v2(23.86,61.79) v2(23.81,61.16) v2(23.95,64.4) v2(24.2,62.88) v2(24.33,63.9) v2(24.38,62.08) v2(24.71,63.39) v2(24.84,62.63) v2(27.1,41.95) v2(27.15,41.35) v2(27.71,42.06) v2(28.32,41.99) v2(28.94,42.06) v2(29.09,41.48) v2(44.02,33.47) v2(44.35,32.78) v2(44.42,32.04) v2(44.9,33.47) v2(45.24,32.78) v2(45.29,32.04) v2(45.79,33.47) v2(46,32.76) v2(68.58,35.86) v2(69.17,35.89) v2(69.19,35.31) v2(69.1,34.73) v2(69.87,34.73) v2(69.94,35.89) v2(69.95,35.31) v2(70.7,35.89) v2(70.63,34.73) v2(70.72,35.31) v2(71.39,34.73) v2(71.46,35.89) v2(71.48,35.31)
+20V_VBUS_DC_SS1: length 7
  TOP w0.508: v2(81.73,30.97) 81.73,30.93 83.39,29.28 83.39,27.45 82.71,26.77 PD700.2
  BOTTOM w0.508: PQ18.5 v2(81.73,30.97)
  vias: v4(77.42,38.97)
+20V_VBUS_DC_SS2:
  vias: v1(77.84,39.36)
+VCC_CORE: length 17.1
  TOP w0.127: UC1.AJ14 239.69,47.17 v2(239.48,47.46)
  TOP w0.152: UC1.AN13 239.16,44.43 239.05,44.54 239.05,44.9 239.16,45 UC1.AM13 239.16,45.35 239.05,45.45 239.05,45.98 UC1.AL13 239.27,46.21 239.27,46.34 v2(239.48,46.55)
  TOP w0.203: UC1.AK34 v2(255.69,46.85) UC1.AJ35 ; UC1.AP35 v2(256.34,43.7) UC1.AN36 ; UC1.AN13 239.45,43.81 v2(239.48,43.8) 239.16,43.48 UC1.AP13 ; UC1.AM35 v2(256.34,45.27) UC1.AL36 ; UC1.AL35 v2(255.69,45.27) UC1.AM34 ; UC1.AL38 v2(258.37,45.34) ; UC1.AN35 v2(255.69,43.7) ; v2(239.48,44.68) UC1.AM13
  TOP w0.254: UC1.K13 239.34,62.78 239.42,62.7 239.42,62.68 239.68,62.42 239.68,62.42 UC1.K14 UC1.L14 239.81,61.49 v2(239.48,61.17) UC1.L13 ; UC1.AH13 239.16,47.79 v2(239.48,47.46) UC1.AH14 v2(239.48,48.38) UC1.AG14 ; UC1.AN14 v2(239.48,44.68) UC1.AM14 ; v2(240.15,49.25) UC1.AG14 ; UC1.AG14 v2(240.22,48.49)
  vias: v2(239.48,59.35) v2(239.48,58.44) v2(239.48,57.51) v2(239.48,55.69) v2(239.48,52.95) v2(239.48,52.04) v2(239.48,51.13) v2(239.54,53.86) v2(240.36,50.05) v2(240.48,53.35) v2(240.43,52.75) v2(240.43,51.96) v2(240.43,51.32) v2(240.43,50.69) v2(240.43,47.9) v2(240.43,47.26) v2(240.43,46.63) v2(240.43,45.86) v2(240.43,45.23) v2(240.43,44.59) v2(240.43,43.83) v2(241.2,43.73) v2(241.74,48.32) v2(241.98,44.88) v2(242.37,48.32) v2(242.85,44.86) v2(243,48.33) v2(243.63,48.33) v2(243.76,44.88) v2(244.26,48.3) v2(244.43,43.54) v2(244.59,44.86) v2(244.93,52.72) v2(244.93,48.3) v2(245.49,44.85) v2(245.51,52.72) v2(245.79,48.31) v2(246.1,52.72) v2(246.32,44.87) v2(246.51,48.29) v2(246.68,52.72) v2(247.31,44.84) v2(247.85,48.78) v2(248.06,45.21) v2(248.61,48.78) v2(249.02,45.16) v2(249.25,48.78) v2(249.37,58.12) v2(249.69,58.63) v2(249.88,48.78) v2(249.87,45.15) v2(250.52,48.78) v2(250.64,45.19) v2(251.49,55.42) v2(251.41,52.36) v2(251.48,45.28) v2(251.49,44.61) v2(251.47,43.94) v2(251.6,47.51) v2(253.1,59.44) v2(253.1,57.08) v2(253.1,54.72) v2(253.08,52.36) v2(253.08,50) v2(253.1,46.85) v2(253.75,59.44) v2(253.75,58.66) v2(253.75,57.08) v2(253.75,56.29) v2(253.75,54.72) v2(253.75,53.93) v2(253.75,52.36) v2(253.75,51.57) v2(253.75,50) v2(253.75,49.21) v2(253.75,48.42) v2(253.75,46.85) v2(253.74,46.06) v2(253.74,45.27) v2(253.74,43.7) v2(254.4,58.66) v2(254.4,56.29) v2(254.4,53.93) v2(254.4,51.57) v2(254.4,49.21) v2(254.39,46.85) v2(254.39,45.27) v2(254.39,43.7) v2(255.05,58.66) v2(255.05,56.29) v2(255.05,53.93) v2(255.05,51.57) v2(255.05,49.21) v2(255.04,46.85) v2(255.7,58.66) v2(255.7,56.29) v2(255.7,53.93) v2(255.7,51.57) v2(255.7,49.21) v2(255.7,48.42) v2(256.35,59.44) v2(256.35,58.66) v2(256.35,57.08) v2(256.35,56.29) v2(256.35,54.72) v2(256.35,53.93) v2(256.35,52.36) v2(256.35,51.57) v2(256.35,50) v2(256.35,49.21) v2(256.34,46.85) v2(257,58.66) v2(257,56.29) v2(257,53.93) v2(257,51.57) v2(257,49.21) v2(256.99,45.27) v2(256.99,43.7) v2(257.65,59.44) v2(257.65,57.08) v2(257.65,54.72) v2(257.65,52.36) v2(257.65,50) v2(258.3,58.66) v2(258.3,56.29) v2(258.3,53.93) v2(258.3,51.57) v2(258.3,49.21) v2(266.6,46.64) v2(266.53,41.94) v2(267.28,41.95) v2(267.34,46.63) v2(267.99,41.96) v2(268.04,46.61) v2(268.68,46.59) v2(268.68,41.97) v2(269.34,46.6) v2(269.31,42) v2(270.03,46.58) v2(270.01,42.02) v2(270.58,51.07) v2(270.58,50.43) v2(270.58,49.8) v2(270.58,49.16) v2(270.66,46.65) v2(270.63,42.04) v2(270.71,45.35) v2(270.71,44.72) v2(270.71,44.08) v2(270.84,55.13) v2(270.84,54.5) v2(270.84,53.86) v2(270.84,53.23) v2(270.86,39.36) v2(270.86,38.34) v2(270.86,37.45) v2(270.86,36.18) v2(270.98,58.79) v2(271.35,51.07) v2(271.35,50.43) v2(271.35,49.8) v2(271.35,49.16) v2(271.47,45.35) v2(271.47,44.72) v2(271.47,44.08) v2(271.6,55.13) v2(271.6,54.5) v2(271.6,53.86) v2(271.6,53.23) v2(271.63,39.36) v2(271.63,38.72) v2(271.63,38.09) v2(271.63,37.45) v2(271.63,36.82) v2(271.63,36.18) v2(271.74,58.79) v2(272.11,51.07) v2(272.11,50.43) v2(272.11,49.8) v2(272.11,49.16) v2(272.23,45.35) v2(272.23,44.72) v2(272.23,44.08) v2(272.26,39.36) v2(272.26,38.72) v2(272.26,38.09) v2(272.26,37.45) v2(272.26,36.82) v2(272.26,36.18) v2(272.37,58.79) v2(272.36,55.13) v2(272.36,54.5) v2(272.36,53.86) v2(272.36,53.23) v2(272.87,51.07) v2(272.87,50.43) v2(272.87,49.8) v2(272.87,49.16) v2(272.9,39.36) v2(272.9,38.72) v2(272.9,38.09) v2(272.9,37.45) v2(272.9,36.82) v2(272.9,36.18) v2(272.87,32.65) v2(272.87,31.64) v2(272.87,30.75) v2(272.87,29.48) v2(273,45.35) v2(273,44.72) v2(273,44.08) v2(273.14,58.79) v2(273.12,55.13) v2(273.12,54.5) v2(273.12,53.86) v2(273.12,53.23) v2(273.53,39.36) v2(273.53,38.72) v2(273.53,38.09) v2(273.53,37.45) v2(273.53,36.82) v2(273.53,36.18) v2(273.63,51.07) v2(273.63,50.43) v2(273.63,49.8) v2(273.63,49.16) v2(273.63,32.65) v2(273.63,32.02) v2(273.63,31.38) v2(273.63,30.75) v2(273.63,30.11) v2(273.63,29.48) v2(273.76,45.35) v2(273.76,44.72) v2(273.76,44.08) v2(273.82,58.77) v2(273.89,55.13) v2(273.89,54.5) v2(273.89,53.86) v2(273.89,53.23) v2(274.14,58.26) v2(274.14,57.67) v2(274.14,57.04) v2(274.14,56.4) v2(274.14,55.77) v2(274.17,39.36) v2(274.17,38.72) v2(274.17,38.09) v2(274.17,37.45) v2(274.17,36.82) v2(274.17,36.18) v2(274.27,51.07) v2(274.27,50.43) v2(274.27,49.8) v2(274.27,49.16) v2(274.27,32.65) v2(274.27,32.02) v2(274.27,31.38) v2(274.27,30.75) v2(274.27,30.11) v2(274.27,29.48) v2(274.2,28.59) v2(274.2,27.95) v2(274.2,27.32) v2(274.2,26.68) v2(274.39,45.35) v2(274.39,44.72) v2(274.39,44.08) v2(274.52,55.13) v2(274.52,54.5) v2(274.52,53.86) v2(274.52,53.23) v2(274.65,58.94) v2(274.77,58.31) v2(274.77,57.67) v2(274.77,57.04) v2(274.77,56.4) v2(274.77,55.77) v2(274.8,39.36) v2(274.8,38.72) v2(274.8,38.09) v2(274.8,37.45) v2(274.8,36.82) v2(274.8,36.18) v2(274.84,28.59) v2(274.84,27.95) v2(274.84,27.32) v2(274.84,26.68) v2(274.9,32.65) v2(274.9,32.02) v2(274.9,31.38) v2(274.9,30.75) v2(274.9,30.11) v2(274.9,29.48) v2(275.09,45.04) v2(275.09,44.4) v2(275.03,35.45) v2(275.03,34.81) v2(275.22,55.13) v2(275.22,54.5) v2(275.22,53.86) v2(275.22,53.23) v2(275.54,32.65) v2(275.54,32.02) v2(275.54,31.38) v2(275.54,30.75) v2(275.54,30.11) v2(275.54,29.48) v2(275.66,35.45) v2(275.66,34.81) v2(275.73,45.04) v2(275.73,44.4) v2(275.85,55.13) v2(275.85,54.5) v2(275.85,53.86) v2(275.85,53.23) v2(276.17,32.65) v2(276.17,32.02) v2(276.17,31.38) v2(276.17,30.75) v2(276.17,30.11) v2(276.17,29.48) v2(276.3,35.45) v2(276.3,34.81) v2(276.36,45.04) v2(276.36,44.4) v2(276.81,32.65) v2(276.81,32.02) v2(276.81,31.38) v2(276.81,30.75) v2(276.81,30.11) v2(276.81,29.48) v2(277,45.04) v2(277,44.4) v2(276.93,35.45) v2(276.93,34.81) v4(272.36,52.2)
+VCC_FUSEPRG: length 27.8
  TOP w0.203: UC1.G30 253.31,64.38 v2(253.38,64.38)
  TOP w0.508: v2(258.89,76.78) 259.52,76.78 260.69,77.96 260.69,80.42 262.47,82.2 RC326.1
  BOTTOM w0.381: v2(258.89,76.78) 258.61,76.5 258.27,76.5 v4(257.54,75.77) 257.54,75.48 258.77,74.25 258.77,72.94 256.61,70.78 256.61,70.78 255.14,69.3 255.14,65.21 254.3,64.38 v2(253.38,64.38)
+VCC_GT: length 14.7
  TOP w0.203: v2(241.34,27.65) 241.67,27.98 UC1.BR16 ; v2(241.34,30.25) 241.67,30.58 UC1.BL16 ; UC1.AT33 254.72,41.8 v2(255.04,42.12) ; UC1.BL17 242.59,30.58 v2(242.92,30.25) ; v2(241.34,29.6) 241.67,29.93 UC1.BM16 ; UC1.BP16 241.67,28.63 v2(241.34,28.3) ; UC1.BD33 254.72,35.5 v2(255.04,35.82) 255.37,35.49 UC1.BD34 ; v2(254.39,33.46) 254.72,33.13 UC1.BG33
  TOP w0.254: UC1.BK20 UC1.BJ20 v2(244.88,32.45) ; v2(248.03,32.45) UC1.BJ24 UC1.BK24 ; v2(247.24,32.45) UC1.BJ23 UC1.BK23 ; 250.16,31.64 UC1.BJ27 ; UC1.BK21 UC1.BJ21 v2(245.67,32.45) ; v2(244.09,32.45) UC1.BJ19 UC1.BK19 ; UC1.BD14 v2(239.48,34.66) UC1.BD13 ; UC1.BJ26 UC1.BK26 ; UC1.BG36 256.67,33.14 v2(256.99,33.46) ; UC1.BL23 v2(247.64,30.9)
  TOP w0.508: v2(262.07,42.05) 262.05,42.03 PR1124.2
  vias: v2(240.12,41.07) v2(240.13,40.15) v2(240.13,39.23) v2(240.13,34.66) v2(240.29,41.96) v2(240.29,36.65) v2(240.31,37.37) v2(241.34,28.95) v2(241.53,36.01) v2(241.57,33.8) v2(242.26,36.08) v2(242.97,33.42) v2(242.91,28.95) v2(243.15,36.08) v2(244.04,36.08) v2(244.93,36.08) v2(245.82,36.08) v2(246.71,36.08) v2(247.25,26.55) v2(247.6,36.08) v2(248.42,30.27) v2(248.61,36.08) v2(249.5,36.08) v2(249.6,32.86) v2(249.98,32.3) v2(250.79,30.9) v2(251.44,35.8) v2(251.53,40.53) v2(251.57,39.91) v2(251.57,35.16) v2(251.53,33.44) v2(253.1,35.82) v2(253.1,33.46) v2(253.74,42.12) v2(253.75,41.33) v2(253.74,40.55) v2(253.74,38.97) v2(253.71,38.2) v2(253.74,37.4) v2(253.74,35.82) v2(253.74,34.25) v2(253.74,32.67) v2(254.39,39.76) v2(254.39,38.18) v2(254.39,35.03) v2(255.04,40.55) v2(255.04,37.4) v2(255.69,39.76) v2(255.69,38.18) v2(255.69,35.03) v2(255.69,33.46) v2(255.69,32.67) v2(256.34,42.12) v2(256.34,40.55) v2(256.34,38.97) v2(256.34,37.4) v2(256.34,35.82) v2(256.34,34.25) v2(256.34,32.67) v2(256.34,31.1) v2(256.99,41.33) v2(256.99,39.76) v2(256.99,36.61) v2(256.99,35.03) v2(257.65,42.12) v2(257.65,38.97) v2(257.65,37.4) v2(257.65,34.25) v2(257.63,32.7) v2(257.63,31.87) v2(258.3,41.33) v2(258.3,39.76) v2(258.3,38.18) v2(258.3,36.61) v2(258.3,35.03) v2(258.4,31.94) v2(258.49,29.38) v2(258.47,28.41) v2(259.08,28.44) v2(259.69,29.35) v2(266.14,29.22) v2(267.15,28.21) v2(267.92,27.45) v2(268.68,26.68) v2(271.54,17.87) v2(271.55,17.22) v2(271.55,16.58) v2(271.55,15.95) v2(271.59,15.2) v2(271.59,14.57) v2(271.59,13.93) v2(272.17,17.87) v2(272.18,17.22) v2(272.18,16.58) v2(272.18,15.95) v2(272.22,15.2) v2(272.22,14.57) v2(272.22,13.93) v2(272.81,17.87) v2(272.82,17.22) v2(272.82,16.58) v2(272.82,15.95) v2(272.86,15.2) v2(272.86,14.57) v2(272.86,13.93) v2(273.44,17.87) v2(273.45,17.22) v2(273.45,16.58) v2(273.45,15.95) v2(273.49,15.2) v2(273.49,14.57) v2(273.49,13.93) v2(274.11,18.06) v2(274.11,17.43) v2(274.11,16.79) v2(274.11,16.16) v2(274.15,15.5) v2(274.15,14.86) v2(274.17,14.18) v2(274.88,17.82) v2(274.88,17.19) v2(274.88,16.55) v2(277.12,14.47) v2(277.12,13.83) v2(277.66,14.85) v2(277.66,14.21) v4(275.69,18.05)
+VCC_SA: length 1.3
  TOP w0.203: UC1.K29 UC1.J30 UC1.K30
  vias: v2(253.09,61.02) v2(253.1,61.81) v2(253.75,61.81) v2(253.74,61.02) v2(254.39,61.81) v2(254.39,61.02) v2(255.04,61.02) v2(255.69,61.81) v2(255.69,61.02) v2(256.34,61.81) v2(256.34,61.02) v2(256.99,61.81) v2(256.99,61.02) v2(258.47,61.65) v2(267.26,62.09) v2(267.84,62.09) v2(268.42,62.09) v2(269.01,62.09) v2(269.59,62.09) v2(270.18,62.09) v2(270.76,62.09) v2(271.35,62.09) v2(271.93,62.09) v2(272.96,64.86) v2(272.96,64.22) v2(273.54,64.86) v2(273.54,64.22) v2(273.72,65.42) v2(274.18,64.86) v2(274.18,64.22) v2(274.3,66.08) v2(274.3,65.49) v2(274.9,64.86) v2(274.81,64.22) v2(274.94,66.08) v2(274.94,65.49) v2(275.49,64.85) v2(275.45,64.22) v2(275.45,63.59) v2(276.08,64.86) v2(276.08,64.22) v2(276.72,64.86) v2(276.72,64.22) v4(271.92,62.82)
+VCC_SFR_OC: length 151.7
  TOP w0.203: v2(238.86,32.83) 238.85,32.71 UC1.BH13
  TOP w0.254: UC1.BH13 239.16,32.19 UC1.BJ13
  TOP w0.305: v2(237.6,63.67) 237.65,63.67 UC1.G11
  IN1 w0.254: v2(240.29,59.51) 240.39,59.42 240.39,55.06 241.04,54.4 241.04,44.87 241.82,44.09 241.82,41.97 241.15,41.3 241.15,38.72 241.02,38.59 v2(241.02,38.42)
  IN1 w0.508: v2(171.4,22.85) 169.7,24.55 169.7,25.31 168.02,26.99 168.02,30.62 164.11,34.53 v2(164.11,36.31)
  IN2 w0.508: v2(241.02,38.42) 241.02,36.52 240.77,36.26 240.77,33.13 241.12,32.77 241.12,31.56 240.5,30.93 240.5,26.92 238.55,24.97 238.55,20.92 237.77,20.14 235.32,20.14 230.87,15.69 199.82,15.69 198.55,14.42 196.35,14.42 195.29,13.36 187.94,13.36 186.18,15.12 183.57,15.12 181.54,17.15 178.67,17.15 177.55,16.03 176.41,16.03 175.69,16.75 175.28,16.75 172.95,19.09 172.95,21.83 171.93,22.85 v2(171.4,22.85)
  BOTTOM w0.203: v2(240.29,59.51) 240.93,59.51 CC210.2 240.93,59.9 240.61,59.9 239.95,60.56 239.95,61.38 239.62,61.71 238.92,61.71 238.73,61.9 238.73,63.05 238.43,63.35 237.92,63.35 v2(237.6,63.67)
  BOTTOM w0.254: CC334.1 239.74,37.78 239.79,37.84 CC209.2 239.95,37.86 240.29,38.2 240.8,38.2 v2(241.02,38.42)
  BOTTOM w0.305: CC334.1 239.74,36.39 240.08,36.05 240.33,36.05 240.73,35.64 240.73,33.53 240.03,32.83 v2(238.86,32.83)
  vias: v4(165.07,36.44)
+VCCRTCEXT: length 5
  TOP w0.254: CH68.1 119.73,22.87 120.19,23.33 120.43,23.33 122.88,25.77 UH1.BG47 UH1.BF47
+VDD_SUPPLY: length 17.2
  IN2 w0.381: v2(13.62,29.07) 13.4,28.85 12.5,28.85 11.34,30.01 10.26,30.01 v2(9.88,30.39)
  BOTTOM w0.254: v2(21.54,31.66) 22.03,31.66 UT5.C10 ; v2(21.54,32.25) 21.96,32.25 UT5.D10
  BOTTOM w0.305: RT535.1 17.69,39.26 v2(17.11,39.26)
  BOTTOM w0.356: RT517.1 16.84,38.98 v2(17.11,39.26) ; v2(19.12,39.64) 19.19,39.58 RT521.1 ; CT345.1 CT344.1 CT346.1 25.87,32.36 v2(25.71,32.2) ; RT522.1 RT519.1 14.43,27.7 13.99,28.14 13.99,28.69 v2(13.62,29.07)
  BOTTOM w0.508: RT525.1 v2(20.39,41.07) ; RT534.1 26.64,39.82 v2(26.81,39.98) ; v2(9.88,30.39) 10.16,30.11 RT526.2
  vias: v1(24.79,41.73) v2(24.92,41.06) v2(25.36,40.68)
+VDDA_AVDD1: length 17.2
  TOP w0.109: LA27.1 383.97,31.91 v1(384.07,32.01)
  TOP w0.203: 383.33,28.01 383.39,27.95 383.39,27.47 382.73,26.82 382.73,25.97 UA1.40
  TOP w0.356: 383.33,28.01 383.32,28.02 CA8.1 383.32,29.39 v2(383.55,29.62)
  TOP w0.508: LA27.1 383.13,31.62 383.55,31.19 CA9.1 v2(383.55,29.62)
  BOTTOM w0.508: v2(383.55,29.62) 383.36,29.43 383.36,28.08 383.77,27.67 383.77,26.13 384.11,25.78 385.24,25.78 386.24,26.79 387.03,26.79 387.75,26.06 RA214.2
+VSS_PLL: length 3.5
  TOP w0.254: 131.41,75.14 131.42,75.16 132.32,75.16 132.84,74.64 UE1.G1
  TOP w0.305: CE17.2 130.68,75.49 CE18.2 130.92,75.41 131.19,75.14 131.41,75.14
DV10: length 6.6
  BOTTOM w0.109: v1(21.88,23.5) 21.99,23.38 CR246.2
  BOTTOM w0.203: UR1.46 18.9,19.73 19.24,20.07
  BOTTOM w0.356: CR246.2 CR245.2 21.66,21.45 21.04,20.83
  BOTTOM w0.508: 21.04,20.83 20.57,20.36 19.53,20.36 19.24,20.07
DV33_18: length 3.6
  BOTTOM w0.356: 14.74,12.66 14.46,12.66 14.1,12.31 14.1,9.58 CR244.2
GND: length 6423.1
  TOP w0.102: v2(153.34,105.35) v4(153.85,105.87) ; 151.33,43.83 150.87,44.29 150.11,44.29 149.76,43.93 148.92,43.93 148.36,43.37 145.29,43.37 145.15,43.23 144.87,43.23 144.66,43.03 UH1.C12 144.52,42.92 144.88,42.56 145.69,42.56 145.84,42.71 150.98,42.71 151.33,43.07 v2(151.33,43.65) 151.33,43.83
  TOP w0.127: DT18.2 v2(12.32,56.29) ; DT18.2 v2(12.86,56.79) ; DT18.2 v2(11.76,56.79) ; v2(10.81,65.19) DT44.2 ; DT44.2 v2(10.81,64.09) ; DT44.2 v2(10.25,64.64) ; DT13.2 v2(16.76,48.44) ; DT13.2 v2(17.31,49) ; DT13.2 v2(16.21,49) ; v4(148.27,111.93) 148.58,111.62 v2(149.57,111.62) ; DT17.2 v2(11.76,58.29) ; DT17.2 v2(12.86,58.29) ; DT17.2 v2(12.32,58.84) ; v2(305.24,13.4) 305.15,13.49 v4(304.45,13.49) ; v2(12.31,64.06) DT45.2 ; DT45.2 v2(12.31,65.19) ; DT45.2 v2(12.86,64.64) ; DT14.2 v2(17.32,50.49) ; DT14.2 v2(16.2,50.49) ; DT14.2 v2(16.76,51.05) ; v2(239.19,62.22) 239.19,62.3 238.9,62.58 238.9,62.63 238.78,62.75 238.78,63.36 UC1.H12 ; DT54.2 v2(14.87,72.24) ; DT54.2 v2(14.32,72.79) ; DT54.2 v2(15.44,72.79) ; v2(14.26,74.29) DT52.2 ; DT52.2 v2(14.87,74.86) ; DT52.2 v2(15.43,74.29) ; v4(322.4,13.67) v2(321.74,13.67)
  TOP w0.152: UH1.BG22 122.73,38.24 122.07,38.24 121.85,38.46 121.72,38.46 121.55,38.64 121.55,38.85 121.39,39.01 121.39,39.18 v2(121.38,39.18) ; UC1.BH2 UC1.BH3 UC1.BH4 UC1.BH5 ; v2(232.32,46.84) 232.32,46.95 UC1.AJ3 ; UH1.F41 143.31,28.82 143.46,28.88 143.52,28.89 143.55,28.9 v2(143.85,29.01) ; v2(139.19,42.74) 139.09,42.84 138.9,42.84 UH1.R12 ; UC1.AF2 232,49.65 v2(232.29,49.35) ; UC1.AF2 UC1.AF1 v2(230.8,49.79) ; UC1.AF2 UC1.AF3 UC1.AF4 233.73,50.22 234.19,50.22 UC1.AE6 ; v2(230.31,39.32) 230.73,39.74 UC1.AW1 UC1.AW2 UC1.AW3 UC1.AW4 UC1.AW5 ; UH1.BC45 124.93,27.12 v2(124.93,27.65) ; UH1.BG28 122.68,34.83 v2(122.5,34.83) ; UH1.P4 139.04,46.8 138.7,46.83 UH1.R4 138.7,46.93 138.73,47.11 UH1.R3 ; UC1.T5 UC1.T4 UC1.T3 ; UH1.U12 137.47,43.36 v2(136.74,44.09) 136.4,44.09 UH1.Y10 ; UH1.E40 143.85,29.48 v2(143.85,29.01) ; v2(128.26,32.95) 128.29,32.98 UH1.AT32 ; v2(128.26,32.95) 128.83,32.39 129.02,32.39 UH1.AR34 UH1.AN34 ; v2(128.26,32.95) 128.29,32.92 UH1.AT34 ; UC1.AJ3 UC1.AJ2 UC1.AJ1 v2(230.8,47.28) ; UC1.AJ3 UC1.AJ4 UC1.AJ5 UC1.AJ6 ; UH1.E35 143.77,31.35 v2(143.82,31.29) ; UH1.K39 140.96,29.87 140.47,29.87 140.37,29.98 v2(140.3,29.98) 139.99,30.29 UH1.N38 ; UH1.BG17 123.19,40.61 123.27,40.53 124.02,40.53 124.49,40.06 v2(124.49,40.05) 124.57,39.97 124.57,39.58 UH1.BC19 ; v2(145.87,35.4) UH1.A28 ; UC1.W5 UC1.W4 UC1.W3 ; UH1.F43 143.42,28.37 UH1.E42 143.69,28.76 v2(143.85,29.01) ; UH1.J29 141.63,34.15 v2(141.81,33.97) ; UH1.V4 136.75,46.47 v2(136.31,46.31) ; UH1.R16 UH1.N16 UH1.M16 140,40.94 v2(139.98,40.55) 139.98,40.14 UH1.M18 ; UH1.E31 143.77,33.53 v2(143.86,33.44) ; UH1.E31 143.96,34.1 144.12,34.21 UH1.C30 ; UH1.E31 UH1.D30 ; UH1.AG1 132.66,48.67 v2(132.66,49.42) ; UC1.N3 UC1.N4 UC1.N5 ; UC1.N3 232.65,59.74 v2(232.32,59.41) ; UC1.N3 UC1.N2 UC1.N1 231.21,59.85 231.21,59.86 230.63,59.86 230.63,59.85 v2(230.57,59.85) ; UH1.P46 139.65,26.67 v2(139.73,26.59) 139.73,26.84 140.06,27.17 140.43,27.17 ; UH1.J46 141.86,26.67 141.93,26.59 ; UH1.E19 143.33,39.07 v2(143.33,38.83) 143.57,38.59 UH1.E22 143.5,38.27 143.5,37.49 143.68,37.31 UH1.E24 ; UC1.AR3 UC1.AR2 UC1.AR1 v2(229.6,42.25) ; UH1.AT24 128.03,36.96 v2(128.03,36.63) ; UC1.K4 233.17,62.37 233.16,62.38 232.78,62.38 232.77,62.37 UC1.K3 ; v2(122.5,32.61) 122.5,32.65 122.7,32.86 UH1.BG33 ; UH1.BG25 122.08,36.73 121.88,36.53 120.76,36.53 v2(120.69,36.59) ; v2(232.34,56.9) 232.65,57.22 UC1.T3 ; v2(141.73,35.57) 141.73,35.98 UH1.J26 ; UC1.BT3 232.64,27.32 v2(232.45,26.72) ; UH1.R34 UH1.N34 139.58,32.38 139.95,32.75 v2(139.95,32.92) 140.13,33.09 UH1.M32 ; UH1.E8 143.85,44.44 v2(143.85,44.41) 143.85,43.98 UH1.E10 ; UH1.AW46 126.56,26.67 v2(126.51,26.72) 126.51,27.05 126.01,27.55 UH1.BA44 ; UH1.M49 140.31,24.5 v2(140.15,24.35) ; 232.38,52.31 UC1.AC2 UC1.AC1 v2(230.8,52.31) ; 232.38,52.31 232.38,51.97 232.31,51.9 v2(232.31,51.86) ; 232.38,52.31 UC1.AC3 UC1.AC4 233.47,52.31 233.48,52.32 233.81,52.32 233.82,52.31 UC1.AC5 ; UH1.R29 138.55,34.72 v2(138.95,35.12) 138.84,35.12 138.48,35.47 138.48,36.12 UH1.R26 ; UH1.E33 143.56,32.94 v2(143.86,33.44) ; UH1.BB41 125.02,28.85 124.55,28.85 v2(124.47,28.93) 124.54,29 124.54,29.46 UH1.BC40 ; UH1.AN16 UH1.AR16 UH1.AT16 ; UH1.N37 139.75,31.15 140.18,31.15 v2(140.23,31.21) ; v2(130.1,49.3) 130.13,49.3 130.34,49.1 UH1.AM1 ; UC1.M13 UC1.M14 ; UH1.J4 141.39,46.79 v2(141.73,46.45) 142.06,46.45 142.41,46.09 UH1.G6 142.15,45.35 UH1.H8 UH1.J9 141.73,44.11 UH1.J10 UH1.K11 140.95,43.57 140.84,43.57 v2(140.54,43.27) 140.03,43.27 139.93,43.17 UH1.N12 ; UH1.C25 143.96,36.3 UH1.E26 143.85,36.08 v2(143.85,35.63) ; UH1.E15 143.84,41.78 v2(143.84,42.26) UH1.E13 ; v2(124.93,27.65) 124.34,27.82 UH1.BD43 124.16,27.75 UH1.BE44 ; v2(124.93,27.65) 125.17,28.13 UH1.BB43 ; 141.93,26.59 141.93,26.89 142.41,27.37 UH1.G44 ; 141.93,26.59 141.51,26.17 UH1.J47 141.49,25.88 141.33,25.73 UH1.J48 ; UC1.K3 232.65,62.25 v2(232.32,61.93) ; UC1.K3 UC1.K2 UC1.K1 230.63,62.37 v2(230.61,62.35) ; v2(127.83,50.48) 127.94,50.36 127.94,50.2 128.11,50.03 UH1.AT1 ; UH1.AT21 v2(128.31,39.29) ; UH1.T7 138.57,45.37 v2(138.81,45.61) ; UH1.BA14 126.07,42.53 v2(126.11,42.56) ; v2(128.19,43.11) 127.48,43.81 UH1.AV11 ; UH1.AR38 128.65,30.17 128.42,30.17 v2(128.31,30.06) 127.9,29.65 UH1.AV39 126.88,29.65 UH1.AW40 ; UH1.AP4 129.24,46.79 129.53,46.49 130.04,46.49 130.21,46.32 130.25,46.32 130.28,46.28 130.54,46.28 130.72,46.46 130.86,46.61 v2(130.86,46.66) 130.99,46.79 UH1.AK4 ; v2(134.95,24.5) 134.53,24.92 UH1.AD49 ; UC1.T3 UC1.T2 UC1.T1 231.25,57.34 231.25,57.34 230.84,57.34 v2(230.38,56.89) ; UH1.C12 144.3,43.03 144.22,42.95 UH1.D12 ; v2(134.47,49.09) 134.47,48.8 UH1.AD1 UH1.AD2 ; v2(135.36,26.61) 135.32,26.61 135.26,26.67 UH1.AC46 ; UH1.AM49 130.45,24.92 130.72,24.65 v2(130.72,24.54) ; v2(137,24.45) 137.79,24.45 138.08,24.74 UH1.T49 ; v2(124.57,44.45) UH1.BC8 ; v2(124.57,44.45) UH1.BB9 ; v2(124.57,44.45) 124.57,43.98 UH1.BC10 ; UC1.BE3 232.52,34.71 232.51,34.72 232.13,34.72 232.12,34.71 UC1.BE2 231.87,34.71 231.86,34.72 231.48,34.72 231.47,34.71 UC1.BE1 231.22,34.71 231.21,34.72 230.84,34.72 v2(230.38,34.26) ; v2(145.97,32.87) 145.96,32.86 145.78,32.86 UH1.A33 ; UH1.AG49 132.53,24.62 v2(132.7,24.45) ; UH1.AA49 135.89,24.66 136.06,24.49 v2(136.07,24.49) ; UC1.BB1 231.48,37.22 231.49,37.22 231.85,37.22 231.86,37.22 UC1.BB2 UC1.BB3 232.77,37.22 232.78,37.24 233.16,37.24 233.17,37.22 UC1.BB4 233.42,37.22 233.43,37.24 233.81,37.24 233.82,37.22 UC1.BB5 UC1.BB6 ; v2(143.86,33.44) 143.84,33.42 143.96,32.94 UH1.D33 ; UH1.M34 140.31,32.25 140.32,32.03 140.23,31.93 v2(140.18,31.87) 140.03,31.71 139.75,31.71 UH1.N35 ; v2(138.94,35.71) 138.94,35.82 UH1.P26 ; UH1.AE4 134.16,46.79 v2(134.25,46.88) ; UH1.AC12 134.91,43.17 135.05,43.17 135.25,43.37 v2(135.38,43.37) 135.48,43.47 135.88,43.47 UH1.Y12 ; UH1.AM18 UH1.AK19 v2(130.72,39.44) UH1.AK20 UH1.AL21 ; UH1.AA5 135.45,46.8 v2(135.34,46.87) 135.26,46.79 UH1.AC4 ; v2(146.08,30.66) UH1.A37 ; UH1.AL17 130.96,40.85 131.27,40.8 v2(131.49,40.5) 131.75,40.76 UH1.AH17 ; v2(230.42,54.38) 230.78,54.82 UC1.W1 231.65,54.82 231.87,54.82 UC1.W2 UC1.W3 ; v2(131.5,39.44) UH1.AJ19 v2(132.27,39.44) ; UH1.Y9 136.49,44.73 136.82,44.73 v2(136.93,44.61) ; UH1.V46 137.25,26.67 v2(137.48,26.9) ; UC1.W3 232.65,54.71 v2(232.32,54.38) ; v2(132.92,27.38) UH1.AE46 ; UH1.D8 144.22,44.95 145.45,44.95 UH1.A8 145.6,45.03 145.62,45.01 146.14,45.01 146.14,45.01 147.26,46.13 147.26,46.27 147.45,46.45 v2(147.45,46.57) ; UH1.BG37 122.68,30.66 122.59,30.75 v2(122.27,30.75) ; UH1.BC13 v2(124.57,42.25) 124.57,41.78 UH1.BC15 ; UC1.BM5 233.45,29.41 UC1.BN4 ; UH1.BC35 124.65,31.86 124.93,32.14 124.93,32.58 125.24,32.88 125.24,33.04 124.86,33.42 v2(124.66,33.42) 124.57,33.5 124.57,33.88 UH1.BC31 ; v2(127.86,40.42) UH1.AT18 ; UH1.P29 v2(139.66,34.33)
  TOP w0.203: UC1.BF33 254.72,33.93 v2(255.04,34.25) 255.37,33.92 UC1.BF34 ; PU1202.14 287.85,33.79 287.69,33.63 287.67,33.63 287.41,33.37 287.41,33.31 287.27,33.17 v2(287.25,33.17) ; UC1.D30 252.74,66.25 252.6,66.25 UC1.C29 252.13,66.65 v2(251.81,66.98) ; v2(236.88,46.55) UC1.AL10 ; v2(236.88,46.55) 236.28,46.55 v2(236.23,46.59) ; v2(236.88,46.55) UC1.AL9 ; v2(236.88,46.55) v2(237.53,46.55) UC1.AL10 ; UC1.AL10 UC1.AL9 ; v2(236.95,57.52) v2(236.31,57.52) 236.31,57.47 UC1.T8 ; v2(236.95,57.52) 237.09,57.27 UC1.T10 ; v2(236.95,57.52) v2(237.58,57.53) ; v2(236.95,57.52) UC1.T9 ; v2(236.94,38.32) UC1.BA9 ; v2(236.94,38.32) v2(236.3,38.32) ; v2(236.94,38.32) v2(237.57,38.32) ; v2(236.94,38.32) UC1.BA10 ; UC1.BA9 UC1.BA10 ; UC1.BA9 UC1.BA8 ; UC1.BA9 v2(236.3,38.32) ; UH1.C4 144.89,46.8 v2(144.98,46.66) ; UC1.AA12 238.51,53.54 v2(238.83,53.86) 239.16,54.19 239.16,54.32 UC1.Y13 ; 132.27,35.57 UH1.AJ27 ; UH1.AJ27 v2(132.27,36.34) ; UH1.AJ27 131.49,36.35 v2(131.49,36.36) ; UC1.AY12 238.41,38.63 238.33,38.5 v2(238.21,38.32) ; UC1.AY12 v2(238.84,38.32) UC1.BA12 ; UC1.AY12 238.51,38.91 238.77,39.17 238.77,39.43 UC1.AW12 238.77,39.95 238.77,40.34 UC1.AU12 UC1.AU11 ; UC1.AG30 UC1.AG29 ; v2(232.6,66.71) 232.68,67.22 UC1.B3 UC1.A3 v2(233.06,68.53) UC1.A4 ; v2(232.6,66.71) 232.05,66.6 UC1.C2 ; v2(232.6,66.71) 232.55,66.17 UC1.D3 232.85,65.86 232.85,65.83 UC1.E4 ; UC1.BH9 v2(236.31,32.83) ; UC1.BH9 UC1.BH10 ; UC1.BH9 v2(236.95,32.83) ; UC1.BH9 UC1.BH8 ; v2(236.31,32.83) UC1.BH8 ; v2(236.31,32.83) v2(236.95,32.83) ; UC1.D38 258.39,65.86 v2(258.49,65.95) ; UC1.AF13 UC1.AF14 239.48,50.07 v2(239.48,50.22) ; UC1.AF13 UC1.AF12 238.83,50.07 v2(238.83,50.21) ; UC1.AF13 239.16,49.67 239.41,49.42 239.41,49.09 UC1.AG13 238.82,48.49 v2(238.82,48.38) 238.64,48.2 238.64,48.19 238.51,48.06 UC1.AH12 238.51,47.77 v2(238.82,47.46) 238.82,47.35 UC1.AJ13 239.16,46.87 v2(238.83,46.55) 238.83,46.42 UC1.AL12 238.77,45.83 238.77,45.44 UC1.AM12 238.77,44.92 238.77,44.52 UC1.AN12 ; UC1.N6 v2(234.27,59.41) 234.6,59.08 UC1.P6 ; UC1.N6 234.56,59.89 233.99,59.89 UC1.N5 ; UC1.N6 UC1.M6 ; UC1.N6 234.95,59.85 235,59.81 UC1.N7 UC1.N8 UC1.N9 ; v2(236.88,52.03) 237.03,51.83 UC1.AD10 ; v2(236.88,52.03) v2(237.53,52.03) ; v2(236.88,52.03) 236.74,51.83 UC1.AD9 ; v2(236.88,52.03) v2(236.23,52.03) ; v2(238.21,38.32) 238.33,38.14 UC1.BA12 ; v2(238.21,38.32) UC1.BA11 ; v2(238.21,38.32) v2(237.57,38.32) ; UC1.BH5 234.04,32.19 234.08,32.23 234.46,32.23 234.5,32.19 UC1.BH6 ; UC1.BD6 UC1.BC6 234.27,36.71 v2(234.27,36.78) 234.6,37.11 UC1.BB6 ; UC1.BD6 234.85,35.29 234.85,35.13 ; UC1.BD6 234.6,35.43 v2(234.27,35.1) 234.27,35.03 UC1.BE5 ; v2(254.39,41.33) 254.72,41.01 UC1.AU33 ; v2(237.33,68.45) 237.24,68.36 UC1.A10 ; UC1.BH6 UC1.BG6 UC1.BF6 UC1.BE6 ; UC1.BH6 234.6,32.1 v2(234.27,31.77) 234.27,31.68 UC1.BK6 UC1.BL6 UC1.BM6 ; UC1.BH6 234.78,32.37 UC1.BH7 UC1.BH8 ; UC1.AU10 237.06,40.87 v2(236.95,41.06) ; UC1.AU10 UC1.AU11 ; UC1.AU10 UC1.AU9 ; UC1.AU10 237.42,40.87 v2(237.58,41.07) ; UC1.BH10 v2(236.95,32.83) ; UC1.BH10 v2(237.58,32.84) ; UC1.BH10 UC1.BH11 ; v2(236.95,32.83) v2(237.58,32.84) ; v2(237.57,38.32) UC1.BA11 ; v2(237.57,38.32) UC1.BA10 ; UC1.BA11 UC1.BA10 ; UC1.BA11 UC1.BA12 ; v2(238.22,43.8) 238.18,43.75 UC1.AP11 v2(237.58,43.81) ; v2(238.22,43.8) UC1.AN12 ; v2(238.22,43.8) 237.59,43.8 v2(237.58,43.81) ; v2(238.22,43.8) 238.25,43.75 238.33,43.63 UC1.AP12 238.81,43.75 v2(238.85,43.8) UC1.AN12 ; UC1.C9 236.49,66.65 v2(236.8,66.34) 237.14,66 UC1.D10 ; UC1.AD11 UC1.AD10 ; UC1.AD11 237.68,51.83 v2(237.53,52.03) ; UC1.AD11 238.04,51.83 v2(238.18,52.03) ; UC1.AD11 UC1.AD12 ; UC1.AD10 UC1.AD9 ; UC1.AD10 237.39,51.83 v2(237.53,52.03) ; UC1.BP24 248.1,28.69 248.1,29.21 UC1.BN24 ; v2(240,66.33) 239.67,66.65 UC1.C13 ; UC1.AD9 UC1.AD8 ; UC1.AD9 236.38,51.83 v2(236.23,52.03) ; UC1.N9 UC1.N10 ; UC1.N9 v2(236.95,60.26) ; UC1.AL9 UC1.AL8 ; UC1.AL9 236.56,46.13 v2(236.23,46.59) ; v2(143.18,41.49) 143.23,41.49 143.52,41.2 UH1.D16 144.02,40.99 UH1.D17 143.78,40.75 UH1.E17 ; v2(254.44,63.38) 254.72,63.1 UC1.J33 ; v2(254.44,63.38) 254.07,63.75 UC1.H32 254.07,64.33 253.77,64.63 UC1.F31 253.71,64.7 v2(253.38,65.03) ; v2(254.44,63.38) 254.07,63.01 UC1.J32 ; UH1.BA6 UH1.BA5 126.06,46.77 126.44,47 v2(126.53,46.97) 126.95,46.91 UH1.AW4 ; UC1.BN34 255.17,29.28 v2(255.5,28.95) 255.39,28.95 255.12,28.68 UC1.BP34 UC1.BR34 ; UC1.BC34 255.37,36.29 v2(255.69,36.61) ; UC1.T11 237.73,57.27 v2(237.58,57.53) ; UC1.T11 UC1.T12 ; UC1.T11 UC1.T10 ; UC1.T11 238.02,57.27 v2(238.22,57.52) ; v2(240.26,68.49) 240.39,68.36 UC1.A14 ; v2(239.71,30.96) UC1.BL13 ; v2(239.71,30.96) UC1.BK13 ; v2(239.71,30.96) UC1.BK14 ; v2(239.71,30.96) UC1.BL14 v2(239.76,30.25) ; UC1.BL13 239.05,30.25 v2(238.98,30.25) ; UC1.BL13 v2(239.76,30.25) ; v2(254.39,42.91) 254.72,42.58 UC1.AR33 ; UC1.BA6 UC1.BB6 ; UC1.BB6 234.98,37.61 235.01,37.61 UC1.BA7 UC1.BA8 ; v2(237.53,52.03) v2(238.18,52.03) ; UH1.A2 UH1.A3 UH1.A4 UH1.A5 ; v2(239.76,29.6) UC1.BM14 v2(239.76,30.25) ; v2(239.76,29.6) UC1.BM13 v2(238.98,30.25) ; v2(239.76,29.6) UC1.BN14 v2(239.76,28.95) UC1.BP14 v2(239.76,28.3) UC1.BR14 ; UC1.AU9 v2(236.31,41.06) ; UC1.AU9 v2(236.95,41.06) ; UC1.AU9 UC1.AU8 ; v2(236.31,41.06) 236.14,40.87 UC1.AU8 ; v2(236.31,41.06) v2(236.95,41.06) ; v2(236.3,38.32) UC1.BA8 ; v2(152.14,119.15) 152.14,119 151.69,118.55 UV64.57 ; UC1.BN7 UC1.BP7 v2(235.83,28.3) ; UC1.BN7 v2(234.9,29.35) 234.52,29.72 UC1.BM6 ; UC1.BN7 UC1.BM7 235.69,29.68 235.97,29.68 UC1.BM8 236.47,29.68 236.76,29.68 UC1.BM9 237.13,30.05 237.68,30.05 UC1.BM11 237.86,29.93 v2(238.19,29.6) ; v2(236.95,41.06) v2(237.58,41.07) ; v2(237.58,41.07) 237.7,40.87 UC1.AU11 ; UC1.M12 UC1.M13 ; v2(238.22,57.52) 237.59,57.52 v2(237.58,57.53) ; v2(238.22,57.52) 238.33,57.35 238.38,57.27 UC1.T12 ; v2(238.19,29.6) 238.26,29.6 UC1.BN12 238.53,29.23 238.53,29.15 238.52,29.14 238.52,28.76 238.53,28.75 238.53,28.68 UC1.BP12 UC1.BR12 UC1.BT12 238.59,27.32 v2(238.71,26.73) ; v2(238.19,29.6) 238.33,29.71 UC1.BM12 v2(238.98,30.25) ; UC1.A26 v2(249.84,68.56) ; v2(144.03,46.23) UH1.C5 ; UC1.BJ35 255.96,31.56 255.44,31.56 UC1.BJ34 ; UC1.BA12 238.83,37.4 UC1.BB12 v2(238.82,36.49) 238.51,36.18 UC1.BC12 ; UC1.M14 239.81,60.59 v2(239.48,60.26) ; UV64.33 158.42,120.7 v2(158.7,120.42) ; UC1.AD8 UC1.AD7 235.09,51.83 v2(234.97,52.02) ; UC1.AD8 236.09,51.83 v2(236.23,52.03) ; UC1.BP29 252.03,28.68 252.03,29.22 UC1.BN29 UC1.BM29 UC1.BL29 252.18,30.79 UC1.BK29 252.58,31.63 UC1.BJ30 252.7,31.49 v2(253.09,31.1) 253.42,31.43 UC1.BJ31 ; UC1.BJ29 251.52,32.12 v2(251.52,32.31) ; UC1.T12 238.66,57.27 v2(238.85,57.52) UC1.R12 v2(238.83,58.44) UC1.P12 v2(238.83,59.35) UC1.N12 ; UC1.T12 UC1.T13 ; UC1.L34 255.37,61.48 v2(255.04,61.81) 254.72,61.49 UC1.L33 ; UC1.T10 237.38,57.27 v2(237.58,57.53) ; UC1.T10 UC1.T9 ; UC1.BD8 236.31,35.52 v2(236.31,35.58) ; UC1.BD8 UC1.BD9 ; UC1.BD8 UC1.BD7 234.86,35.12 234.85,35.13 ; UC1.BH12 UC1.BH11 ; UC1.BH12 238.33,32.12 v2(238.18,31.92) 238.33,31.8 UC1.BJ12 ; UC1.BH12 v2(238.22,32.83) ; UC1.BH11 v2(238.22,32.83) ; UC1.BH11 v2(237.58,32.84) ; UC1.A12 238.81,67.97 238.74,68.04 v2(238.74,68.52) ; UC1.C5 234.09,66.75 234.51,67.17 234.51,67.44 234.89,67.82 UC1.A6 234.9,67.96 234.9,68.38 v2(234.95,68.43) ; UH1.C48 143.58,25.36 UH1.F47 ; v2(240.13,35.58) 239.81,35.9 UC1.BC14 UC1.BC13 UC1.BC12 ; UC1.A16 241.96,68.51 v2(241.91,68.57) ; v2(251.42,68.46) 251.41,68.46 UC1.A28 ; UC1.AR13 239.16,42.57 v2(239.48,42.89) 239.81,42.57 UC1.AR14 ; v2(331.21,20.04) 331.39,20.04 331.61,19.83 UZ9.11 ; 131.63,32.26 v2(131.57,32.26) 132.02,32.7 UH1.AH33 132.21,32.69 UH1.AE33 UH1.AC33 134.79,33.44 UH1.AB31 ; v2(158.44,115.71) 158.42,115.74 UV64.18 ; v2(234.97,52.02) UC1.AD6 234.43,51.3 234.32,51.2 234.32,50.91 UC1.AE6 ; v2(234.97,52.02) UC1.AC6 ; UC1.G22 246.62,64.05 v2(246.3,64.38) 245.97,64.7 UC1.F21 245.83,64.7 v2(245.51,64.38) ; v2(237.58,32.84) v2(238.22,32.83) ; v2(238.22,32.83) UC1.BG12 UC1.BG13 ; UC1.BB29 UC1.BB30 v2(253.1,36.61) ; UC1.A20 245.11,68.61 v2(245.15,68.65) ; UC1.AP9 UC1.AP8 ; UC1.AP9 236.3,43.75 v2(236.26,43.8) ; UC1.AP9 236.9,43.75 v2(236.95,43.8) ; UC1.AP8 235.47,43.79 235.12,43.79 234.98,43.93 UC1.AN6 234.55,43.88 UC1.AN5 233.62,44.2 v2(233.62,44.37) 233.95,44.7 UC1.AM5 ; UC1.AP8 v2(236.26,43.8) ; v2(235.83,28.3) 235.83,27.49 UC1.BT8 ; v2(235.83,28.3) UC1.BR7 ; 234.85,35.13 234.85,34.96 UC1.BE6 ; UC1.BC12 v2(238.22,35.58) ; UC1.Y10 v2(236.88,54.78) ; UC1.Y10 UC1.Y11 ; UC1.Y10 UC1.Y9 ; v2(236.88,54.78) UC1.Y9 ; v2(236.88,54.78) v2(236.23,54.78) ; UC1.Y14 UC1.Y13 ; UC1.Y13 238.83,54.65 v2(238.83,54.78) UC1.W12 v2(238.83,55.69) 238.76,55.79 UC1.V12 ; UC1.Y9 v2(236.23,54.78) ; UC1.Y9 UC1.Y8 ; v2(236.23,54.78) UC1.Y8 ; v2(239.48,56.63) 239.81,56.95 UC1.T14 ; v2(255.04,48.42) 255.17,48.27 UC1.AH34 ; UC1.BP18 UC1.BR18 UC1.BT18 243.21,27.33 v2(242.64,26.76) ; UC1.BM6 UC1.BM5 v2(233.42,30.06) UC1.BM3 ; UC1.AL8 UC1.AL7 234.95,46.4 234.95,46.59 234.85,46.69 234.85,47.03 UC1.AJ6 UC1.AH6 UC1.AG6 v2(234.87,49.35) UC1.AG7 UC1.AG8 ; UC1.AL8 235.9,46.12 v2(236.23,46.59) ; v2(138.81,45.61) 138.81,44.46 138.48,44.13 138.48,43.77 137.86,43.15 UH1.U12 ; UC1.N12 UC1.N11 UC1.N10 ; UC1.N12 v2(238.85,60.26) ; UC1.N12 v2(238.22,60.26) 237.59,60.26 v2(237.58,60.27) ; UC1.AC6 UC1.AB6 234.6,53.42 235.02,53.85 235.02,54.09 UC1.Y7 UC1.Y8 ; UC1.AC6 234.48,52.31 234.46,52.32 234.08,52.32 234.07,52.31 UC1.AC5 ; UC1.BM3 UC1.BN4 ; UC1.BM3 UC1.BM2 v2(231.8,29.82) UC1.BN2 ; UC1.AU8 UC1.AU7 ; UC1.AU7 234.63,40.6 UC1.AU6 234.35,40.32 234.35,40.14 UC1.AW5 ; UC1.AU7 235.01,40.86 235.01,41 UC1.AT6 ; v2(230.61,32.39) 231.06,31.94 UC1.BH1 231.74,31.94 UC1.BH2 232,32.14 232.32,31.82 v2(232.32,31.75) ; UC1.AL34 255.37,45.6 v2(255.04,45.27) 254.72,45.59 UC1.AL33 ; v2(253.07,43.72) 253.07,43.72 252.72,44.08 UC1.AN30 UC1.AN29 ; UC1.K38 258.41,62.2 v2(258.5,62.29) ; UC1.BT26 v2(249.61,26.55) ; UC1.N10 v2(236.95,60.26) ; UC1.N10 v2(237.58,60.27) ; UH1.AT45 128.27,26.88 128.41,27.02 128.89,27.02 UH1.AP46 129.24,26.71 129.54,27.02 130.08,27.02 130.35,27.29 130.35,27.58 130.81,28.04 130.81,28.29 131.2,28.68 v2(131.33,28.68) ; v2(236.95,43.8) 236.98,43.75 UC1.AP10 v2(237.58,43.81) ; v2(236.95,43.8) v2(237.58,43.81) ; v2(236.95,43.8) v2(236.26,43.8) ; UC1.BD9 v2(236.31,35.58) ; UC1.BD9 v2(236.95,35.58) ; UC1.BD9 UC1.BD10 ; UH1.D12 143.78,42.95 UH1.E13 ; UC1.BE5 234.06,34.59 234.48,34.59 UC1.BE6 ; UC1.BE5 233.82,34.71 233.81,34.72 233.43,34.72 233.42,34.71 UC1.BE4 233.17,34.71 233.16,34.72 232.78,34.72 232.77,34.71 UC1.BE3 232.65,34.59 v2(232.32,34.26) ; UH1.R16 138.18,41.08 v2(137.97,41.29) 137.63,41.63 UH1.U15 ; v2(236.95,35.58) v2(237.58,35.58) ; v2(236.95,35.58) UC1.BD10 ; v2(236.95,35.58) v2(236.31,35.58) ; v2(237.58,35.58) v2(238.22,35.58) ; v2(237.58,35.58) UC1.BD10 ; v2(237.58,35.58) UC1.BD11 ; UC1.BP33 254.11,28.63 253.54,29.2 UC1.BN31 ; v2(233.62,63.61) 233.62,63.53 UC1.J4 UC1.K4 233.42,62.37 233.43,62.38 233.81,62.38 233.82,62.37 UC1.K5 ; UV64.8 v2(154.42,115.75) ; v2(238.18,49.29) UC1.AG11 v2(237.53,49.29) UC1.AG10 ; v2(253.19,68.46) UC1.A30 ; UH1.J46 141.27,26.78 140.88,27.17 140.43,27.17 ; UC1.AR38 257.97,42.59 v2(258.3,42.91) ; UH1.BC24 UH1.BC26 124.65,36.13 125.11,35.68 126.69,35.68 127.25,35.12 127.9,35.12 v2(128.38,35.61) ; v2(295.89,81.21) 295.76,81.34 UV8.52 ; UC1.T8 UC1.T9 ; UC1.T8 UC1.T7 235.01,56.81 234.91,56.81 UC1.U6 UC1.V6 234.35,55.41 234.35,55.22 UC1.W5 ; v2(299.34,76.43) 299.37,76.46 UV8.11 ; UC1.BC33 254.72,36.28 v2(254.39,36.61) ; UC1.BG13 UC1.BF12 v2(238.8,34.66) UC1.BD12 ; UC1.BG13 UC1.BG14 ; UC1.AM38 257.97,44.94 v2(257.65,45.27) ; UH1.T4 138.23,46.81 UH1.T5 138.01,46.26 v2(137.87,46.12) ; UC1.E38 257.68,65.06 257.54,64.92 v2(257.01,64.92) 256.67,64.59 UC1.F36 256.34,64.23 256.34,64.17 256.02,63.85 UC1.H35 ; v2(240.12,33.75) 239.81,33.44 UC1.BG14 ; v2(246.69,62.17) UC1.J22 ; UC1.BB3 232.65,37.11 v2(232.32,36.78) ; v2(251.57,34.33) 251.88,34.64 UC1.BE29 ; v2(257,57.08) 257.32,56.76 UC1.U37 257.65,56.36 ; UC1.AL14 239.81,45.96 v2(239.48,45.63) ; PU200.3 v2(113.17,15.57) ; UH1.AL26 130.92,36.15 UH1.AK27 ; UC1.AM4 233.23,44.77 233.16,44.83 232.78,44.83 232.71,44.77 UC1.AM3 UC1.AM2 UC1.AM1 v2(230.86,44.77) ; v2(249.21,30.25) 249.54,29.93 UC1.BM26 ; v2(302.44,78.67) 302.57,78.55 UV8.19 ; UC1.AR35 256.02,42.58 v2(255.69,42.91) 255.37,42.59 UC1.AR34 ; UC1.F15 241.18,64.65 240.97,64.45 240.79,64.45 UC1.G14 240.64,63.8 240.64,63.73 240.78,63.59 240.78,62.54 240.55,62.31 240.54,62.31 v2(240.39,62.15) ; v2(72.46,21.48) 72.59,21.6 72.59,21.89 72.45,22.03 PU700.22 ; UC1.BD12 v2(238.22,35.58) ; UC1.BD12 UC1.BD11 ; v2(238.83,52.95) 238.52,52.5 UC1.AC12 v2(238.83,52.01) v2(238.18,52.03) ; UC1.AY34 255.37,38.64 v2(255.04,38.97) 254.72,38.65 UC1.AY33 ; UC1.BT4 233.36,26.85 v2(233.3,26.72) ; UC1.BD11 v2(238.22,35.58) ; UC1.BD11 UC1.BD10 ; v2(136.74,44.09) 136.93,44.27 v2(136.93,44.61) 137.68,45.37 UH1.T7 ; UZ40.11 v2(367.61,34.56) ; UC1.G23 247.4,64.05 v2(247.08,63.73) ; v2(135.37,36.29) 135.71,35.96 UH1.AA27 ; UC1.AP33 254.72,43.38 v2(255.04,43.7) 255.37,43.37 UC1.AP34 ; UC1.BG14 UC1.BH14 ; UH1.AK28 131.11,35.19 v2(131.49,35.57) ; v2(245.67,26.55) UC1.BT21 ; UC1.AR3 232.66,42.26 233.16,42.26 233.17,42.25 UC1.AR4 233.43,42.25 233.44,42.25 233.8,42.25 UC1.AR5 ; v2(236.95,60.26) v2(237.58,60.27) ; UC1.AK29 UC1.AK30 252.72,46.44 v2(253.1,46.06) ; UC1.BT5 234.16,26.77 v2(234.24,26.68) ; UZ44.11 v2(148.03,105.57) ; UC1.F29 251.8,64.3 251.66,64.3 UC1.G28 ; v2(248.66,64.38) 248.98,64.7 UC1.F25 ; v2(255.69,41.33) 255.37,41.01 UC1.AU34 ; UC1.F27 250.37,64.45 250.37,64.3 250.26,64.2 250.26,63.76 250.23,63.73 v2(250.19,63.73) 250.16,63.73 UC1.G26 ; UH1.P4 139.65,46.79 v2(139.73,46.87) 140.01,46.59 UH1.M5 ; UH1.AJ28 UH1.AK30 ; UC1.AW29 UC1.AW30 ; PU200.14 113.57,12.18 v2(113.17,12.58) ; v2(232.32,46.84) 232.85,46.84 UC1.AK4 233.14,46.23 233.14,45.81 UC1.AL4 ; v2(154.33,120.42) 154.72,120.42 155.22,120.92 UV64.41 ; UC1.BT32 v2(254.27,26.55) ; v2(113.17,13.82) 113.65,13.82 113.97,14.15 PU200.1 ; UC1.AY14 v2(240.37,38.68) ; UC1.AW3 232.65,39.62 v2(232.32,39.29) ; v2(257,59.44) 257,59.38 UC1.P37 257.65,58.73 ; UH1.W28 UH1.W27 ; UC1.F17 242.68,64.7 v2(242.36,64.38) ; UC1.L30 UC1.L29 251.65,61.41 v2(251.5,61.25) ; UC1.BN21 246,29.6 v2(246.06,29.6) UC1.BM21 ; v2(248.37,68.63) 248.26,68.52 UC1.A24 ; UC1.AT30 UC1.AT29 ; UC1.A22 v2(246.69,68.59) ; UZ41.11 v2(298.4,67.45) ; UC1.B9 UC1.A9 ; v2(253.38,66.98) 253.71,66.65 UC1.C31 254.17,66.25 254.31,66.25 UC1.D33 254.89,65.67 254.95,65.67 255.27,65.35 UC1.E34 255.43,65.43 255.94,65.43 UC1.E35 ; UC1.BN20 244.56,28.95 v2(244.49,28.95) 244.16,29.28 UC1.BN19 ; UC1.BR9 v2(237.4,28.3) ; UC1.A18 v2(243.54,68.61) ; UH1.AJ30 131.89,34.43
  TOP w0.254: CT314.2 34.4,45.33 35.12,44.6 CT300.2 ; UC1.G5 233.62,63.68 v2(233.62,63.61) UC1.G4 UC1.F4 ; v2(257,52.36) 257.17,52.19 257.17,52.16 257.32,52 UC1.AC37 257.32,51.93 257.42,51.83 257.48,51.77 257.48,51.74 v2(257.65,51.57) 257.65,51.64 UC1.AC38 258.3,52.29 v2(258.3,52.36) ; 255.05,54.79 UC1.W33 254.4,54.79 v2(254.4,54.72) ; 255.05,54.79 UC1.W34 255.7,54.79 v2(255.7,54.72) ; 255.05,54.79 v2(255.05,54.72) ; 196.52,71.73 JDIMM4.217 ; UH1.BF2 UH1.BF1 123.01,48.78 122.61,48.78 v2(122.37,48.54) ; UH1.BF2 UH1.BG2 ; UH1.BF2 UH1.BF3 123.08,47.19 UH1.BG4 122.86,47.19 122.27,47.77 122.27,48.45 v2(122.37,48.54) ; v2(257.65,58.66) 257.65,58.73 UC1.P38 258.3,59.38 v2(258.3,59.44) ; UC1.H12 238.72,63.5 238.72,63.96 UC1.G12 238.75,64.05 v2(238.42,64.38) 238.1,64.7 UC1.F11 ; UC1.BT35 255.85,27.32 v2(256.29,26.76) 256.65,27.32 UC1.BT36 UC1.BR36 ; v2(253.1,51.57) 253.1,51.52 252.72,51.19 UC1.AD30 UC1.AD29 v2(251.48,51.71) ; v2(41.22,23.51) 40.99,23.51 40.67,23.18 39.87,23.18 UT9.4 ; v2(172.16,80.02) 172.16,80.23 172.41,80.48 JDIMM2.252 ; 132.27,35.57 UH1.AJ28 132.27,34.79 ; 132.27,35.57 UH1.AG27 ; 132.27,35.57 UH1.AG28 132.27,34.79 ; v2(131.5,34.02) UH1.AK31 UH1.AM32 ; v2(131.5,34.02) UH1.AJ31 132.27,34.02 ; v2(131.5,34.02) UH1.AJ30 ; v2(131.5,34.02) UH1.AK30 UH1.AL29 ; v2(334.46,54.32) 334.69,54.55 JUSH1.17 ; UC1.A34 255.81,68.46 v2(255.75,68.52) ; v2(244.72,63.73) 245.04,64.05 UC1.G20 ; UH1.AG25 v2(132.27,36.34) ; UH1.AG25 132.27,37.12 ; UH1.AG25 132.7,36.73 v2(133.08,37.11) ; v2(132.27,36.34) UH1.AJ25 ; v2(132.27,36.34) UH1.AG27 ; UC1.BN31 253.24,28.97 v2(253.16,28.97) 253.06,28.97 UC1.BN30 ; UC1.BR24 v2(247.64,27.65) UC1.BT24 ; UC1.BR24 UC1.BR25 UC1.BP25 ; UC1.BR24 248.03,28.01 248.12,28.1 248.12,28.5 248.03,28.59 UC1.BP24 ; v2(254.4,57.08) 254.4,57.15 UC1.T33 255.05,57.15 ; v2(248.68,32.4) 248.82,32.26 UC1.BJ25 ; v2(250.22,66.37) 250.22,66.36 249.86,66 UC1.D26 249.52,66.32 249.38,66.32 UC1.C25 ; v2(257.65,35.82) 257.65,35.76 ; 257.65,35.76 257.65,35.75 UC1.BD37 ; 257.65,35.76 UC1.BD38 ; UC1.BM29 UC1.BM28 v2(250.79,30.25) UC1.BM27 250.4,29.92 249.99,29.51 ; UH1.T18 137.89,39.64 UH1.V20 137.62,38.75 UH1.U21 138.07,38.46 v2(138.07,38.34) 138.01,38.28 UH1.V22 ; v2(136.14,34.8) 135.76,34.43 UH1.AA30 v2(135.37,34.02) ; v2(136.14,34.8) 136.01,34.93 UH1.AA28 ; v2(136.14,34.8) UH1.W30 ; v2(136.14,34.8) 136.51,35.18 UH1.W28 ; JDIMM4.209 197.15,69.73 198.1,68.78 v2(198.1,68.24) ; UC1.H35 256.02,63.7 v2(256.35,63.38) 256.67,63.05 UC1.J36 ; UC1.B37 v2(256.88,66.88) 257.21,66.55 UC1.C37 ; v2(133.08,37.11) 133.44,36.76 UH1.AF25 133.63,36.92 134.02,36.92 UH1.AD25 134.35,36.87 134.85,36.87 UH1.AB25 134.98,36.68 v2(135.37,36.29) 135.37,36.34 UH1.AA25 ; v2(133.08,37.11) 132.69,37.51 UH1.AG23 132.27,37.12 ; UC1.BJ34 255.17,31.25 v2(255.04,31.1) ; v2(145.99,48.42) UH1.A2 ; JDIMM4.205 197.14,68.73 197.49,68.38 v2(197.49,68.25) ; v2(131.57,32.26) 131.53,32.22 131.33,32.22 UH1.AL33 ; JEDP1.40 132.7,118.16 v2(132.36,117.82) ; v2(253.1,39.76) 252.72,39.38 UC1.AW30 ; 132.27,34.79 UH1.AG30 132.27,34.02 ; 132.27,34.79 UH1.AJ30 ; JDIMM4.171 196.72,60.23 197.59,61.1 197.59,61.77 v2(197.61,61.79) ; v2(251.48,46.12) UC1.AK29 ; UH1.AG27 132.66,35.93 133.41,35.18 UH1.AF28 ; UC1.BT26 UC1.BR26 UC1.BP26 249.61,28.66 249.99,29.04 249.99,29.51 ; PU1800.4 288.75,66.64 v2(288.85,66.74) ; CT340.2 36.48,43.89 v2(36.44,43.94) ; UC1.G28 251.49,64.05 v2(251.81,63.73) ; UH1.U24 137.8,37.44 v2(138.1,37.74) ; v2(254.39,42.91) 254.07,42.59 UC1.AR32 253.94,42.64 253.55,42.64 UC1.AR31 UC1.AR30 ; v2(247.64,29.6) UC1.BM24 v2(247.64,30.24) UC1.BM23 v2(247.64,29.6) ; v2(247.64,29.6) UC1.BN24 ; v2(255.04,31.1) UC1.BL33 ; v2(255.04,31.1) UC1.BJ33 ; UH1.AC38 v2(135.34,30.4) ; v2(233.62,44.37) 233.45,44.54 233.45,44.58 233.3,44.73 UC1.AM4 ; v2(253.1,58.66) 253.1,58.64 UC1.R30 UC1.R29 251.49,58.73 251.47,58.89 v2(251.48,58.89) v2(251.48,59.48) ; UH1.AW10 126.88,43.81 UH1.AV11 ; UZ45.5 335.76,12.69 335.99,12.46 v2(335.99,12.21) ; v2(122.93,24.46) 122.93,24.49 123.25,24.81 UH1.BF49 UH1.BF48 UH1.BG48 ; UC1.C21 245.9,66.62 246.18,66.34 246.35,66.34 UC1.D22 246.73,66 247.38,66.65 UC1.C23 ; UC1.C21 245.83,66.65 v2(245.51,66.33) 245.18,66 UC1.D20 245.11,66.05 244.51,66.65 UC1.C19 ; UC1.C21 245.98,66.65 v2(246.28,66.95) ; v2(257,54.72) 257.17,54.55 257.17,54.52 257.32,54.36 UC1.Y37 257.32,54.29 257.48,54.13 257.48,54.1 v2(257.65,53.93) 257.65,54 UC1.Y38 258.3,54.65 v2(258.3,54.72) ; v2(135.37,34.02) UH1.AB31 ; v2(135.37,34.02) UH1.AA31 ; JUSH1.3 334.69,47.55 v2(334.46,47.32) ; UC1.BK15 UC1.BJ15 240.43,32.4 v2(240.43,32.4) ; UH1.AL24 130.62,37.22 UH1.AK25 ; UC1.BT21 245.74,27.33 v2(246.07,27.65) 246,27.65 UC1.BR21 245.58,28.1 245.58,28.5 UC1.BP21 245.58,28.75 245.58,29.15 UC1.BN21 UC1.BN20 ; UH1.J40 141.72,30.07 v2(141.63,30.16) 141.18,29.72 UH1.K39 ; UC1.M13 v2(238.83,61.18) UC1.M12 v2(238.22,60.26) ; UC1.M13 v2(238.85,60.26) ; UC1.M13 v2(239.48,60.26) ; 244.75,89.57 244.75,89.56 244.51,89.32 JDGFF2.G4 ; UH1.AH12 132.94,43.13 v2(133.02,43.06) 133.02,43.06 UH1.AE12 ; UC1.BL21 v2(246.08,30.24) ; v2(246.08,30.24) UC1.BL22 ; v2(246.08,30.24) UC1.BM21 v2(245.28,30.25) UC1.BL20 244.69,30.73 244.29,30.73 UC1.BL19 ; v2(246.08,30.24) UC1.BM22 v2(246.06,29.6) ; UH1.AJ30 132.27,34.02 ; UH1.AL38 130.62,30.31 v2(130.43,30.12) 130.26,30.29 UH1.AN38 ; v2(243.41,62.12) 243.54,62.25 UC1.J18 ; UC1.AH36 256.99,48.35 v2(256.99,48.42) ; UH1.W25 136.15,37.12 ; 136.15,37.12 UH1.AA25 ; 136.15,37.12 v2(136.15,37.89) v2(136.15,38.67) UH1.AA20 ; v2(237.54,62.92) 238.03,63.4 UC1.H11 ; v2(237.54,62.92) UC1.K11 ; v2(237.54,62.92) UC1.J10 ; v2(237.54,62.92) UC1.K10 237.08,62.53 236.69,62.53 UC1.K9 236.43,62.53 236.04,62.53 UC1.K8 v2(235.42,62.87) ; PU1700.14 287.85,12.71 v2(287.6,12.46) ; UC1.G10 237.17,64.13 236.61,64.13 236.57,64.09 236.48,64.09 UC1.G9 236.16,64.34 v2(236.04,64.34) ; v2(132.92,27.38) 132.79,27.26 132.07,27.26 131.49,26.67 UH1.AK46 ; UC1.C15 241.5,66.98 v2(241.57,66.98) ; v2(257,46.85) 257.32,47.17 UC1.AJ37 UC1.AJ38 ; UC1.D24 248.33,66 v2(248.66,65.68) ; UC1.BR38 v2(258.4,27.54) ; UH1.BG2 UH1.BG3 ; UH1.BG2 122.72,48.19 v2(122.37,48.54) ; UH1.T17 v2(137.39,40.35) ; UC1.BL38 v2(258.4,30.44) UC1.BM38 ; v2(255.7,59.44) 255.7,59.51 UC1.N34 255.05,59.51 ; 249.99,29.51 249.61,29.89 UC1.BM26 ; UC1.BJ36 256.63,31.49 256.54,31.58 256.14,31.58 256.06,31.49 UC1.BJ35 ; JDGFF3.G4 259.31,89.32 259.67,88.96 259.67,88.93 259.96,88.64 v2(260.54,88.64) ; UH1.R38 138.04,30.29 v2(138.01,30.31) UH1.U38 ; UC1.D28 251.29,66 v2(250.97,66.33) 250.64,66.65 UC1.C27 ; UC1.J25 UC1.H25 248.97,63.35 v2(248.61,63.71) ; v2(253.09,53.93) 253.09,53.91 UC1.AA30 UC1.AA29 v2(251.48,53.99) v2(251.48,54.63) ; v2(197.02,61.79) 197.02,61.59 196.65,61.23 JDIMM4.175 ; JEDP1.30 127.7,119.82 v2(127.85,119.97) 128.02,119.97 128.2,119.79 JEDP1.31 ; UH1.T32 137.89,33.57 v2(138.25,33.92) ; CT339.2 38.34,43.89 v2(38.39,43.94) ; UH1.AA25 UH1.W27 ; PU1201.14 287.85,43.24 v2(287.61,43) ; 255.05,52.43 UC1.AB33 254.4,52.43 v2(254.4,52.36) ; 255.05,52.43 v2(255.05,52.36) ; 255.05,52.43 UC1.AB34 255.7,52.43 v2(255.7,52.36) ; v2(290.88,56.99) 290.53,56.64 PU1200.4 ; v2(33.2,49.13) 33,49.13 32.55,49.58 CT320.1 ; UH1.AT29 128.38,34.79 v2(128.38,35.61) UH1.AT26 ; v2(254.39,48.42) UC1.AH33 v2(255.04,48.42) ; v2(237.63,66.98) 237.7,66.98 UC1.C11 238.16,66.65 UC1.D12 ; UC1.BK14 240.2,31.27 UC1.BJ14 240.2,32.17 v2(240.43,32.4) ; PU300.11 v2(309.43,56.09) ; v2(240.43,32.4) 239.82,32.4 UC1.BH14 ; v2(254.4,59.44) 254.4,59.51 UC1.N33 255.05,59.51 ; UC1.J7 v2(235.42,62.87) ; v2(235.42,62.87) UC1.K7 ; UH1.AA20 v2(135.37,39.44) ; UH1.AA20 v2(135.37,38.67) ; v2(135.37,39.44) UH1.AB19 ; v2(135.37,39.44) UH1.AA19 ; v2(320.18,1.93) 320.37,1.74 321.38,1.74 321.66,2.02 PR512.2 ; UC1.BT14 UC1.BR14 ; v2(253.1,35.03) UC1.BE30 UC1.BE29 ; UC1.D14 240.32,66 v2(240,66.33) ; UH1.AN16 130.73,41.08 UH1.AL17 ; v2(249.21,30.25) UC1.BM25 ; UH1.A45 UH1.A46 ; UH1.A46 145.74,26.27 145.93,26.08 v2(145.96,26.08) ; UH1.A46 UH1.B47 ; v2(288.85,65.65) 288.84,65.64 PU1800.2 ; UH1.AJ25 v2(131.5,37.12) UH1.AK25 ; UH1.AJ25 132.27,37.12 ; UC1.BG37 257.32,33.08 257.5,33.26 257.78,33.26 UC1.BG38 258.02,33.07 258.3,33.34 v2(258.3,33.46) ; UC1.BP29 251.97,28.62 UC1.BR29 UC1.BT29 ; UC1.D18 243.1,66.44 242.96,66.44 UC1.C17 243.08,66.98 v2(243.15,66.98) ; v2(254.73,29.6) 254.4,29.93 UC1.BM33 ; UC1.AM37 257.32,44.92 257.65,45.24 v2(257.65,45.27) ; v2(241.57,66.33) 241.64,66.33 UC1.D16 ; v2(254.4,50) UC1.AE33 v2(255.05,50) 255.17,50.14 UC1.AE34 v2(255.7,50) ; UH1.BA12 125.94,43.35 125.94,43.79 v2(126.05,43.89) ; v2(242.36,64.38) 242.03,64.05 UC1.G16 ; v2(127.86,40.42) 127.86,40.68 UH1.AT16 ; v2(197.05,73.07) 196.89,73.23 JDIMM4.223 ; UC1.BL35 v2(256.26,30.27) UC1.BM35 ; UC1.BK22 UC1.BJ22 v2(246.45,32.45) ; UH1.AK20 v2(131.5,39.44) UH1.AJ20 UH1.AG22 v2(133.05,38.67) UH1.AF22 v2(133.82,38.67) UH1.AD22 ; 131.89,35.97 UH1.AJ27 131.88,35.96 v2(131.49,35.57) UH1.AK27 131.11,35.98 ; UH1.AE38 v2(133.08,30.4) ; UH1.AL12 130.91,43.19 v2(130.44,43.19) ; UC1.G24 248.59,64.38 v2(248.66,64.38) ; UC1.F19 244.26,64.7 v2(243.93,64.38) ; v2(236.57,69.41) 236.45,69.29 UC1.A9 ; UH1.Y17 136.39,40.92 v2(136.92,40.92) 137.3,40.88 UH1.U17 ; UH1.AK25 131.48,36.36 v2(131.49,36.36) ; UH1.AN12 v2(129.31,43.17) ; v2(253.09,56.29) 253.09,56.27 UC1.V30 UC1.V29 251.7,55.9 v2(251.4,56.2) v2(251.4,56.96) ; JUSH1.21 336.48,56.55 v2(336.69,56.34) 336.4,56.05 JUSH1.20 ; JDIMM2.98 171.61,39.98 v2(171.5,40.09) ; v2(257.65,56.29) 257.65,56.36 UC1.U38 258.3,57.01 v2(258.3,57.08) ; UC1.AR30 UC1.AR29 251.88,42.52 251.74,42.38 v2(251.47,42.38) ; UC1.AR30 UC1.AT30 ; UC1.AG29 251.68,48.81 v2(251.48,48.61) ; UC1.AD12 238.69,51.83 v2(238.83,52.01) ; UC1.AV37 257.32,40.23 v2(257.65,40.55) 257.97,40.22 UC1.AV38 ; v2(172.18,41.65) 172.19,41.65 172.53,41.98 JDIMM2.106 ; UH1.B48 UH1.C48 ; UH1.B48 UH1.B49 ; UH1.B48 UH1.A48 ; UH1.AH38 v2(131.65,30.33) ; v2(251.48,41.73) 251.48,41.73 UC1.AT29 ; UH1.Y33 137.36,32.7 UH1.U33 137.67,32.6 v2(138,32.27) ; UC1.AR36 256.67,42.59 v2(256.99,42.91) 257.32,42.58 UC1.AR37 ; v2(256.99,38.18) 256.99,38.12 UC1.BA37 257.36,37.79 257.45,37.88 257.85,37.88 257.93,37.79 UC1.BA38 ; v2(243.35,32.53) 243.31,32.49 UC1.BJ18 UC1.BK18 UC1.BL18 243.4,30.45 243.4,30.05 UC1.BM18 v2(242.91,29.6) UC1.BN18 243.4,29.19 243.4,28.72 UC1.BP18 ; v2(239.21,65.03) 239.53,64.7 UC1.F13 ; UC1.F4 233.55,64.43 233.84,64.43 UC1.F5 234.6,64.17 UC1.G6 ; UC1.F4 233.11,64.88 233.11,65.19 UC1.E4 ; UC1.F4 UC1.F3 ; v2(366.01,11.2) 366.01,11.62 365.82,11.81 UZ23.5 ; v2(255.7,57.08) 255.7,57.15 UC1.T34 255.05,57.15 ; v2(235.26,65.03) 235.59,64.7 UC1.F8 235.25,64.29 v2(235.21,64.29) 235.44,64.05 UC1.G8 235.75,64.05 v2(236.04,64.34) ; JDIMM2.102 v2(172.45,40.98) ; v2(236.04,64.34) 236.4,64.7 UC1.F9 236.41,64.74 236.41,65.31 UC1.E9 ; v2(235.27,65.68) 235.2,65.68 UC1.D6 234.97,66 235.62,66.65 UC1.C8 ; JEDP1.14 v2(119.7,119.97) ; v2(128.19,43.11) 128.25,43.17 UH1.AR12 ; UC1.AH35 256.34,48.35 v2(256.34,48.42) ; 197.18,64.73 JDIMM4.189 ; UT11.4 45.02,22.87 45.39,22.49 v2(45.39,22.43) ; v2(287.59,22.23) 287.83,22.46 PU1203.14 ; UI3.14 113.55,151.03 v2(113.37,151.21) ; UH1.Y38 v2(136.77,30.33) ; 255.05,57.15 v2(255.05,57.08) ; UC1.D9 236.46,66 v2(236.8,66.34) ; v2(383.02,60.1) 382.77,60.35 UI1.14 ; v2(255.05,59.44) 255.05,59.51 ; CT303.2 40.99,49.12 v2(40.99,48.49) ; UC1.BJ32 v2(254.39,31.1) ; UH1.AC17 134.79,40.6 v2(134.54,40.35) 134.21,40.02 UH1.AD19 ; v2(171.22,38.01) 171.25,37.98 JDIMM2.90 ; UE1.E6 v2(136.47,76.42) ; PU1201.4 290.88,45.89 v2(290.9,45.91) ; UI2.14 382.49,38.39 v2(382.72,38.62) ; UC1.G22 247.01,64.38 v2(247.08,64.38) 247.41,64.7 UC1.F23 ; v2(238.85,57.52) UC1.T13 v2(238.83,56.61) UC1.V12 ; UC1.F3 232.56,64.88 232.08,64.88 UC1.F2 v2(232.32,64.4) UC1.F3 ; v2(31.69,48.58) 31.75,48.53 CT332.2 ; UC1.AW29 251.74,39.37 v2(251.46,39.08) ; JEDP1.12 v2(118.7,120.12) ; JDIMM4.185 197.1,63.73 ; v2(15.09,64.58) DT12.3
  TOP w0.305: UE1.C4 v2(134.84,78.05) ; v2(290.78,36.17) 290.78,36.16 PU1202.4 ; JDIMM2.248 172.59,79.48 172.29,79.18 v2(172.29,78.63) 172.43,78.48 JDIMM2.244 ; v2(170.61,38.01) 170.61,38.22 171.38,38.98 JDIMM2.94 ; JDIMM4.248 185.87,79.48 v2(185.42,79.92) ; v2(183.27,26.25) 183.25,26.23 JDIMM2.43 ; JDIMM2.36 172.23,24.48 v2(171.5,23.71) 172.28,22.98 JDIMM2.30 ; JDIMM4.172 186.06,60.48 185.84,60.25 v2(185.84,59.86) 186.22,59.48 JDIMM4.168 ; CT308.2 33.84,47.19 v2(33.84,47.19) ; v2(244.79,91.52) 244.39,91.12 JDGFF2.G7 ; JDIMM2.86 171.41,36.98 v2(170.74,36.31) ; v2(197.65,73.07) 197.62,73.09 197.62,73.71 197.1,74.23 JDIMM4.227 ; UE1.H4 v2(134.87,73.28) ; v2(197.4,20.12) 197.3,20.12 197.2,20.23 JDIMM4.19 ; JDIMM2.2 172.28,15.98 v2(171.5,15.21) ; JDIMM4.35 197.32,24.23 197.45,24.09 v2(197.48,24.09) ; v2(197.45,17.84) 197.45,17.8 197.46,17.79 197.46,17.77 197.41,17.73 JDIMM4.9 ; v2(184.76,75.79) 184.95,75.98 JDIMM4.234 ; JDIMM4.60 186,30.48 185.7,30.17 v2(185.7,30.02) ; JDIMM2.234 172.61,75.98 v2(172.07,75.45) 172.79,74.98 JDIMM2.230 ; JDIMM4.103 196.72,41.23 v2(196.99,41.49) ; JDGFF2.C6 251.06,90.52 251.66,91.12 252.04,91.12 v2(252.37,90.79) 252.7,91.12 JDGFF2.B7 ; v2(185.32,31.81) 185.98,32.48 JDIMM4.68 ; v2(184.58,66.49) 185.59,65.48 JDIMM4.192 ; JDIMM2.222 172.59,72.98 172.2,73.38 v2(172.2,73.7) 172.49,73.98 JDIMM2.226 ; JDIMM2.78 172.28,34.98 v2(172.06,34.76) ; JPB1.5 v2(370.9,46.95) ; JDGFF1.A6 239.32,90.52 v2(239.71,90.91) ; v2(196.96,78.75) 196.44,78.23 JDIMM4.243 ; JDIMM2.188 172.17,64.48 v2(171.82,64.14) 172.47,63.48 JDIMM2.184 ; v2(197.06,36.77) 197.02,36.73 JDIMM4.85 ; JDIMM2.10 172,17.98 v2(171.57,18.42) ; JDIMM2.14 172.56,18.98 v2(171.51,20.03) 171.67,20.2 172.19,20.2 172.41,19.98 JDIMM2.18 ; JDIMM2.206 172.67,68.98 172.24,68.55 172.24,67.98 ; UC1.J22 UC1.H22 ; v2(197.66,38.77) 197.66,38.46 196.92,37.73 JDIMM4.89 ; JDIMM2.72 171.88,33.48 171.41,33.02 v2(171.41,32.53) ; v2(185.62,42.17) 185.81,41.98 JDIMM4.106 ; v2(185.52,21.71) 185.78,21.98 JDIMM4.26 ; v2(145.96,26.08) 145.66,25.77 UH1.A47 ; v2(171.12,21.67) 171.81,20.98 JDIMM2.22 ; v2(171.88,21.67) 172.2,21.98 JDIMM2.26 ; QE2.1 124.25,71.96 124.86,71.35 v2(124.86,70.23) CE22.2 ; JDIMM2.82 171.79,35.98 v2(171.46,36.31) ; UH1.M21 140.11,38.08 v2(140.36,37.84) 140.04,37.51 UH1.M24 ; JDIMM2.1 183.01,15.73 183.6,16.33 v2(183.6,16.52) 183.39,16.73 JDIMM2.5 ; JDIMM4.40 184.98,25.48 184.52,25.94 v2(184.52,26.25) ; JDIMM4.27 197.2,22.23 v2(197.4,22.02) 196.6,21.23 JDIMM4.23 ; v2(39.69,44.59) 39.8,44.7 CT321.1 ; JDIMM4.93 195.63,38.76 v2(197.02,38.76) ; JDIMM4.48 186.48,27.48 186.17,27.79 v2(186.17,28.3) ; v2(36.42,45.89) 36.42,45.91 36.31,46.02 CT319.1 ; JDIMM2.180 172.44,62.48 172.24,62.69 171.54,62.69 v2(171.5,62.72) ; CZ106.2 272.78,81.84 272.7,81.76 UZ19.5 ; v2(236.41,88.33) 236.02,88.72 JDGFF1.C3 ; v2(290.9,15.51) 290.81,15.41 PU1700.4 ; JDIMM2.52 172.62,28.48 172.24,28.1 171.3,28.1 v2(170.74,27.55) ; UE1.A13 142.73,79.54 v2(142.73,79.71) ; v2(198.24,17.81) 198.24,17.79 197.17,16.73 JDIMM4.5 ; UE1.A6 136.84,79.88 v2(136.86,79.9) ; JDIMM4.39 197.11,25.23 198.11,26.23 v2(198.11,26.24) ; v2(259.79,91.47) 259.44,91.12 JDGFF3.G7 ; JDIMM2.168 172.39,59.48 v2(171.77,60.11) 171.91,60.11 172.29,60.48 JDIMM2.172 ; v2(197.74,30.55) 197.58,30.39 197.58,30.21 197.09,29.73 JDIMM4.57 ; JDIMM2.192 171.61,65.48 171.54,65.56 v2(171.5,65.59) ; v2(227.43,90.39) 227.56,90.52 JDGFF1.H6 ; JDIMM4.210 186.46,69.98 186.15,70.29 186.15,70.66 ; v2(145.68,24.82) 145.68,25.12 UH1.A48 ; v2(185.18,26.24) 185.41,26.48 JDIMM4.44 ; JDIMM2.64 172.84,31.48 172.3,30.95 v2(172.3,30.9) 172.3,30.87 172.69,30.48 JDIMM2.60 ; JDIMM4.180 186.33,62.48 v2(186.03,62.78) ; JDIMM2.196 171.63,66.48 v2(170.74,65.59) ; JDIMM4.252 188.37,80.48 188.86,80.97 188.86,83.21 189.13,83.48 189.83,83.48 189.99,83.32 v2(189.99,83.03) ; v2(171.5,29.25) 171.5,29.27 171.71,29.48 JDIMM2.56 ; JDIMM4.1 197.32,15.73 v2(197.37,15.78) ; v2(239.77,88.84) 239.65,88.72 JDGFF1.A3 ; v2(184.96,68.06) 185.35,68.06 186.27,68.98 JDIMM4.206 ; v2(183.96,20.01) 183.93,19.97 183.93,19.38 183.78,19.23 JDIMM2.15 ; JDIMM4.2 184.88,15.98 v2(184.29,16.56) 185.79,16.56 186.2,16.98 JDIMM4.6 ; JDIMM4.78 186.39,34.98 v2(185.46,34.04) 186.02,33.48 JDIMM4.72 ; JDGFF1.C6 236.07,90.52 236.42,90.87 v2(236.45,90.87) ; CZ511.2 v2(118.35,117.24) ; v2(197.7,36.75) 197.7,36.47 196.95,35.73 JDIMM4.81 ; JDGFF2.A6 v2(255.19,90.52) ; v2(171.5,27.55) 171.56,27.48 JDIMM2.48 ; v2(183.86,26.27) 183.86,25.92 183.18,25.23 JDIMM2.39 ; JDGFF2.C3 251.04,88.72 251.4,88.36 v2(251.4,88.27) ; v2(172.18,77.08) 172.28,76.98 JDIMM2.238 ; UC1.G18 UC1.H18 UC1.J18 ; v2(197.37,26.24) 197.35,26.23 JDIMM4.43 ; JDIMM2.210 171.9,69.98 v2(171.55,69.64) ; v2(312.24,38.75) 312.29,38.7 PC1101.1 ; v2(185.95,66.62) 186.09,66.48 JDIMM4.196 ; v2(377.5,26.56) 377.37,26.43 CA55.2 ; 172.24,67.98 171.58,67.32 v2(171.58,67.26) ; 172.24,67.98 JDIMM2.202 ; JDGFF2.H3 242.33,88.72 v2(242.3,88.69) ; v2(165.11,109.73) 165.29,109.91 166.3,109.91 166.85,109.36 QV44.4 ; v2(237.41,91.48) 237.77,91.12 JDGFF1.B7 ; JDIMM4.102 186.23,40.98 v2(186.06,41.15) ; CT314.2 34.4,46.55 CT305.2 33.85,46.56 v2(33.84,46.54) ; JDIMM4.64 185.74,31.48 185.41,31.15 184.96,31.15 v2(184.31,31.79) ; JDIMM4.244 186.03,78.48 184.71,79.8 v2(184.71,79.92) ; v2(183.34,19.93) 183.03,20.23 JDIMM2.19 ; v2(198.21,22.05) 198.09,22.05 196.92,23.23 JDIMM4.31 ; v2(266.72,91.1) 266.85,91.1 266.9,91.15 268.06,91.15 JDGFF3.B7 ; JDIMM4.222 186.13,72.98 185.64,73.47 v2(185.64,73.73) 185.89,73.98 JDIMM4.226 ; v2(254.84,89.01) 254.77,89.01 254.48,88.72 JDGFF2.A3 ; JDIMM4.94 186.56,38.98 v2(186.18,38.59) ; CT333.2 35.13,49.2 34.49,48.56 v2(34.49,48.49) ; 171.68,70.98 171.65,71.01 171.65,71.64 172,71.98 JDIMM2.218 ; 171.68,70.98 JDIMM2.214 ; 171.68,70.98 171.32,70.63 v2(171.23,70.63) ; JDGFF1.H3 227.47,88.72 v2(227.38,88.81) ; JDIMM2.6 v2(171.5,16.98) ; CD117.2 183.52,44.83 183.36,44.67 v2(183.36,44.21) ; v2(48.5,18.07) 49.1,17.47 49.59,17.47 UT7.2 ; PU1203.4 290.92,25.11 v2(290.97,25.16) ; JDIMM4.167 194.04,59.23 193.17,60.1 192.17,60.1 191.91,59.83 v2(191.91,59.57) ; JDIMM4.47 197.46,27.23 198.08,27.84 v2(198.08,27.99) ; v2(172.04,32.56) 172.11,32.48 JDIMM2.68 ; UC1.BJ25 UC1.BK25 ; JDIMM4.18 v2(185.85,19.98) 185.85,20.84 185.99,20.98 JDIMM4.22 ; JDIMM4.15 197.39,19.23 198.22,20.05 v2(198.22,20.14) ; JDIMM2.176 171.77,61.48 v2(171.5,61.69) ; JDIMM4.30 186.46,22.98 185.62,23.82 v2(185.62,24.24) 185.85,24.48 JDIMM4.36 ; JDIMM2.44 171.84,26.48 v2(171.18,25.83) ; CT316.1 38.44,47.25 v2(38.39,47.19) 37.63,47.19 CT309.2 37.58,46.71 37.67,46.62 CT338.2 ; JDIMM4.214 186.48,70.98 186.16,70.66 ; JDIMM2.40 172.29,25.48 v2(171.95,25.83) ; v2(185.4,37.31) 185.4,36.64 186.06,35.98 JDIMM4.82 ; JDGFF1.G7 229.46,91.12 v2(229.75,91.4)
  TOP w0.33: 138,17.29 137.74,17.03 CZ54.2 ; 138,17.29 137.61,17.67 CZ53.2 ; 138,17.29 v2(138.03,17.29) ; v2(123.22,54.54) 123.22,54.02 123.18,53.97 123.18,53.14 122.76,52.72 RH606.2 ; CT331.2 34.38,47.94 v2(34.49,47.84) ; RH603.2 125.74,53.57 126.98,54.81 v2(128.03,54.81)
  TOP w0.356: PQ2001.4 59.65,17.53 v2(59.21,17.08) ; v2(182.57,90.62) 182.63,90.56 CD37.2 ; CL20.2 169.49,162.57 v2(170.13,163.21) ; v2(19.25,54.12) DT2.1 ; v2(123.22,54.54) 123.2,54.56 CH10.2 ; v2(162.61,123.84) 163.35,124.58 CV844.2 ; RL12.2 147.21,140.39 v2(147.1,140.39) 146.65,139.94 CL15.2 ; v2(377.77,11.24) 378.29,11.24 CN287.2 ; v2(52.69,28.4) 52.98,28.11 52.98,27.76 PQ6.4 ; CC336.2 239.15,22.94 v2(239.21,23) ; v2(170.13,160.92) 169.75,161.3 CL21.2 ; CT101.2 12.24,52.47 v2(12.27,52.44) ; CV816.2 161.95,118.14 v2(161.96,118.15) ; CV915.2 53.95,47.7 v2(54.22,47.98) ; v2(375.74,18.82) 375.91,18.65 CA10.2 377.46,18.65 377.73,18.38 CA33.2 ; CD118.2 184.95,48.94 v2(184.43,48.43) ; CL9.2 149.75,133.94 v2(149.68,133.87) ; CH349.2 113.13,31.74 v2(113.05,31.82) ; v2(35.45,20.49) 35.77,20.17 CT356.2 ; UT32.2 114.25,64.4 114.11,64.54 v2(113.99,64.54) ; CT318.1 34.56,47.77 ; CE38.2 142.71,83.97 v2(142.9,84.17) ; RT611.1 118.98,60.95 v2(119.01,60.97) 118.98,61 CT389.2 ; v2(119.65,54.47) 119.77,54.59 CC302.2 ; v2(298.6,69.2) 298.07,69.74 CZ518.2 297.61,70.45 CZ528.2 ; CE64.2 144.73,82.8 v2(144.73,83.39) ; CT341.2 36.26,42.71 35.79,43.18 v2(35.79,43.31) ; CT328.2 33.99,51.25 v2(33.83,51.09) ; CE36.2 132.03,63.01 131.75,62.73 v2(131.75,61.81) ; RT616.1 130.51,21.73 v2(129.93,21.73) 129.77,21.73 RH326.1 ; CZ506.2 123.02,78.26 123.11,78.35 CZ507.2 ; CH35.2 117.93,24.53 117.57,24.17 CH340.2 117.09,24.6 116.93,24.76 v2(116.93,25.38) ; CL18.2 134.52,152.33 CL199.2 ; v2(273.7,80.76) 273.7,81.9 273.28,82.31 CZ106.2 ; v2(134.77,64.61) 134.81,64.65 CE61.2 ; v2(147.17,62.55) 146.84,62.22 145.82,62.22 CE8.2 ; CZ514.2 92.89,56.09 93.16,56.36 UZ43.9 ; CL19.2 134.16,155.87 v2(133.8,156.22) ; v2(38.39,48.49) 38.3,48.57 CT315.2 ; CZ218.2 100.19,62.6 v2(100.34,62.75) ; v2(259.88,14.04) 259.51,13.67 CC337.2 ; v2(65.61,57.34) 66.51,57.34 67.54,56.31 68.45,56.31 CV923.2 68.49,55.73 CV921.2 ; RT440.1 v2(118.73,64.12) CT237.2 RT447.1 ; v2(380.06,31.76) 379.93,31.89 CA60.2 ; v2(46.68,15.62) 46.31,15.62 46.02,15.92 45.13,15.92 44.95,16.09 CT376.2 ; v2(145.11,87.78) 145.79,88.46 CE63.2 ; JDGFF3.C3 266.07,88.72 v2(266.41,88.39) ; v2(54.22,46.81) 53.91,46.49 53.39,46.49 CV918.2 ; v2(155.79,133.02) 155.72,133.09 CL4.2 ; CZ529.2 297.74,64.35 CZ513.2 298.59,65.1 v2(298.65,65.17) ; CT1.2 v2(49.35,42.56) ; CT327.2 37.72,54.08 v2(37.81,54.17) 38.01,54.17 38.43,53.75 RT184.2 ; CZ524.2 369.45,30.3 v2(369.26,30.11) ; CZ64.2 338.3,51.46 338.31,51.47 ; CV913.2 53.52,52.36 RV895.2 ; CT306.2 36.68,48.53 36.75,48.45 CT310.2 37.07,47.86 v2(37.09,47.84) ; v2(268.4,80.23) 268.56,80.06 CZ105.2 ; v2(236.71,12.33) 236.57,12.47 CC269.2 ; RZ513.2 134.03,99.04 CZ525.2 134.2,98.47 CZ545.2 ; v2(13.31,70.6) CT364.2 ; CZ120.2 334.34,15.51 v2(333.81,16.03) ; CV922.2 v2(87.32,55.26) ; v2(161.31,137.02) 160.83,137.49 CL7.2 ; RA52.1 374.27,24.63 CA226.2 373.43,24.65 v2(373.34,24.74) ; CZ66.2 v2(338.76,48.63) ; v2(272.68,75.11) 272.68,73.87 273.07,73.48 CZ544.2 ; PQ2001.1 58.35,16.97 v2(58.47,17.08) ; CL12.2 v2(156.61,133.09) ; v2(31.49,45.77) 32.28,45.77 CT302.2 ; v2(12.33,55.65) 12.04,55.65 CT109.2 ; v2(340.76,47.06) 340.76,47.6 CZ61.2 ; CZ129.2 365.88,14.14 365.48,14.54 364.84,14.54 v2(364.2,15.18)
  TOP w0.381: JDGFF3.C9 JDGFF3.D9 ; JDGFF2.H9 241.93,92.32 v2(241.75,92.14) ; CZ520.2 141.01,18.91 141.04,18.88 141.04,18.84 v2(141.07,18.81) ; v2(39.32,15.55) 39.51,15.35 QT4.1 ; v2(81.35,43.4) 81.15,43.19 RV903.2 ; v2(120.96,58.63) 120.81,58.48 UC3.3 ; JDGFF3.C6 266.26,90.52 266.45,90.33 v2(266.56,90.33) ; v2(281.43,88.23) 281.43,88.33 281.04,88.72 JDGFF4.C3 ; v2(77.9,19.24) 78.89,18.26 PQ2.1 ; UE11.3 107.84,63 107.12,63.72 v2(107.12,63.83) ; JDGFF3.A9 269.79,92.32 270.48,93.01 v2(270.48,93.2) ; v2(227.48,92.65) 227.81,92.32 JDGFF1.H9 ; CH41.1 122.1,20.66 v2(121.66,20.22) ; v2(338.43,49.47) 338.34,49.56 CZ67.2 ; v2(136.31,19.49) 136.31,19.81 RH325.1 ; CH341.2 111.01,37.29 RH634.2 110.5,37.8 110.44,37.86 110.31,37.86 v2(109.59,38.58) ; PC808.2 111.45,41.44 111.81,41.8 ; v2(89.35,20.98) 88.89,20.52 PQ1.1 ; v2(284.81,90.46) 284.75,90.52 JDGFF4.A6 ; JDGFF1.B1 238.07,87.5 238.03,87.5 v2(237.49,86.96) ; CC324.2 252.49,19.3 v2(252.58,19.2) ; v2(52.46,20.04) 52.09,20.41 PQ2006.1 ; v2(244.03,93.66) 244.11,93.58 JDGFF2.G10 ; CT301.2 35.29,41.75 RT554.1 35.58,40.42 35.43,40.27 v2(35.41,40.27) ; CT311.2 40.22,47.07 v2(40.34,47.19) ; v2(40.99,47.19) 40.9,47.11 CT322.1 ; JDGFF4.A3 285.22,88.72 v2(285.32,88.81) ; CE29.2 134.43,82.43 v2(135.11,82.43) ; v2(253.06,93.61) 253.06,93.45 253.09,93.42 JDGFF2.B10 ; v2(229.28,93.48) 229.11,93.31 JDGFF1.G10 ; v2(291.28,79.36) 292,79.36 RV62.2 ; JDGFF2.B1 252.96,87.39 252.96,86.81 v2(252.96,86.81) ; JDGFF2.F3 245.92,88.72 245.84,88.64 245.16,88.64 245.13,88.66 245.13,89.3 244.86,89.57 244.75,89.57 v2(244.75,89.6) ; v2(268.48,93.44) 268.09,93.05 JDGFF3.B10 ; v2(64.34,30.11) 63.97,29.75 PQ5.1 ; JDGFF1.G1 229.9,86.73 231.07,86.73 231.49,87.15 JDGFF1.F1 231.03,87.52 v2(230.81,87.74) ; JDGFF3.H3 257.53,88.72 v2(257.48,88.77) ; JDGFF3.B4 267.65,89.32 v2(267.42,89.1) ; RH633.2 111.72,32.51 CH348.2 112.45,32.43 v2(113.05,31.82) ; RT34.2 38.89,44.64 38.39,45.14 v2(38.39,45.24) ; v2(244.83,86.92) 244.23,87.52 JDGFF2.G1 ; JDGFF3.D1 264.79,86.86 v2(264.82,86.83) ; UZ10.3 388.1,9.21 v2(387.42,9.21) ; JDGFF3.G10 259.11,93.33 259.75,93.97 259.78,93.97 v2(259.82,94.01) ; v2(237.41,89.13) 237.45,89.13 237.64,89.32 JDGFF1.B4 ; v2(118.37,44.23) 118.4,44.26 118.57,44.26 119.16,44.51 RH637.1 ; JDGFF3.A6 269.3,90.52 v2(269.67,90.89) ; QT4.4 42.55,14.05 42.9,13.71 v2(42.9,13.32) ; JDGFF4.G1 274.7,87.52 v2(274.98,87.8) ; v2(166.38,122.61) 166.36,122.64 UV65.3 ; v2(276.25,77.27) 275.96,76.98 UZ35.3 ; JDGFF3.E2 262.82,88.12 v2(263.22,87.72) ; 338.31,51.47 v2(338.34,51.5) ; v2(290.14,82.26) 290.14,82.03 290.82,81.36 RV60.2 ; v2(52.85,13.77) 52.86,13.79 PQ2012.1 ; PQ2004.4 54.29,22 v2(53.67,22.62) 53.22,22.18 PC2003.1 ; JDGFF4.F3 276.15,88.72 275.83,88.39 v2(275.54,88.39) 275.34,88.39 274.49,89.25 274.18,89.25 JDGFF4.G4 ; JDGFF3.C1 265.81,87.52 v2(266.52,86.81) ; JDGFF4.B10 283.09,93.19 283.36,93.46 286.05,93.46 v2(286.1,93.41) ; JDGFF3.E1 262.56,87.52 v2(262.99,87.09) ; UL2.3 132.49,145.19 v2(132.59,145.29) ; v2(269.66,89.07) 269.31,88.72 JDGFF3.A3 ; v2(118.31,46.03) 118.54,46.03 118.73,46.22 RH636.1 ; PQ5.4 62.67,28.09 v2(62.56,28.21) ; CH68.2 119.03,22.63 119.05,22.61 119.05,22.34 v2(119.13,22.27) ; JDGFF4.H9 v2(272.43,92.32) ; v2(112.27,156.15) 112.87,156.75 DI4.3 v2(112.87,158.99) ; v2(260.8,90.13) 261.19,90.52 JDGFF3.F6 ; RV897.2 78.71,42.66 v2(78.71,43.32) ; v2(126.5,71.39) 126.55,71.39 CE21.2 ; v2(255.11,92.07) 254.86,92.32 JDGFF2.A9 ; PU1.3 87.14,19.76 87.4,20.02 v2(87.4,20.85) ; UZ61.3 277.28,74.41 277.09,74.6 277.09,74.93 277.44,75.29 v2(277.44,75.49) ; v2(282.31,89.79) 282.79,89.32 JDGFF4.B4 ; JDGFF3.D2 264.35,88.12 v2(263.88,87.64) ; JDGFF4.G7 274.63,91.12 v2(274.8,90.95) 275.4,90.95 275.83,90.52 JDGFF4.F6 ; CZ68.2 v2(336.83,53.66) ; JDGFF1.F3 231.14,88.72 231.04,88.62 230.27,88.62 230.13,88.75 v2(230.13,89.42) 230.03,89.32 JDGFF1.G4 ; v2(242.44,90.67) 242.59,90.52 JDGFF2.H6 ; PQ2003.4 v2(60.48,20.13) ; CE54.2 129.34,78.67 v2(128.97,79.05) ; v2(154.4,97.87) 154.48,97.79 154.48,96.67 PR405.2 ; v2(282.55,86.98) 282.55,87.15 282.91,87.52 JDGFF4.B1 ; v2(260.3,86.65) 259.66,86.65 259.11,87.21 JDGFF3.G1 ; JDGFF2.F6 246.08,90.52 v2(245.83,90.76) ; v2(272.48,88.72) JDGFF4.H3 ; PQ3.1 84.01,23.14 v2(83.77,23.38) ; v2(291.46,82.62) 291.46,82.82 291.83,83.19 RV58.2 ; v2(366.75,11.32) 366.75,10.84 CN191.2 ; CL17.2 169.86,168.81 v2(170.13,168.54) ; PQ2006.4 50,21.71 v2(49.35,22.37) ; CH346.2 117.42,28.44 v2(116.81,28.44) RH631.2 ; JDGFF2.B4 252.62,89.32 v2(252.42,89.52) ; JDGFF3.C2 266.14,88.12 266.35,88.33 v2(266.41,88.39) ; v2(170.13,170.83) 169.5,170.21 CL16.2 ; JDGFF3.F1 261.49,86.94 v2(261.84,86.59) ; v2(402.92,12.59) 402,13.51 JLED1.4 ; JDGFF3.F3 260.62,88.72 v2(260.54,88.64) 261.02,88.15 261.06,88.15 261.09,88.12 JDGFF3.F2 ; v2(387.52,6.75) 387.74,6.53 CZ93.2 ; v2(53.38,30.24) 53.38,29.54 PQ4.1 ; v2(82.83,17.29) 82.5,16.96 PQ2.4 ; JDGFF1.F6 v2(230.77,90.52) ; JDGFF4.B7 282.68,91.12 v2(282.42,91.38) ; JDGFF1.B10 238.09,93.62 237.94,93.77 v2(237.94,94.02) ; v2(38.39,45.89) 38.45,45.95 CT317.1 ; CZ541.2 v2(356.89,52.39) ; v2(230.12,69.98) 229.66,69.52 227.06,69.52 226.18,68.65 RC5.1 ; v2(404.44,12.33) 404,11.89 JLED1.9 ; QE2.4 125.55,76.67 124.62,77.6 CE10.2 125.44,77.75 v2(125.86,77.33) ; UC1.H22 246.7,63.35 v2(247.08,63.73) ; JDGFF3.H9 v2(257.46,92.32) ; DT16.1 v2(17.79,60.97) ; 34.56,47.77 v2(34.49,47.84) ; v2(293.98,33.9) 293.96,33.92 PC1235.2 ; v2(360.73,11.55) 360.73,11.98 360.51,12.19 UZ60.3 ; JDGFF3.H10 v2(257.44,92.92) ; C193.1 147.61,107.25 147.61,108.04 v2(147.72,108.15) 148.51,107.36 C192.1 ; JDGFF4.G10 v2(274.84,92.92) ; CT307.2 36.99,49.69 v2(37.09,49.79) ; PC1234.1 v2(294.07,35.05) ; PQ2109.4 95.31,28.51 v2(95.57,28.25) ; 11.85,67.07 v2(12.31,66.61) ; JDGFF3.H6 257.53,90.52 v2(257.46,90.45) ; v2(239.77,92.04) 239.49,92.32 JDGFF1.A9 ; CC186.1 CC195.1 263.84,64.62 v2(263.66,64.44) ; v2(284.73,92.22) 284.62,92.32 JDGFF4.A9 ; v2(269.88,93.36) 269.45,92.92 JDGFF3.A10 ; JDGFF4.H6 v2(272.47,90.52) ; v2(267.13,86.71) 267.27,86.71 JDGFF3.B1 ; v2(13.86,54.19) DT8.3 ; RH641.2 CH349.2 ; JDGFF3.F9 JDGFF3.E9 ; v2(354.7,53.1) PWRSW1.2
  TOP w0.406: v2(85.93,24.3) 85.9,24.32 85.51,24.32 PQ3.4 ; UT34.3 115.39,60.39 114.51,59.51 v2(114.02,59.51)
  TOP w0.432: QZ17.4 135.89,98.2 135.65,98.44 135.65,98.77 v2(135.33,99.09) ; QZ17.1 138.16,96.9 v2(138.78,96.28) ; v2(135.61,101.72) 135.39,101.49 135.39,101.08 135.53,100.93 QZ18.1 ; v2(137.74,98.95) 137.74,99.51 QZ18.4
  TOP w0.457: R129.2 151.62,100.76 v2(151.55,100.69) ; v2(190.28,91.22) 189.96,90.91 189.96,90.27 190.68,89.56 RD51.2 ; v2(124.99,18.11) 124.99,18.89 125.46,19.36 CH5.1 ; CD51.2 183.98,46.57 183.32,45.91 v2(183.32,45.77) ; v2(118.37,44.23) 118.37,43.96 118.59,43.74 119.1,43.74 CA76.2 ; v2(118.31,35.87) 118.56,35.62 CC318.2
  TOP w0.508: RV868.2 v2(80.46,58.05) ; PC312.2 PR307.2 309.74,63.09 v2(309.69,63.13) ; v2(111.96,146.26) 111.71,146 UV24.2 ; v2(227.85,62.56) 227.74,62.46 226.56,62.46 226.2,62.82 RC7.1 RC6.1 ; v2(308.18,73.04) 308.12,73.1 JFAN2.1 ; v2(74.22,30.47) 74.26,30.42 PC700.1 ; CV842.2 126.9,109.23 v2(126.72,109.06) ; CV843.2 126.29,112.23 125.88,112.64 ; RC171.1 229.71,24.02 v2(229.79,23.94) ; PR74.2 86.33,24.7 v2(85.93,24.3) ; CV916.2 54.19,45.61 v2(54.22,45.64) ; PR905.2 97.43,22.62 v2(97.19,22.38) ; DT2008.2 13.47,62.68 v2(13.28,62.87) ; v2(310.08,45.58) 310.07,45.6 PC1100.1 ; PC905.2 PC906.2 107.27,17.27 v2(107.29,17.29) ; PC807.2 PR801.1 105.46,25.31 v2(105.48,25.29) 105.48,25.03 105.92,24.6 105.99,24.6 CC320.2 ; RV890.2 49.54,54.5 49.83,54.21 v2(49.83,53.87) ; PC15.2 22.01,68.86 v2(20.73,70.14) ; PR402.2 157.86,95.84 PC401.2 157.82,96.33 158.87,97.38 158.87,98.18 v2(158.9,98.21) ; v2(23.06,2.75) 23.38,3.07 JKBTP1.23 ; v2(16.46,63.44) 16.99,62.9 DT2007.2 ; v2(12.58,1.84) 12.34,2.09 JKBTP1.21 ; PQ2003.1 v2(62.44,21.12) ; v2(23.62,4.76) 23.84,4.99 JKBTP1.24 ; v2(123.29,124.32) 122.95,123.98 JEDP1.43 ; PR1129.2 262.05,39.76 v2(261.97,39.67) ; v2(311.43,47.41) 311.39,47.37 PR1118.1 ; v2(334.01,23.32) 334.01,22.6 C203.2 ; CA22.2 347.08,21.73 v2(347.61,21.2) 348.23,21.82 CA24.2 ; v2(113.84,7.11) 114.03,6.92 PD200.2 ; v2(78.35,58.15) 78.33,58.12 CV930.2 ; PD10.1 66.77,18.34 v2(66.77,18.76) ; RV64.2 290.72,77.62 290.29,77.2 v2(290.29,77.06) ; RI79.1 112.52,150.83 v2(112.42,150.93) ; v2(31.34,52.39) 31.42,52.39 31.49,52.47 CT326.2 CT324.2 CT325.2 ; v2(134.3,65.74) 134.62,66.06 RE56.2 ; JEDP1.44 131.85,122.14 v2(131.52,121.81) ; JKBTP1.3 14.34,3.06 v2(14.34,1.48) ; UT2.4 43.63,51.38 43.13,51.89 43.13,52.4 v2(43.01,52.51) 42.96,52.57 42.92,52.57 RT553.2 ; v2(387.68,58.5) 387.73,58.55 CI14.2 ; v2(79.71,58.18) 79.23,57.7 CV931.2 ; JKBTP1.9 17.34,3.06 17.34,1.8 v2(17.35,1.79) ; v2(305.32,73.98) RV50.2 ; v2(73.24,17.52) 73.26,17.5 PR726.2 ; v2(131.75,61.81) 131.75,61.44 132.04,61.15 132.82,61.15 CE47.2 ; CA228.2 391.03,27.94 v2(391.22,28.14) ; QV2.3 138.01,136.33 v2(138.69,135.65) ; JEDP1.42 v2(114.05,123.99) ; v2(198.94,89.33) 198.72,89.11 CD128.2 ; v2(170.66,130.68) RV836.2 ; CT337.2 38.12,41.7 37.89,41.7 37.64,41.95 v2(37.01,41.95) ; v2(247.76,85.55) 246.73,84.52 CV902.2 ; v2(153.74,124.78) 153.74,125.13 153.1,125.77 CV818.1 151.93,125.77 RV832.2 ; RT41.1 31.78,42.92 31.57,42.7 v2(31.57,42.51) ; QE17.3 149.51,87.74 v2(149.62,87.85) ; v2(168.68,83.43) 168.16,82.91 JDIMM2.262 165.77,83.36 166.88,84.47 v2(168.65,84.47) ; JLED1.10 404,15.32 v2(403.96,15.36) ; v2(32.65,21.48) 32.52,21.35 JSD1.3 ; PC902.2 101.24,22.64 PR902.2 101.26,22.92 v2(101.6,23.26) ; CI3.2 388.34,31.61 v2(388.57,31.38) ; v2(111.77,119.46) 110.98,119.46 110.8,119.64 JEDP1.41 111.46,120.86 v2(111.77,121.17) ; 137.04,58.37 137.08,58.41 YH2.4 ; RE20.2 130.09,65.65 v2(130.08,65.64) ; CV911.2 53.68,48.6 v2(54.22,49.14) ; v2(131.26,109.49) 131.76,109.98 PC113.2 ; CZ73.2 338.63,52.21 338.96,52.54 v2(338.96,52.92) ; YH2.2 140.59,56.38 CH13.2 140.59,56 141.13,55.46 v2(141.13,55.21) ; PR75.2 58.23,24.67 v2(57.2,25.69) ; v2(23.29,7.25) 22.84,6.8 JKBTP1.20 ; v2(290.36,53.96) 289.81,53.41 PH1103.2 ; CV919.2 53.57,43.34 53.57,44.02 53.58,44.03 CV917.2 54.75,44.59 v2(55.8,45.64) ; v2(67.28,53.2) 67.92,53.2 RV889.2 ; v2(30.05,30.24) 30.21,30.4 30.33,30.4 JSD1.6 ; v2(115.79,45.38) 116.12,45.05 CA73.2 ; CV914.2 CV912.2 53.64,54.37 v2(54.22,53.79) ; RH74.2 130.95,58.02 130.88,58.1 130.88,58.74 131.13,58.99 v2(131.13,59.15) ; DZ21.2 v2(119.91,81.62) ; PC527.2 332.01,11.99 v2(332.13,12.11) ; v2(120.96,58.63) 121.32,58.63 RH70.2 ; PR2161.1 97.59,30.64 v2(97.71,30.76) PQ2109.1 ; QA10.3 387.92,18.06 v2(387.91,18.05) ; v2(262.25,50.71) 262.28,50.69 PR1125.1 ; v2(144.09,74.17) 144.42,74.5 144.72,74.5 RE65.2 ; v2(184.48,62.75) 184.65,62.58 CD126.2 ; RT614.2 40.69,55.41 v2(40.91,55.64) ; v2(4.9,10.05) 4.9,10.05 3.59,10.05 ; RZ10.1 339.82,47.02 v2(339.84,47) ; JSD1.21 32.58,36.15 33.35,35.38 v2(33.35,33.82) ; v2(371.5,34.93) CZ523.1 CZ522.1 ; CA65.2 CA66.2 373.62,18.72 372.65,18.72 v2(372.46,18.54) ; v2(109.9,111.75) CZ543.2 110.51,112.64 CZ542.2 ; v2(140.15,136.67) 140.52,137.04 CV14.2 ; PR18.1 86.31,20.85 v2(87.4,20.85) ; RV829.2 RV831.2 146.97,118.65 v2(146.91,118.71) ; CA46.2 380.69,32.88 380.59,32.78 CA59.2 380.12,33.78 v2(379.98,33.92) ; CD56.2 184.75,56.11 185.39,56.75 v2(185.39,57.32) 184.6,58.1 CD125.2 ; v2(57.37,46.81) 58.9,45.28 RV902.2 ; v2(160.35,140.17) 162.89,140.17 163.22,140.5 163.22,144.48 163.09,144.61 v2(162.05,144.61) ; v2(160.35,140.17) Y1.2 ; v2(160.35,140.17) 159.18,140.17 v2(159.05,140.3) CL13.2 ; v2(107.8,10.85) 107.8,11.65 108.78,12.64 PC213.2 ; CN288.2 380.23,10.64 v2(380.75,11.17) ; CZ512.1 118.39,114.7 v2(118.49,114.59) ; CV956.2 251.06,83.82 CV806.2 251.29,85.35 v2(250.89,85.75) ; v2(46.41,12.94) 46.41,12.69 46.07,12.35 PC126.2 ; DI3.1 v2(391.28,35.7) ; v2(297.84,63.06) 297.84,62.93 297.67,62.77 PC309.2 ; JFAN2.5 309.83,75.63 v2(309.83,74.18) ; PR312.1 314.47,62.43 314.77,62.13 v2(314.77,61.7) ; v2(106.44,21.7) 106.63,21.88 PC903.2 ; CT355.2 37.79,19.67 v2(38.5,20.39) ; v2(349.93,17.4) 349.61,17.08 DA7.1 ; v2(366.01,11.2) 365.72,10.91 365.68,10.91 365.58,10.81 CN190.2 ; v2(46.3,20.08) 46.81,20.59 CT374.2 ; CZ69.2 340.48,51.31 v2(340.76,51.02) ; RV863.2 v2(83.51,58.05) ; RV830.2 156.49,127.89 v2(155.97,128.42) ; CN189.2 CN188.2 359.71,10.76 359.31,11.17 v2(359.31,11.55) ; PR804.2 109.43,29.14 v2(108.14,29.14) ; v2(158.77,126.46) 158.73,126.41 RV835.1 ; RE58.2 129,81.92 v2(128.91,82.01) ; CT323.2 32,53.91 v2(32.14,54.05) ; v2(234.48,14.78) 234.38,14.68 CC33.2 ; PC404.2 167.16,94.86 v2(167.31,94.71) ; RA225.2 391.1,27.05 v2(391.28,27.24) ; CV813.2 149.98,123.48 v2(149.48,122.98) ; v2(303.5,87.87) 303.27,88.1 302.51,88.1 RV130.1 ; v2(116.85,155.92) 116.66,155.73 CI76.2 ; v2(153.34,105.35) 152.74,104.76 C194.2 ; PC17.2 25.31,65.33 v2(25.88,65.9) ; RT42.1 31.55,43.73 v2(31.43,43.61) ; JSD1.20 32.67,22.6 v2(32.78,22.49) ; RC75.2 124.48,21.66 124.76,21.94 v2(124.76,22.11) ; v2(115.69,114.26) CZ510.2 114.92,115.52 CV849.1 ; 4.68,19.35 v2(4.68,20.72) ; RC324.2 242.71,20.21 v2(242.77,20.14) 243.07,20.14 244.42,21.49 RC322.2 ; v2(162.05,144.61) Y1.4 ; v2(162.05,144.61) 159.1,144.61 v2(159.07,144.58) ; PC1215.2 293.21,55.74 PC1213.1 v2(293.15,56.48) ; RV884.2 v2(82.5,58.05) ; RV66.2 295.04,74.26 295.51,73.79 v2(295.87,73.79) ; RV874.2 RV873.2 RV872.2 RV871.2 RV870.1 86,52.24 85.37,52.87 v2(84.48,52.87) ; RV875.2 v2(81.48,58.05) ; C202.1 C201.1 329.21,20.46 v2(328.95,20.72) ; PH1104.2 289.61,12.13 289.07,11.6 288.08,11.6 287.6,12.08 v2(287.6,12.46) ; QH6.3 118.36,19 118.87,18.49 CMOS1.1 119.75,18.49 v2(120.33,19.08) 120.33,19.71 119.35,20.69 CH40.1 ; CA19.2 v2(351.61,21.95) ; v2(86.81,58.56) CV924.2 ; DA6.1 345.7,16.4 v2(345.7,17.5) ; QZ20.3 133.44,88.74 RZ547.2 132.15,88.74 131.6,88.18 v2(131.6,87.87) ; v2(40.33,48.48) 40.12,48.48 39.75,48.86 RT26.2 ; CD101.2 194.12,89.32 RD89.1 193.24,88.91 192.61,88.28 192.61,84.88 v2(192.61,81.96) ; CA23.2 344.38,20.8 v2(344.47,20.72) ; v2(298.93,63.11) 298.89,63.07 PC310.2 ; CN289.2 375.28,10.63 v2(374.75,11.17) ; JLED1.8 399.08,14.57 v2(398.71,14.57) ; JIR1.8 v2(108.25,136.71) ; JFAN2.6 309.85,68.06 v2(309.52,68.39) ; CH14.2 v2(137.84,54.61) ; v2(174.19,90.31) RD81.1 RD82.1 ; JSD1.22 16.77,10.15 17.63,9.29 v2(17.63,8.58) ; v2(27.2,64.66) 26.55,64.01 PC16.2 ; v2(330.72,60.59) 331.12,61 JUSH1.27 ; v2(390.24,17.08) 390.1,16.94 390.1,16.23 389.2,15.33 389.2,14.91 388.58,14.29 387.34,14.29 387.09,14.05 ; CH4.1 128.28,19.32 128.36,19.24 v2(128.95,19.24) ; DT2003.2 16.96,55.89 v2(17.47,55.39) ; PD702.2 76.91,20.89 76.81,21 v2(76.73,21) ; CD62.2 181.44,90.01 181.74,90.31 CD63.2 181.74,90.32 181.39,90.67 v2(180.92,90.67) ; v2(84.4,47.13) CV926.2 CV925.2 ; CV920.2 83.84,53.53 v2(84.03,53.72) ; PC533.2 325.29,2.39 v2(325.77,1.92) ; CH266.2 123.58,18.49 v2(124.17,19.08) ; v2(311.5,46.5) 311.49,46.48 PC1108.1 ; C190.2 142.01,104.66 v2(141.68,104.33) 140.8,105.21 PC109.2 ; RV898.2 60.09,47.01 v2(61.16,45.94) ; v2(112.59,82.28) 112.68,82.28 112.87,82.09 115.45,82.09 JFAN1.6 ; CV840.2 CV841.2 112.47,115.33 v2(111.9,115.9) ; PC6.2 86.33,21.6 v2(86.94,21.6) ; v2(20.71,4.14) 21.34,3.51 JKBTP1.17 ; PD9.1 64.27,16.59 v2(64.21,16.52) ; PC206.2 114.01,9.28 v2(113.83,9.11) ; RV895.2 53.49,52.19 v2(54.22,51.46) ; v2(54.22,50.29) 53.73,49.8 RV892.2 ; v2(333.36,16.49) 332.56,17.29 C200.2 ; RE541.1 v2(142.9,84.84) 142.63,85.1 141.57,85.1 141.25,84.78 RE77.2 ; JIR1.7 v2(115.85,136.71) ; v2(51.64,38.37) 51.64,37.71 50.9,36.97 PR2163.1 ; PC707.2 75.36,25.47 v2(75,25.11) ; v2(89.06,33.48) 89.1,33.52 PR732.2 ; RH193.2 144.27,52.72 144.14,52.85 v2(144.14,53.13) ; PQ2005.4 53.98,19 v2(53.92,19.06) ; v2(338.97,55.96) 338.73,55.72 CZ62.2 ; RV839.2 v2(164.43,127.4) ; v2(255.93,83.38) 255.65,83.66 CV957.2 ; v2(294.08,12.46) 293.82,12.71 PC1708.2 293.29,12.8 PC1707.1 ; v2(384.44,12.03) 384.41,12.05 RA228.1 ; v2(109.78,112.66) 109.78,113.35 CZ535.2 ; PR314.2 v2(311.47,63.09) ; v2(296.62,48.27) 296.42,48.07 296.42,47.77 PC1128.1 ; v2(146.89,120.56) 146.95,120.5 147.52,120.5 RV833.2 ; v2(343.44,12.61) 344.3,13.47 JSPK1.8 ; CT329.2 CT330.2 31.49,46.11 v2(31.49,45.77) ; v2(373.28,22.01) 373.66,22.01 CA54.2 ; CA61.2 376.18,21.54 v2(375.87,21.22) ; CE12.2 126.79,79.02 v2(127.16,78.65) ; CC319.2 111.82,33.29 RH633.2 ; v2(159.07,144.58) 158.27,144.58 v2(158.23,144.53) RL13.2 ; v2(159.07,144.58) CL14.2 ; QV43.3 v2(139.67,128.57) ; PQ2012.4 50.96,18.01 v2(51,18.05) ; DI2.1 v2(391.51,62.81) ; v2(380.12,16.3) 380.91,16.3 CA53.1 381.98,16.46 CA69.2 ; v2(341.1,49.7) 340.92,49.88 CZ72.2 ; PR209.2 108.74,15.02 v2(107.82,15.93) ; PR310.1 v2(307.21,63.1) 307.21,62.42 PR308.2 ; v2(382.13,31.25) 382.45,30.93 CA48.2 ; v2(356.12,36.79) 356.12,38.14 PC513.2 ; v2(26.52,65.37) 25.92,64.78 PR45.2 ; CA74.2 119.02,42.9 118.9,42.9 v2(118.4,42.41) ; v2(132.66,151.91) 133.09,152.33 CL18.2 ; CC300.2 254.35,19.34 v2(254.33,19.32) ; PC5.1 v2(85.36,16.65) ; v2(131.01,114.23) 131.01,114.11 131.43,113.69 PR108.2 ; PR1168.2 294.89,41.72 295.25,42.08 296.08,42.08 v2(296.11,42.05) PR1171.2 PR1157.2 ; v2(134.06,96.41) 134.2,96.55 CZ545.2 ; RI14.1 379.62,60.01 v2(379.63,60.01) ; v2(376.26,49.05) 376.1,49.2 JPB1.7 ; v2(111.83,7.69) PC209.2 ; RA222.1 386.18,33.14 v2(386.15,33.16) ; v2(62.52,22.3) PQ2010.3 ; v2(109.5,74.42) 110.09,73.84 JFAN1.5 113.85,73.84 114.65,74.64 JFAN1.1 ; v2(122.61,53.96) 121.86,53.96 121.49,53.59 RH612.1 ; JKBTP1.22 11.19,6.07 v2(11.17,6.09) ; v2(73.71,19.98) 73.71,20.49 PC706.2 ; v2(335.99,12.21) 336.27,11.93 CZ121.2 ; PC1129.2 v2(296.11,40.4) ; JSPK1.6 v2(341.94,10.91) ; CZ516.1 CZ517.1 293.95,67.2 v2(293.82,67.32) ; CV75.2 303.43,74.02 v2(303.18,73.77) ; DI5.1 119.73,161.07 v2(119.59,161.22) ; SW3.3 v2(360.12,50.01) ; v2(122.27,73.63) 122.63,73.98 122.63,76.72 123.02,77.12 CZ506.2 ; v2(143.94,68.62) 143.94,68.12 144.46,67.6 CE57.2 ; v2(128.3,58.6) 127.77,58.6 127.26,58.09 RH313.2 ; v2(310.13,44.69) 310.12,44.71 PR1116.1 ; v2(344.18,1.92) 344.38,2.12 JSPK1.7 ; v2(353.57,37.39) 353.23,37.73 PC515.2 352.42,38.11 PR507.2 ; v2(31.51,13.22) 31.51,12.33 31.52,12.31 JSD1.19 ; v2(8.81,36.16) 8.81,36.97 9.49,37.65 JSD1.24 ; CE65.2 146.48,81.6 146.61,81.73 146.85,81.73 v2(147.4,82.28) ; RV842.1 v2(125.41,135.32) ; JKBTP1.2 13.95,6.18 v2(13.95,7.17) ; JEDP1.45 v2(135.1,118) ; v2(245.39,20.32) 245.53,20.47 RC325.2 ; CE28.2 131.62,82.29 132.05,81.85 132.3,81.85 v2(132.37,81.79) ; v2(139.55,18.81) 139.3,18.56 CZ55.2 ; CC338.2 257.69,16.27 v2(256.93,17.03) 256.95,17.04 256.95,17.08 RC319.1 ; RH617.2 118.37,40.33 v2(118.36,40.32) ; R127.2 146.35,101.36 v2(146.07,101.64) ; JKBTP1.15 20.34,3.06 20.34,2.23 v2(20.65,1.92) ; v2(140.98,131.78) 141.17,131.59 CV15.2 CV839.1 ; JPB1.8 v2(368.45,50.69) ; v2(357.26,37) PC505.2 ; v2(23.12,68.64) PC14.2 ; v2(380.82,40.4) 380.9,40.48 RI71.1 ; v2(107.9,26.3) 108.23,25.97 108.51,25.97 PR808.2 ; SW3.1 v2(362.1,50.01) ; QZ21.3 v2(349.68,51.57) ; v2(103.01,32.4) 103.01,32.41 PC801.2 PC800.2 ; PC301.2 v2(300.59,63.05) ; 4.68,29.85 v2(4.68,31.42) ; JUSH1.28 v2(333.7,44.6) ; RH268.2 118.84,33.64 v2(118.32,33.64) ; JLED1.7 v2(398.52,11.15) ; RC114.2 248.84,23.52 249.11,23.26 v2(249.11,22.77) ; RV3.2 v2(113.23,144.27) ; RV834.2 v2(146.94,122.71) ; PC702.2 v2(75.17,30.58) ; DT2001.2 v2(16.51,51.77) ; PC314.2 309.37,53.24 v2(309.83,52.78) ; v2(295.12,44.08) PC1130.2 ; PR729.2 v2(64.84,21.54) ; PR1100.1 v2(262.05,59.68) ; RT27.2 v2(42.67,53.76)
  GND1 w0.203: H8.1 266.25,20.87 ; H8.1 261.65,20.87 ; H8.1 262.26,19.18 ; H8.1 262.26,22.56 ; H8.1 265.64,22.56 ; H8.1 265.64,19.18 ; H8.1 263.95,18.57 ; H8.1 263.95,23.17 ; 132.95,170.05 H9.1 ; H9.1 131.44,170.59 ; H9.1 130.9,172.1 ; H9.1 134.46,170.59 ; H9.1 135,172.1 ; H9.1 132.95,174.15 ; H9.1 131.44,173.61 ; H9.1 134.46,173.61 ; H16.1 4.86,61.7 ; H16.1 3.6,61.27 ; H16.1 5.29,62.95 ; H16.1 3.6,64.64 ; H16.1 4.86,64.21 ; H16.1 2.34,64.21 ; H16.1 2.34,61.7 ; H16.1 1.91,62.95 ; JUSBC1.5 3.29,49.7 ; JUSBC1.5 1.8,51.37 ; JUSBC1.5 3.29,51.37 ; JUSBC1.5 3.29,50.54 ; JUSBC1.5 0.31,49.7 ; JUSBC1.5 1.8,49.7 ; JDG1.8 112.74,109.16 ; JDG1.8 110.76,109.16 ; JDG1.8 110.76,108.45 ; JDG1.8 111.75,107.74 ; JDG1.8 112.74,108.45 ; JDG1.8 110.76,107.74 ; JDG1.8 111.75,109.16 ; JDG1.8 112.74,107.74 ; H11.1 295.95,92.85 ; H11.1 297.46,92.31 ; H11.1 294.44,92.31 ; H11.1 293.9,90.8 ; H11.1 298,90.8 ; H11.1 294.44,89.29 ; H11.1 295.95,88.75 ; H11.1 297.46,89.29 ; JUSB1.11 396.38,70.09 ; JUSB1.11 398.01,69.2 ; JUSB1.11 394.74,70.09 ; JUSB1.11 398.01,68.31 ; JUSB1.11 394.74,69.2 ; JUSB1.11 398.01,70.09 ; JUSB1.11 394.74,68.31 ; JUSB1.11 396.38,68.31 ; JUSBC1.2 6.96,76.14 ; JUSBC1.2 6.25,76.14 ; JUSBC1.2 5.54,75.08 ; JUSBC1.2 5.54,76.14 ; JUSBC1.2 5.54,74.16 ; H7.1 265.64,73.58 ; H7.1 266.25,75.27 ; H7.1 262.26,76.96 ; H7.1 265.64,76.96 ; H7.1 263.95,77.57 ; H7.1 262.26,73.58 ; H7.1 263.95,72.97 ; H7.1 261.65,75.27 ; 394.92,36.21 JUSB2.7 ; JUSB2.7 394.26,37.71 ; JUSB2.7 395.58,36.39 ; JUSB2.7 394.92,37.89 ; JUSB2.7 395.76,37.05 ; JUSB2.7 394.08,37.05 ; JUSB2.7 395.58,37.71 ; JUSB2.7 394.26,36.39 ; H13.1 227.85,78.47 ; H13.1 225.55,76.17 ; H13.1 226.16,74.48 ; H13.1 230.15,76.17 ; H13.1 227.85,73.87 ; H13.1 229.54,77.86 ; H13.1 229.54,74.48 ; H13.1 226.16,77.86 ; 394.08,62 JUSB1.7 ; JUSB1.7 395.58,62.66 ; JUSB1.7 394.92,62.84 ; JUSB1.7 395.58,61.34 ; JUSB1.7 395.76,62 ; JUSB1.7 394.92,61.16 ; JUSB1.7 394.26,61.34 ; JUSB1.7 394.26,62.66 ; H1.1 392.25,5.05 ; H1.1 390.2,3 ; H1.1 393.76,1.49 ; H1.1 394.3,3 ; H1.1 390.74,1.49 ; H1.1 390.74,4.51 ; H1.1 393.76,4.51 ; H1.1 392.25,0.95 ; JUSB3.4 116.81,163.81 ; JUSB3.4 115.43,165.19 ; JUSB3.4 116.81,165.19 ; JUSB3.4 116.12,165.39 ; H5.1 65.3,2.6 ; H5.1 64.76,4.11 ; H5.1 63.25,0.55 ; H5.1 61.74,1.09 ; H5.1 61.74,4.11 ; H5.1 64.76,1.09 ; H5.1 63.25,4.65 ; H5.1 61.2,2.6 ; JNGFF4.76 386.89,5.57 ; JNGFF4.76 386.25,3.03 ; JNGFF4.76 386.89,4.3 ; JNGFF4.76 386.25,5.57 ; JNGFF4.76 386.89,3.03 ; 2.69,48.01 H6.1 ; H6.1 5.21,48.01 ; H6.1 2.69,45.5 ; H6.1 5.64,46.76 ; H6.1 5.21,45.5 ; H6.1 2.26,46.76 ; H6.1 3.95,45.07 ; H6.1 3.95,48.44 ; JUSBC1.3 8.17,51.3 ; JUSBC1.3 8.17,50.54 ; JUSBC1.3 6.85,49.77 ; JUSBC1.3 6.85,51.3 ; JUSBC1.3 5.53,50.54 ; JUSBC1.3 5.53,49.77 ; 1.8,65.9 JUSBC1.7 ; JUSBC1.7 0.31,65.9 ; JUSBC1.7 3.29,65.9 ; JUSBC1.7 3.29,67.57 ; JUSBC1.7 1.8,67.57 ; JUSBC1.7 3.29,66.73 ; JUSBC1.6 1.8,60.01 ; JUSBC1.6 3.29,59.18 ; JUSBC1.6 0.31,60.01 ; JUSBC1.6 3.29,58.34 ; JUSBC1.6 1.8,58.34 ; JUSBC1.6 3.29,60.01 ; JUSB1.4 396.42,66.34 ; JUSB1.4 395.76,64.84 ; JUSB1.4 397.08,64.84 ; JUSB1.4 397.26,65.5 ; JUSB1.4 396.42,64.66 ; JUSB1.4 397.08,66.16 ; 5.58,68 JUSBC1.10 ; JUSBC1.10 5.58,67.29 ; JUSBC1.10 6.25,66.57 ; JUSBC1.10 6.92,66.57 ; JUSBC1.10 6.92,68 ; JUSBC1.10 5.58,66.57 ; JUSBC1.10 6.25,68 ; JUSBC1.10 6.92,67.29 ; JUSB2.10 396.38,30.74 ; JUSB2.10 398.01,29.85 ; JUSB2.10 396.38,28.96 ; JUSB2.10 394.74,29.85 ; JUSB2.10 394.74,30.74 ; JUSB2.10 398.01,30.74 ; JUSB2.10 398.01,28.96 ; JUSB2.10 394.74,28.96 ; H12.1 229.54,20.76 ; H12.1 227.85,21.37 ; H12.1 225.55,19.07 ; H12.1 226.16,17.38 ; H12.1 230.15,19.07 ; H12.1 226.16,20.76 ; H12.1 227.85,16.77 ; H12.1 229.54,17.38 ; 114.86,109.16 JDG1.9 ; JDG1.9 115.85,107.74 ; JDG1.9 114.86,108.45 ; JDG1.9 115.85,109.16 ; JDG1.9 116.84,107.74 ; JDG1.9 116.84,108.45 ; JDG1.9 114.86,107.74 ; JDG1.9 116.84,109.16 ; 2.69,77.9 H18.1 ; H18.1 5.21,77.9 ; H18.1 3.95,80.84 ; H18.1 2.69,80.41 ; H18.1 2.26,79.16 ; H18.1 3.95,77.47 ; H18.1 5.21,80.41 ; H18.1 5.64,79.16 ; JDG1.7 116.84,96.34 ; JDG1.7 115.85,97.76 ; JDG1.7 114.86,96.34 ; JDG1.7 114.86,97.76 ; JDG1.7 116.84,97.76 ; JDG1.7 116.84,97.05 ; JDG1.7 114.86,97.05 ; JDG1.7 115.85,96.34 ; H14.1 403.75,76.07 ; H14.1 401.7,74.03 ; H14.1 403.75,71.98 ; H14.1 402.24,72.52 ; H14.1 405.26,75.54 ; H14.1 405.26,72.52 ; H14.1 402.24,75.54 ; H14.1 405.8,74.03 ; 323.11,64.8 H17.1 ; H17.1 326.32,63.43 ; H17.1 323.58,66.17 ; H17.1 324.95,62.96 ; H17.1 326.32,66.17 ; H17.1 323.58,63.43 ; H17.1 324.95,66.64 ; H17.1 326.79,64.8 ; JUSB2.11 398.01,45.14 ; JUSB2.11 394.74,45.14 ; JUSB2.11 398.01,43.36 ; JUSB2.11 396.38,45.14 ; JUSB2.11 394.74,43.36 ; JUSB2.11 394.74,44.25 ; JUSB2.11 398.01,44.25 ; JUSB2.11 396.38,43.36 ; 394.74,54.8 JUSB1.10 ; JUSB1.10 394.74,53.91 ; JUSB1.10 398.01,55.69 ; JUSB1.10 398.01,53.91 ; JUSB1.10 396.38,55.69 ; JUSB1.10 398.01,54.8 ; JUSB1.10 394.74,55.69 ; JUSB1.10 396.38,53.91 ; 108.58,94.17 H4.1 ; H4.1 111.32,91.43 ; H4.1 108.58,91.43 ; H4.1 109.95,94.64 ; H4.1 109.95,90.96 ; H4.1 111.32,94.17 ; H4.1 108.11,92.8 ; H4.1 111.79,92.8 ; H21.1 121.52,139.86 ; H21.1 122.06,138.36 ; H21.1 118.5,139.86 ; H21.1 121.52,136.85 ; H21.1 117.96,138.36 ; H21.1 120.01,136.31 ; H21.1 118.5,136.85 ; H21.1 120.01,140.4 ; H22.1 155.99,151.03 ; H22.1 152.97,151.03 ; H22.1 156.53,152.54 ; H22.1 154.48,154.58 ; H22.1 155.99,154.05 ; H22.1 154.48,150.49 ; H22.1 152.97,154.05 ; H22.1 152.43,152.54 ; 401.85,45.14 JUSB2.13 ; JUSB2.13 403.2,43.36 ; JUSB2.13 404.55,43.36 ; JUSB2.13 404.55,44.25 ; JUSB2.13 401.85,43.36 ; JUSB2.13 403.2,45.14 ; JUSB2.13 401.85,44.25 ; JUSB2.13 404.55,45.14 ; 112.38,163.2 JUSB3.11 ; JUSB3.11 114.06,164.5 ; JUSB3.11 113.22,163.2 ; JUSB3.11 112.38,164.5 ; JUSB3.11 114.06,163.2 ; JUSB3.7 120.51,163 ; JUSB3.7 120.31,162.31 ; JUSB3.7 118.73,163 ; JUSB3.7 119.62,163.89 ; JUSB3.7 119.62,162.11 ; JUSB3.7 118.93,162.31 ; 171.37,101.22 SW1.5 ; SW1.5 172.15,103.02 ; SW1.5 172.93,101.22 ; SW1.5 172.93,102.78 ; SW1.5 171.13,102 ; SW1.5 171.37,102.78 ; SW1.5 173.17,102 ; SW1.5 172.15,100.98 ; JUSBC1.4 8.17,76.14 ; JUSBC1.4 5.53,76.14 ; JUSBC1.4 5.53,75.38 ; JUSBC1.4 6.85,74.61 ; JUSBC1.4 8.17,74.61 ; JUSBC1.4 6.85,76.14 ; JUSBC1.4 8.17,75.38 ; 248.44,1.09 H15.1 ; H15.1 249.95,0.55 ; H15.1 251.46,1.09 ; H15.1 247.9,2.6 ; H15.1 252,2.6 ; H15.1 249.95,4.65 ; H15.1 248.44,4.11 ; H15.1 251.46,4.11 ; 1.8,74.54 JUSBC1.8 ; JUSBC1.8 0.31,76.21 ; JUSBC1.8 3.29,75.38 ; JUSBC1.8 3.29,74.54 ; JUSBC1.8 1.8,76.21 ; JUSBC1.8 3.29,76.21 ; JUSB2.4 397.26,40.55 ; JUSB2.4 395.76,39.89 ; JUSB2.4 397.08,41.21 ; JUSB2.4 397.08,39.89 ; JUSB2.4 396.42,41.39 ; JUSB2.4 396.42,39.71 ; 401.85,69.2 JUSB1.13 ; JUSB1.13 401.85,70.09 ; JUSB1.13 404.55,68.31 ; JUSB1.13 404.55,69.2 ; JUSB1.13 403.2,70.09 ; JUSB1.13 404.55,70.09 ; JUSB1.13 401.85,68.31 ; JUSB1.13 403.2,68.31 ; JUSB1.12 404.55,54.8 ; JUSB1.12 401.85,55.69 ; JUSB1.12 404.55,55.69 ; JUSB1.12 404.55,53.91 ; JUSB1.12 401.85,53.91 ; JUSB1.12 401.85,54.8 ; JUSB1.12 403.2,55.69 ; JUSB1.12 403.2,53.91 ; H19.1 8.22,39.66 ; H19.1 8.22,42.4 ; H19.1 5.01,41.03 ; H19.1 8.69,41.03 ; H19.1 5.48,39.66 ; H19.1 6.85,42.87 ; H19.1 5.48,42.4 ; H19.1 6.85,39.19 ; 401.85,30.74 JUSB2.12 ; JUSB2.12 404.55,28.96 ; JUSB2.12 403.2,28.96 ; JUSB2.12 404.55,29.85 ; JUSB2.12 401.85,28.96 ; JUSB2.12 401.85,29.85 ; JUSB2.12 403.2,30.74 ; JUSB2.12 404.55,30.74 ; JUSB3.10 126.86,163.2 ; JUSB3.10 126.86,164.5 ; JUSB3.10 126.02,163.2 ; JUSB3.10 125.18,163.2 ; JUSB3.10 125.18,164.5 ; 139.7,122.58 H3.1 ; H3.1 139.17,121.07 ; H3.1 141.21,123.12 ; H3.1 141.21,119.02 ; H3.1 139.7,119.56 ; H3.1 142.72,119.56 ; H3.1 143.26,121.07 ; H3.1 142.72,122.58 ; 164.83,102 SW1.4 ; SW1.4 165.85,103.02 ; SW1.4 165.07,101.22 ; SW1.4 166.63,101.22 ; SW1.4 165.07,102.78 ; SW1.4 166.63,102.78 ; SW1.4 165.85,100.98 ; JUSB3.13 111.77,176.99 ; JUSB3.13 110.93,175.3 ; JUSB3.13 111.77,173.61 ; JUSB3.13 110.93,176.99 ; JUSB3.13 110.93,173.61 ; 136.99,168.73 JLOM1.10 ; JLOM1.10 136.99,170.42 ; JLOM1.10 137.72,168.73 ; JLOM1.10 137.72,172.11 ; JLOM1.10 136.99,172.11 ; 5.58,58.62 JUSBC1.9 ; JUSBC1.9 5.58,57.91 ; JUSBC1.9 5.58,59.34 ; JUSBC1.9 6.92,59.34 ; JUSBC1.9 6.25,59.34 ; JUSBC1.9 6.92,58.62 ; 127.47,173.61 JUSB3.12 ; JUSB3.12 128.31,175.3 ; JUSB3.12 127.47,176.99 ; JUSB3.12 128.31,176.99 ; JUSB3.12 128.31,173.61 ; 5.54,50.84 JUSBC1.1 ; JUSBC1.1 6.25,51.75 ; JUSBC1.1 6.25,49.77 ; JUSBC1.1 6.96,51.75 ; JUSBC1.1 6.96,49.77 ; JUSBC1.1 5.54,51.75 ; JUSBC1.1 5.54,49.77 ; 110.76,96.34 JDG1.6 ; JDG1.6 112.74,96.34 ; JDG1.6 110.76,97.05 ; JDG1.6 112.74,97.05 ; JDG1.6 111.75,96.34 ; JDG1.6 110.76,97.76 ; JDG1.6 111.75,97.76 ; JDG1.6 112.74,97.76 ; JLOM1.9 154.51,170.42 ; JLOM1.9 153.77,168.73 ; JLOM1.9 154.51,168.73 ; JLOM1.9 154.51,172.11 ; JLOM1.9 153.77,172.11 ; 363.11,5.57 JNGFF4.77 ; JNGFF4.77 363.75,3.03 ; JNGFF4.77 363.11,4.3 ; JNGFF4.77 363.75,5.57 ; JNGFF4.77 363.11,3.03
  GND1 w0.508: 114.45,164.48 114.47,164.5 JUSB3.4 117.39,164.5 117.4,164.51
  IN1 w0.102: 138.91,48.21 138.91,51.98 138.58,52.31 138.07,52.31 v2(138,52.39) 140.89,55.29 141.06,55.29 v2(141.13,55.21) 141.5,55.21 141.69,55.02 141.69,54.2 140.36,52.87 140.18,52.87 139.67,52.36 139.67,46.92 v2(139.73,46.87) 139.51,46.65 138.88,46.65 138.68,46.45 138.68,46.17 138.66,46.14 138.66,45.76 v2(138.81,45.61) 139.06,45.35 139.06,44.18 138.52,43.63 137.82,43.63 136.93,44.52 v2(136.93,44.61) 136.93,44.69 137.87,45.63 v2(137.87,46.12) 138,46.24 138,47.29 138.91,48.21
  GND2 w0.254: JDG1.8 112.74,107.74 ; JDG1.8 110.76,107.74 ; JDG1.8 110.76,108.45 ; JDG1.8 112.74,108.45 ; JDG1.8 110.76,109.16 ; JDG1.8 112.74,109.16 ; JDG1.8 111.75,109.16 ; JDG1.8 111.75,107.74 ; H6.1 3.95,48.44 ; H6.1 2.69,48.01 ; H6.1 3.95,45.07 ; H6.1 2.69,45.5 ; H6.1 5.64,46.76 ; H6.1 5.21,48.01 ; H6.1 2.26,46.76 ; H6.1 5.21,45.5 ; H8.1 265.64,19.18 ; H8.1 263.95,18.57 ; H8.1 262.26,22.56 ; H8.1 263.95,23.17 ; H8.1 262.26,19.18 ; H8.1 265.64,22.56 ; H8.1 266.25,20.87 ; H8.1 261.65,20.87 ; H5.1 65.3,2.6 ; H5.1 63.25,0.55 ; H5.1 64.76,4.11 ; H5.1 61.74,1.09 ; H5.1 64.76,1.09 ; H5.1 61.74,4.11 ; H5.1 63.25,4.65 ; H5.1 61.2,2.6 ; 226.16,74.48 H13.1 ; H13.1 229.54,74.48 ; H13.1 227.85,78.47 ; H13.1 225.55,76.17 ; H13.1 229.54,77.86 ; H13.1 226.16,77.86 ; H13.1 227.85,73.87 ; H13.1 230.15,76.17 ; 395.76,39.89 JUSB2.4 ; JUSB2.4 396.42,39.71 ; JUSB2.4 397.08,39.89 ; JUSB2.4 396.42,41.39 ; JUSB2.4 397.26,40.55 ; JUSB2.4 397.08,41.21 ; JUSBC1.5 3.29,50.54 ; JUSBC1.5 3.29,51.37 ; JUSBC1.5 3.29,49.7 ; JUSBC1.5 1.8,49.7 ; JUSBC1.5 1.8,51.37 ; JUSB1.7 395.58,62.66 ; JUSB1.7 394.92,62.84 ; JUSB1.7 394.92,61.16 ; JUSB1.7 394.08,62 ; JUSB1.7 394.26,61.34 ; JUSB1.7 395.76,62 ; JUSB1.7 394.26,62.66 ; JUSB1.7 395.58,61.34 ; JDG1.9 116.84,109.16 ; JDG1.9 115.85,109.16 ; JDG1.9 115.85,107.74 ; JDG1.9 116.84,108.45 ; JDG1.9 116.84,107.74 ; JDG1.9 114.86,108.45 ; JDG1.9 114.86,107.74 ; JDG1.9 114.86,109.16 ; JDG1.7 116.84,96.34 ; JDG1.7 115.85,97.76 ; JDG1.7 114.86,97.05 ; JDG1.7 115.85,96.34 ; JDG1.7 116.84,97.76 ; JDG1.7 116.84,97.05 ; JDG1.7 114.86,96.34 ; JDG1.7 114.86,97.76 ; JUSBC1.8 3.29,75.38 ; JUSBC1.8 3.29,76.21 ; JUSBC1.8 1.8,76.21 ; JUSBC1.8 1.8,74.54 ; JUSBC1.8 3.29,74.54 ; JUSB1.12 404.55,54.8 ; JUSB1.12 401.85,55.69 ; JUSB1.12 403.2,55.69 ; JUSB1.12 401.85,54.8 ; JUSB1.12 403.2,53.91 ; JUSB1.12 404.55,53.91 ; JUSB1.12 404.55,55.69 ; JUSB1.12 401.85,53.91 ; 324.95,62.96 H17.1 ; H17.1 323.58,66.17 ; H17.1 324.95,66.64 ; H17.1 323.11,64.8 ; H17.1 323.58,63.43 ; H17.1 326.32,66.17 ; H17.1 326.32,63.43 ; H17.1 326.79,64.8 ; 110.76,97.76 JDG1.6 ; JDG1.6 111.75,96.34 ; JDG1.6 111.75,97.76 ; JDG1.6 112.74,97.76 ; JDG1.6 110.76,96.34 ; JDG1.6 110.76,97.05 ; JDG1.6 112.74,97.05 ; JDG1.6 112.74,96.34 ; H15.1 252,2.6 ; H15.1 251.46,1.09 ; H15.1 249.95,0.55 ; H15.1 249.95,4.65 ; H15.1 251.46,4.11 ; H15.1 247.9,2.6 ; H15.1 248.44,4.11 ; H15.1 248.44,1.09 ; 110.93,176.99 JUSB3.13 ; JUSB3.13 111.77,176.99 ; JUSB3.13 110.93,173.61 ; JUSB3.13 110.93,175.3 ; JUSB3.13 111.77,173.61 ; H22.1 154.48,154.58 ; H22.1 152.97,154.05 ; H22.1 152.97,151.03 ; H22.1 152.43,152.54 ; H22.1 154.48,150.49 ; H22.1 156.53,152.54 ; H22.1 155.99,151.03 ; H22.1 155.99,154.05 ; JUSB1.13 404.55,69.2 ; JUSB1.13 404.55,70.09 ; JUSB1.13 401.85,68.31 ; JUSB1.13 404.55,68.31 ; JUSB1.13 403.2,68.31 ; JUSB1.13 401.85,69.2 ; JUSB1.13 401.85,70.09 ; JUSB1.13 403.2,70.09 ; 1.91,62.95 H16.1 ; H16.1 4.86,64.21 ; H16.1 3.6,64.64 ; H16.1 3.6,61.27 ; H16.1 4.86,61.7 ; H16.1 5.29,62.95 ; H16.1 2.34,64.21 ; H16.1 2.34,61.7 ; JUSB2.12 404.55,30.74 ; JUSB2.12 401.85,30.74 ; JUSB2.12 401.85,28.96 ; JUSB2.12 404.55,29.85 ; JUSB2.12 401.85,29.85 ; JUSB2.12 403.2,28.96 ; JUSB2.12 404.55,28.96 ; JUSB2.12 403.2,30.74 ; H9.1 134.46,173.61 ; H9.1 132.95,174.15 ; H9.1 131.44,173.61 ; H9.1 130.9,172.1 ; H9.1 131.44,170.59 ; H9.1 134.46,170.59 ; H9.1 135,172.1 ; H9.1 132.95,170.05 ; JUSBC1.7 1.8,67.57 ; JUSBC1.7 1.8,65.9 ; JUSBC1.7 3.29,65.9 ; JUSBC1.7 3.29,67.57 ; JUSBC1.7 3.29,66.73 ; 120.01,136.31 H21.1 ; H21.1 118.5,136.85 ; H21.1 120.01,140.4 ; H21.1 122.06,138.36 ; H21.1 118.5,139.86 ; H21.1 121.52,136.85 ; H21.1 121.52,139.86 ; H21.1 117.96,138.36 ; JUSB3.12 128.31,175.3 ; JUSB3.12 128.31,176.99 ; JUSB3.12 128.31,173.61 ; JUSB3.12 127.47,173.61 ; JUSB3.12 127.47,176.99 ; JUSB2.13 404.55,43.36 ; JUSB2.13 401.85,44.25 ; JUSB2.13 404.55,44.25 ; JUSB2.13 403.2,43.36 ; JUSB2.13 404.55,45.14 ; JUSB2.13 403.2,45.14 ; JUSB2.13 401.85,43.36 ; JUSB2.13 401.85,45.14 ; 396.38,43.36 JUSB2.11 ; JUSB2.11 398.01,43.36 ; JUSB2.11 394.74,45.14 ; JUSB2.11 394.74,43.36 ; JUSB2.11 394.74,44.25 ; JUSB2.11 398.01,45.14 ; JUSB2.11 398.01,44.25 ; JUSB2.11 396.38,45.14 ; 225.55,19.07 H12.1 ; H12.1 229.54,20.76 ; H12.1 227.85,16.77 ; H12.1 230.15,19.07 ; H12.1 226.16,17.38 ; H12.1 227.85,21.37 ; H12.1 229.54,17.38 ; H12.1 226.16,20.76 ; H11.1 298,90.8 ; H11.1 295.95,92.85 ; H11.1 295.95,88.75 ; H11.1 294.44,92.31 ; H11.1 297.46,89.29 ; H11.1 297.46,92.31 ; H11.1 294.44,89.29 ; H11.1 293.9,90.8 ; H18.1 5.64,79.16 ; H18.1 3.95,77.47 ; H18.1 3.95,80.84 ; H18.1 2.26,79.16 ; H18.1 5.21,80.41 ; H18.1 2.69,80.41 ; H18.1 2.69,77.9 ; H18.1 5.21,77.9 ; JUSBC1.2 6.96,74.16 ; JUSBC1.2 5.54,74.16 ; JUSBC1.2 5.54,75.08 ; JUSBC1.2 6.96,76.14 ; JUSBC1.2 6.25,76.14 ; JUSBC1.2 6.25,74.16 ; JUSBC1.2 5.54,76.14 ; 403.75,71.98 H14.1 ; H14.1 401.7,74.03 ; H14.1 403.75,76.07 ; H14.1 405.8,74.03 ; H14.1 402.24,75.54 ; H14.1 405.26,75.54 ; H14.1 402.24,72.52 ; H14.1 405.26,72.52 ; 5.58,57.91 JUSBC1.9 ; JUSBC1.9 5.58,59.34 ; JUSBC1.9 6.25,57.91 ; JUSBC1.9 6.92,59.34 ; JUSBC1.9 6.25,59.34 ; JUSBC1.9 5.58,58.62 ; JUSBC1.9 6.92,58.62 ; JUSB3.4 116.81,163.81 ; JUSB3.4 117.01,164.5 ; JUSB3.4 116.81,165.19 ; JUSB3.4 115.43,165.19 ; JUSB3.4 115.23,164.5 ; JUSB3.4 116.12,165.39 ; 394.74,55.69 JUSB1.10 ; JUSB1.10 394.74,53.91 ; JUSB1.10 398.01,55.69 ; JUSB1.10 398.01,53.91 ; JUSB1.10 396.38,53.91 ; JUSB1.10 394.74,54.8 ; JUSB1.10 396.38,55.69 ; JUSB1.10 398.01,54.8 ; SW1.5 172.93,102.78 ; SW1.5 171.37,102.78 ; SW1.5 171.13,102 ; SW1.5 171.37,101.22 ; SW1.5 172.93,101.22 ; SW1.5 172.15,100.98 ; SW1.5 172.15,103.02 ; SW1.5 173.17,102 ; JUSBC1.3 8.17,51.3 ; JUSBC1.3 6.85,51.3 ; JUSBC1.3 5.53,49.77 ; JUSBC1.3 8.17,50.54 ; JUSBC1.3 5.53,50.54 ; JUSBC1.3 6.85,49.77 ; 165.85,100.98 SW1.4 ; SW1.4 165.07,101.22 ; SW1.4 164.83,102 ; SW1.4 165.85,103.02 ; SW1.4 166.63,101.22 ; SW1.4 166.63,102.78 ; SW1.4 165.07,102.78 ; H19.1 8.22,42.4 ; H19.1 5.01,41.03 ; H19.1 6.85,39.19 ; H19.1 5.48,42.4 ; H19.1 8.69,41.03 ; H19.1 5.48,39.66 ; H19.1 8.22,39.66 ; H19.1 6.85,42.87 ; JNGFF4.76 386.89,3.03 ; JNGFF4.76 386.89,4.3 ; JNGFF4.76 386.25,5.57 ; JNGFF4.76 386.89,5.57 ; JNGFF4.76 386.25,3.03 ; H4.1 109.95,94.64 ; H4.1 108.58,94.17 ; H4.1 111.32,91.43 ; H4.1 111.79,92.8 ; H4.1 109.95,90.96 ; H4.1 108.58,91.43 ; H4.1 108.11,92.8 ; H4.1 111.32,94.17 ; 261.65,75.27 H7.1 ; H7.1 265.64,76.96 ; H7.1 265.64,73.58 ; H7.1 262.26,76.96 ; H7.1 262.26,73.58 ; H7.1 263.95,77.57 ; H7.1 266.25,75.27 ; H7.1 263.95,72.97 ; 136.99,168.73 JLOM1.10 ; JLOM1.10 136.99,170.42 ; JLOM1.10 137.72,168.73 ; JLOM1.10 137.72,172.11 ; JLOM1.10 136.99,172.11 ; JUSBC1.6 3.29,58.34 ; JUSBC1.6 3.29,59.18 ; JUSBC1.6 3.29,60.01 ; JUSBC1.6 1.8,60.01 ; JUSBC1.6 1.8,58.34 ; JNGFF4.77 363.75,5.57 ; JNGFF4.77 363.11,5.57 ; JNGFF4.77 363.11,4.3 ; JNGFF4.77 363.11,3.03 ; JNGFF4.77 363.75,3.03 ; JUSBC1.10 6.25,68 ; JUSBC1.10 5.58,66.57 ; JUSBC1.10 6.92,66.57 ; JUSBC1.10 6.92,67.29 ; JUSBC1.10 5.58,67.29 ; JUSBC1.10 6.25,66.57 ; JUSBC1.10 5.58,68 ; JUSBC1.10 6.92,68 ; H3.1 142.72,122.58 ; H3.1 143.26,121.07 ; H3.1 139.7,119.56 ; H3.1 142.72,119.56 ; H3.1 139.7,122.58 ; H3.1 139.17,121.07 ; H3.1 141.21,119.02 ; H3.1 141.21,123.12 ; JUSB1.4 396.42,66.34 ; JUSB1.4 397.08,64.84 ; JUSB1.4 396.42,64.66 ; JUSB1.4 395.76,64.84 ; JUSB1.4 397.08,66.16 ; JUSB1.4 397.26,65.5 ; 125.18,164.5 JUSB3.10 ; JUSB3.10 126.02,163.2 ; JUSB3.10 126.86,163.2 ; JUSB3.10 126.86,164.5 ; JUSB3.10 125.18,163.2 ; JUSB1.11 398.01,68.31 ; JUSB1.11 398.01,69.2 ; JUSB1.11 396.38,70.09 ; JUSB1.11 394.74,70.09 ; JUSB1.11 394.74,68.31 ; JUSB1.11 394.74,69.2 ; JUSB1.11 398.01,70.09 ; JUSB1.11 396.38,68.31 ; 394.74,28.96 JUSB2.10 ; JUSB2.10 396.38,30.74 ; JUSB2.10 394.74,30.74 ; JUSB2.10 398.01,29.85 ; JUSB2.10 398.01,30.74 ; JUSB2.10 394.74,29.85 ; JUSB2.10 396.38,28.96 ; JUSB2.10 398.01,28.96 ; H1.1 393.76,1.49 ; H1.1 390.74,1.49 ; H1.1 393.76,4.51 ; H1.1 390.2,3 ; H1.1 390.74,4.51 ; H1.1 392.25,5.05 ; H1.1 394.3,3 ; H1.1 392.25,0.95 ; JUSBC1.1 6.25,51.75 ; JUSBC1.1 5.54,50.84 ; JUSBC1.1 6.96,49.77 ; JUSBC1.1 5.54,51.75 ; JUSBC1.1 6.25,49.77 ; JUSBC1.1 6.96,51.75 ; JUSBC1.1 5.54,49.77 ; 112.38,164.5 JUSB3.11 ; JUSB3.11 112.38,163.2 ; JUSB3.11 113.22,163.2 ; JUSB3.11 114.06,163.2 ; JUSB3.11 114.06,164.5 ; JUSB2.7 395.76,37.05 ; JUSB2.7 394.92,37.89 ; JUSB2.7 395.58,37.71 ; JUSB2.7 394.08,37.05 ; JUSB2.7 394.92,36.21 ; JUSB2.7 394.26,36.39 ; JUSB2.7 394.26,37.71 ; JUSB2.7 395.58,36.39 ; 153.77,168.73 JLOM1.9 ; JLOM1.9 154.51,170.42 ; JLOM1.9 154.51,172.11 ; JLOM1.9 154.51,168.73 ; JLOM1.9 153.77,172.11 ; 119.62,162.11 JUSB3.7 ; JUSB3.7 118.93,162.31 ; JUSB3.7 120.51,163 ; JUSB3.7 119.62,163.89 ; JUSB3.7 120.31,162.31 ; JUSB3.7 118.73,163 ; JUSBC1.4 8.17,74.61 ; JUSBC1.4 6.85,74.61 ; JUSBC1.4 5.53,76.14 ; JUSBC1.4 8.17,75.38 ; JUSBC1.4 5.53,75.38 ; JUSBC1.4 6.85,76.14 ; JUSBC1.4 8.17,76.14
  GND3 w0.254: H6.1 5.21,45.5 ; H6.1 3.95,48.44 ; H6.1 2.69,48.01 ; H6.1 2.26,46.76 ; H6.1 5.64,46.76 ; H6.1 3.95,45.07 ; H6.1 5.21,48.01 ; H6.1 2.69,45.5 ; H16.1 4.86,64.21 ; H16.1 1.91,62.95 ; H16.1 5.29,62.95 ; H16.1 2.34,61.7 ; H16.1 3.6,64.64 ; H16.1 4.86,61.7 ; H16.1 2.34,64.21 ; H16.1 3.6,61.27 ; H19.1 8.22,42.4 ; H19.1 5.48,42.4 ; H19.1 8.69,41.03 ; H19.1 8.22,39.66 ; H19.1 6.85,39.19 ; H19.1 6.85,42.87 ; H19.1 5.48,39.66 ; H19.1 5.01,41.03 ; JUSBC1.5 3.29,51.37 ; JUSBC1.5 1.8,49.7 ; JUSBC1.5 3.29,49.7 ; JUSBC1.5 3.29,50.54 ; JUSBC1.5 1.8,51.37 ; 114.86,107.74 JDG1.9 ; JDG1.9 116.84,109.16 ; JDG1.9 114.86,109.16 ; JDG1.9 114.86,108.45 ; JDG1.9 115.85,109.16 ; JDG1.9 116.84,107.74 ; JDG1.9 115.85,107.74 ; JDG1.9 116.84,108.45 ; 153.77,168.73 JLOM1.9 ; JLOM1.9 154.51,170.42 ; JLOM1.9 153.77,172.11 ; JLOM1.9 154.51,168.73 ; JLOM1.9 154.51,172.11 ; 386.25,3.03 JNGFF4.76 ; JNGFF4.76 386.89,4.3 ; JNGFF4.76 386.89,5.57 ; JNGFF4.76 386.25,5.57 ; JNGFF4.76 386.89,3.03 ; JUSB1.12 404.55,53.91 ; JUSB1.12 404.55,55.69 ; JUSB1.12 401.85,54.8 ; JUSB1.12 404.55,54.8 ; JUSB1.12 403.2,53.91 ; JUSB1.12 401.85,55.69 ; JUSB1.12 403.2,55.69 ; JUSB1.12 401.85,53.91 ; 401.85,69.2 JUSB1.13 ; JUSB1.13 403.2,70.09 ; JUSB1.13 404.55,69.2 ; JUSB1.13 404.55,70.09 ; JUSB1.13 404.55,68.31 ; JUSB1.13 403.2,68.31 ; JUSB1.13 401.85,68.31 ; JUSB1.13 401.85,70.09 ; JUSBC1.2 6.96,74.16 ; JUSBC1.2 6.25,76.14 ; JUSBC1.2 5.54,75.08 ; JUSBC1.2 6.96,76.14 ; JUSBC1.2 6.25,74.16 ; JUSBC1.2 5.54,74.16 ; JUSBC1.2 5.54,76.14 ; 248.44,4.11 H15.1 ; H15.1 249.95,4.65 ; H15.1 249.95,0.55 ; H15.1 248.44,1.09 ; H15.1 247.9,2.6 ; H15.1 252,2.6 ; H15.1 251.46,1.09 ; H15.1 251.46,4.11 ; H9.1 135,172.1 ; H9.1 134.46,173.61 ; H9.1 130.9,172.1 ; H9.1 131.44,173.61 ; H9.1 131.44,170.59 ; H9.1 132.95,170.05 ; H9.1 134.46,170.59 ; H9.1 132.95,174.15 ; 112.38,163.2 JUSB3.11 ; JUSB3.11 112.38,164.5 ; JUSB3.11 114.06,164.5 ; JUSB3.11 113.22,163.2 ; JUSB3.11 114.06,163.2 ; H1.1 394.3,3 ; H1.1 390.74,1.49 ; H1.1 393.76,1.49 ; H1.1 392.25,5.05 ; H1.1 390.2,3 ; H1.1 392.25,0.95 ; H1.1 393.76,4.51 ; H1.1 390.74,4.51 ; 1.8,58.34 JUSBC1.6 ; JUSBC1.6 3.29,59.18 ; JUSBC1.6 3.29,60.01 ; JUSBC1.6 1.8,60.01 ; JUSBC1.6 3.29,58.34 ; JDG1.6 112.74,97.76 ; JDG1.6 112.74,96.34 ; JDG1.6 110.76,97.76 ; JDG1.6 111.75,97.76 ; JDG1.6 110.76,96.34 ; JDG1.6 112.74,97.05 ; JDG1.6 111.75,96.34 ; JDG1.6 110.76,97.05 ; H4.1 111.32,91.43 ; H4.1 109.95,90.96 ; H4.1 111.79,92.8 ; H4.1 108.58,94.17 ; H4.1 109.95,94.64 ; H4.1 108.11,92.8 ; H4.1 111.32,94.17 ; H4.1 108.58,91.43 ; H18.1 5.21,77.9 ; H18.1 2.26,79.16 ; H18.1 3.95,77.47 ; H18.1 5.64,79.16 ; H18.1 2.69,77.9 ; H18.1 5.21,80.41 ; H18.1 2.69,80.41 ; H18.1 3.95,80.84 ; H7.1 266.25,75.27 ; H7.1 263.95,72.97 ; H7.1 265.64,73.58 ; H7.1 265.64,76.96 ; H7.1 262.26,76.96 ; H7.1 263.95,77.57 ; H7.1 261.65,75.27 ; H7.1 262.26,73.58 ; JUSB1.10 398.01,53.91 ; JUSB1.10 394.74,53.91 ; JUSB1.10 398.01,55.69 ; JUSB1.10 396.38,53.91 ; JUSB1.10 398.01,54.8 ; JUSB1.10 394.74,55.69 ; JUSB1.10 396.38,55.69 ; JUSB1.10 394.74,54.8 ; 110.93,176.99 JUSB3.13 ; JUSB3.13 110.93,173.61 ; JUSB3.13 111.77,176.99 ; JUSB3.13 110.93,175.3 ; JUSB3.13 111.77,173.61 ; 293.9,90.8 H11.1 ; H11.1 294.44,92.31 ; H11.1 294.44,89.29 ; H11.1 297.46,92.31 ; H11.1 295.95,92.85 ; H11.1 298,90.8 ; H11.1 295.95,88.75 ; H11.1 297.46,89.29 ; JUSB2.7 395.76,37.05 ; JUSB2.7 394.92,37.89 ; JUSB2.7 395.58,36.39 ; JUSB2.7 394.26,36.39 ; JUSB2.7 394.26,37.71 ; JUSB2.7 394.92,36.21 ; JUSB2.7 394.08,37.05 ; JUSB2.7 395.58,37.71 ; JUSB2.12 404.55,30.74 ; JUSB2.12 404.55,29.85 ; JUSB2.12 404.55,28.96 ; JUSB2.12 403.2,28.96 ; JUSB2.12 401.85,29.85 ; JUSB2.12 401.85,30.74 ; JUSB2.12 401.85,28.96 ; JUSB2.12 403.2,30.74 ; JUSBC1.7 1.8,67.57 ; JUSBC1.7 3.29,67.57 ; JUSBC1.7 3.29,66.73 ; JUSBC1.7 3.29,65.9 ; JUSBC1.7 1.8,65.9 ; 401.7,74.03 H14.1 ; H14.1 405.8,74.03 ; H14.1 403.75,71.98 ; H14.1 403.75,76.07 ; H14.1 405.26,72.52 ; H14.1 402.24,72.52 ; H14.1 405.26,75.54 ; H14.1 402.24,75.54 ; JUSB2.11 398.01,45.14 ; JUSB2.11 396.38,45.14 ; JUSB2.11 398.01,44.25 ; JUSB2.11 394.74,45.14 ; JUSB2.11 398.01,43.36 ; JUSB2.11 394.74,43.36 ; JUSB2.11 394.74,44.25 ; JUSB2.11 396.38,43.36 ; H21.1 120.01,140.4 ; H21.1 121.52,136.85 ; H21.1 121.52,139.86 ; H21.1 122.06,138.36 ; H21.1 118.5,139.86 ; H21.1 118.5,136.85 ; H21.1 120.01,136.31 ; H21.1 117.96,138.36 ; 61.74,1.09 H5.1 ; H5.1 65.3,2.6 ; H5.1 63.25,0.55 ; H5.1 61.74,4.11 ; H5.1 64.76,1.09 ; H5.1 61.2,2.6 ; H5.1 64.76,4.11 ; H5.1 63.25,4.65 ; JUSB3.12 127.47,176.99 ; JUSB3.12 128.31,173.61 ; JUSB3.12 128.31,175.3 ; JUSB3.12 127.47,173.61 ; JUSB3.12 128.31,176.99 ; 5.54,50.84 JUSBC1.1 ; JUSBC1.1 6.96,51.75 ; JUSBC1.1 5.54,51.75 ; JUSBC1.1 6.25,49.77 ; JUSBC1.1 6.96,49.77 ; JUSBC1.1 6.25,51.75 ; JUSBC1.1 5.54,49.77 ; 165.85,100.98 SW1.4 ; SW1.4 164.83,102 ; SW1.4 166.63,101.22 ; SW1.4 165.07,101.22 ; SW1.4 165.07,102.78 ; SW1.4 166.63,102.78 ; SW1.4 165.85,103.02 ; 363.11,3.03 JNGFF4.77 ; JNGFF4.77 363.75,3.03 ; JNGFF4.77 363.75,5.57 ; JNGFF4.77 363.11,5.57 ; JNGFF4.77 363.11,4.3 ; JUSB2.13 404.55,45.14 ; JUSB2.13 401.85,43.36 ; JUSB2.13 401.85,45.14 ; JUSB2.13 403.2,45.14 ; JUSB2.13 404.55,43.36 ; JUSB2.13 401.85,44.25 ; JUSB2.13 404.55,44.25 ; JUSB2.13 403.2,43.36 ; H8.1 263.95,23.17 ; H8.1 265.64,22.56 ; H8.1 266.25,20.87 ; H8.1 265.64,19.18 ; H8.1 263.95,18.57 ; H8.1 262.26,19.18 ; H8.1 262.26,22.56 ; H8.1 261.65,20.87 ; 323.11,64.8 H17.1 ; H17.1 323.58,66.17 ; H17.1 326.79,64.8 ; H17.1 323.58,63.43 ; H17.1 326.32,63.43 ; H17.1 324.95,66.64 ; H17.1 324.95,62.96 ; H17.1 326.32,66.17 ; 5.53,75.38 JUSBC1.4 ; JUSBC1.4 5.53,76.14 ; JUSBC1.4 6.85,74.61 ; JUSBC1.4 6.85,76.14 ; JUSBC1.4 8.17,76.14 ; JUSBC1.4 8.17,74.61 ; JUSBC1.4 8.17,75.38 ; JUSB1.7 395.58,62.66 ; JUSB1.7 394.08,62 ; JUSB1.7 394.26,62.66 ; JUSB1.7 394.92,61.16 ; JUSB1.7 394.26,61.34 ; JUSB1.7 394.92,62.84 ; JUSB1.7 395.76,62 ; JUSB1.7 395.58,61.34 ; 394.74,69.2 JUSB1.11 ; JUSB1.11 394.74,70.09 ; JUSB1.11 398.01,70.09 ; JUSB1.11 398.01,68.31 ; JUSB1.11 396.38,70.09 ; JUSB1.11 396.38,68.31 ; JUSB1.11 394.74,68.31 ; JUSB1.11 398.01,69.2 ; 139.7,122.58 H3.1 ; H3.1 142.72,122.58 ; H3.1 139.7,119.56 ; H3.1 141.21,119.02 ; H3.1 142.72,119.56 ; H3.1 141.21,123.12 ; H3.1 143.26,121.07 ; H3.1 139.17,121.07 ; 172.15,100.98 SW1.5 ; SW1.5 171.37,102.78 ; SW1.5 171.13,102 ; SW1.5 172.93,101.22 ; SW1.5 172.15,103.02 ; SW1.5 172.93,102.78 ; SW1.5 171.37,101.22 ; SW1.5 173.17,102 ; 395.76,64.84 JUSB1.4 ; JUSB1.4 396.42,66.34 ; JUSB1.4 397.08,64.84 ; JUSB1.4 397.26,65.5 ; JUSB1.4 397.08,66.16 ; JUSB1.4 396.42,64.66 ; JUSBC1.9 6.92,59.34 ; JUSBC1.9 6.25,57.91 ; JUSBC1.9 5.58,58.62 ; JUSBC1.9 5.58,57.91 ; JUSBC1.9 5.58,59.34 ; JUSBC1.9 6.25,59.34 ; JUSBC1.9 6.92,58.62 ; H12.1 230.15,19.07 ; H12.1 225.55,19.07 ; H12.1 226.16,17.38 ; H12.1 227.85,16.77 ; H12.1 226.16,20.76 ; H12.1 229.54,20.76 ; H12.1 227.85,21.37 ; H12.1 229.54,17.38 ; 136.99,170.42 JLOM1.10 ; JLOM1.10 137.72,172.11 ; JLOM1.10 136.99,172.11 ; JLOM1.10 136.99,168.73 ; JLOM1.10 137.72,168.73 ; JDG1.8 111.75,109.16 ; JDG1.8 110.76,108.45 ; JDG1.8 112.74,109.16 ; JDG1.8 110.76,109.16 ; JDG1.8 111.75,107.74 ; JDG1.8 112.74,107.74 ; JDG1.8 112.74,108.45 ; JDG1.8 110.76,107.74 ; JUSBC1.10 6.92,68 ; JUSBC1.10 6.92,66.57 ; JUSBC1.10 5.58,68 ; JUSBC1.10 6.92,67.29 ; JUSBC1.10 6.25,68 ; JUSBC1.10 5.58,66.57 ; JUSBC1.10 6.25,66.57 ; JUSBC1.10 5.58,67.29 ; 115.23,164.5 JUSB3.4 ; JUSB3.4 116.81,165.19 ; JUSB3.4 115.43,165.19 ; JUSB3.4 116.12,165.39 ; JUSB3.4 117.01,164.5 ; JUSB3.4 116.81,163.81 ; 394.74,29.85 JUSB2.10 ; JUSB2.10 398.01,29.85 ; JUSB2.10 396.38,30.74 ; JUSB2.10 394.74,30.74 ; JUSB2.10 394.74,28.96 ; JUSB2.10 398.01,28.96 ; JUSB2.10 396.38,28.96 ; JUSB2.10 398.01,30.74 ; H22.1 155.99,154.05 ; H22.1 156.53,152.54 ; H22.1 154.48,150.49 ; H22.1 152.97,154.05 ; H22.1 152.43,152.54 ; H22.1 154.48,154.58 ; H22.1 152.97,151.03 ; H22.1 155.99,151.03 ; 5.53,50.54 JUSBC1.3 ; JUSBC1.3 6.85,49.77 ; JUSBC1.3 8.17,51.3 ; JUSBC1.3 8.17,50.54 ; JUSBC1.3 6.85,51.3 ; JUSBC1.3 5.53,49.77 ; JUSB2.4 397.08,39.89 ; JUSB2.4 395.76,39.89 ; JUSB2.4 396.42,41.39 ; JUSB2.4 397.26,40.55 ; JUSB2.4 397.08,41.21 ; JUSB2.4 396.42,39.71 ; 125.18,164.5 JUSB3.10 ; JUSB3.10 125.18,163.2 ; JUSB3.10 126.86,164.5 ; JUSB3.10 126.86,163.2 ; JUSB3.10 126.02,163.2 ; 227.85,73.87 H13.1 ; H13.1 227.85,78.47 ; H13.1 229.54,77.86 ; H13.1 230.15,76.17 ; H13.1 225.55,76.17 ; H13.1 226.16,77.86 ; H13.1 226.16,74.48 ; H13.1 229.54,74.48 ; JUSB3.7 120.31,162.31 ; JUSB3.7 118.73,163 ; JUSB3.7 119.62,162.11 ; JUSB3.7 119.62,163.89 ; JUSB3.7 118.93,162.31 ; JUSB3.7 120.51,163 ; JUSBC1.8 3.29,76.21 ; JUSBC1.8 3.29,75.38 ; JUSBC1.8 1.8,74.54 ; JUSBC1.8 1.8,76.21 ; JUSBC1.8 3.29,74.54 ; 115.85,96.34 JDG1.7 ; JDG1.7 115.85,97.76 ; JDG1.7 116.84,97.76 ; JDG1.7 114.86,96.34 ; JDG1.7 114.86,97.76 ; JDG1.7 114.86,97.05 ; JDG1.7 116.84,96.34 ; JDG1.7 116.84,97.05
  VCC w0.203: 394.74,30.74 JUSB2.10 ; JUSB2.10 398.01,28.96 ; JUSB2.10 398.01,30.74 ; JUSB2.10 394.74,28.96 ; JUSB2.10 396.38,28.96 ; JUSB2.10 398.01,29.85 ; JUSB2.10 394.74,29.85 ; JUSB2.10 396.38,30.74 ; 396.42,39.71 JUSB2.4 ; JUSB2.4 396.42,41.39 ; JUSB2.4 397.08,41.21 ; JUSB2.4 397.26,40.55 ; JUSB2.4 397.08,39.89 ; JUSB2.4 395.76,39.89 ; 136.99,172.11 JLOM1.10 ; JLOM1.10 137.72,172.11 ; JLOM1.10 136.99,170.42 ; JLOM1.10 137.72,168.73 ; JLOM1.10 136.99,168.73 ; 363.11,4.3 JNGFF4.77 ; JNGFF4.77 363.75,3.03 ; JNGFF4.77 363.11,3.03 ; JUSB2.13 404.55,44.25 ; JUSB2.13 404.55,45.14 ; JUSB2.13 403.2,43.36 ; JUSB2.13 404.55,43.36 ; JUSB2.13 401.85,43.36 ; JUSB2.13 401.85,44.25 ; JUSB2.13 403.2,45.14 ; JUSB2.13 401.85,45.14 ; 2.69,48.01 H6.1 ; H6.1 5.64,46.76 ; H6.1 2.69,45.5 ; H6.1 5.21,45.5 ; H6.1 2.26,46.76 ; H6.1 5.21,48.01 ; H6.1 3.95,45.07 ; H6.1 3.95,48.44 ; JUSB3.10 126.86,163.2 ; JUSB3.10 125.18,164.5 ; JUSB3.10 125.18,163.2 ; JUSB3.10 126.02,163.2 ; JUSB3.10 126.86,164.5 ; JUSB1.13 404.55,70.09 ; JUSB1.13 403.2,68.31 ; JUSB1.13 401.85,70.09 ; JUSB1.13 404.55,68.31 ; JUSB1.13 401.85,68.31 ; JUSB1.13 403.2,70.09 ; JUSB1.13 401.85,69.2 ; JUSB1.13 404.55,69.2 ; H14.1 405.26,72.52 ; H14.1 403.75,71.98 ; H14.1 402.24,72.52 ; H14.1 405.8,74.03 ; H14.1 403.75,76.07 ; H14.1 405.26,75.54 ; H14.1 402.24,75.54 ; H14.1 401.7,74.03 ; 5.54,75.08 JUSBC1.2 ; JUSBC1.2 6.96,76.14 ; JUSBC1.2 6.96,74.16 ; JUSBC1.2 6.25,76.14 ; JUSBC1.2 5.54,74.16 ; JUSBC1.2 5.54,76.14 ; JUSBC1.2 6.25,74.16 ; JUSBC1.3 6.85,51.3 ; JUSBC1.3 5.53,49.77 ; JUSBC1.3 5.53,50.54 ; JUSBC1.3 6.85,49.77 ; 63.25,0.55 H5.1 ; H5.1 63.25,4.65 ; H5.1 61.2,2.6 ; H5.1 64.76,4.11 ; H5.1 61.74,1.09 ; H5.1 65.3,2.6 ; H5.1 61.74,4.11 ; H5.1 64.76,1.09 ; H22.1 155.99,154.05 ; H22.1 156.53,152.54 ; H22.1 152.97,151.03 ; H22.1 152.43,152.54 ; H22.1 154.48,154.58 ; H22.1 155.99,151.03 ; H22.1 152.97,154.05 ; H22.1 154.48,150.49 ; JNGFF4.76 386.25,5.57 ; JNGFF4.76 386.25,3.03 ; JNGFF4.76 386.89,3.03 ; JNGFF4.76 386.89,4.3 ; JNGFF4.76 386.89,5.57 ; 115.43,165.19 JUSB3.4 ; JUSB3.4 115.23,164.5 ; JUSB3.4 116.12,165.39 ; JUSB3.4 116.81,163.81 ; JUSB3.4 117.01,164.5 ; JUSB3.4 116.81,165.19 ; 390.74,4.51 H1.1 ; H1.1 392.25,5.05 ; H1.1 392.25,0.95 ; H1.1 390.2,3 ; H1.1 393.76,1.49 ; H1.1 393.76,4.51 ; H1.1 390.74,1.49 ; H1.1 394.3,3 ; JUSB1.7 394.92,62.84 ; JUSB1.7 394.92,61.16 ; JUSB1.7 394.26,61.34 ; JUSB1.7 395.58,61.34 ; JUSB1.7 394.08,62 ; JUSB1.7 395.76,62 ; JUSB1.7 395.58,62.66 ; JUSB1.7 394.26,62.66 ; H16.1 3.6,64.64 ; H16.1 5.29,62.95 ; H16.1 3.6,61.27 ; H16.1 2.34,61.7 ; H16.1 2.34,64.21 ; H16.1 1.91,62.95 ; H16.1 4.86,61.7 ; H16.1 4.86,64.21 ; 118.93,162.31 JUSB3.7 ; JUSB3.7 119.62,163.89 ; JUSB3.7 120.51,163 ; JUSB3.7 119.62,162.11 ; JUSB3.7 120.31,162.31 ; JUSB3.7 118.73,163 ; JUSBC1.8 3.29,76.21 ; JUSBC1.8 3.29,75.38 ; JUSBC1.8 1.8,76.21 ; JUSBC1.8 0.31,76.21 ; JUSBC1.8 3.29,74.54 ; JUSBC1.8 1.8,74.54 ; JUSBC1.6 1.8,60.01 ; JUSBC1.6 1.8,58.34 ; JUSBC1.6 3.29,60.01 ; JUSBC1.6 3.29,59.18 ; JUSBC1.6 0.31,60.01 ; JUSBC1.6 3.29,58.34 ; 5.54,49.77 JUSBC1.1 ; JUSBC1.1 5.54,50.84 ; JUSBC1.1 6.96,49.77 ; JUSBC1.1 5.54,51.75 ; JUSBC1.1 6.96,51.75 ; JUSBC1.1 6.25,49.77 ; JUSBC1.1 6.25,51.75 ; JUSB3.13 111.77,176.99 ; JUSB3.13 110.93,175.3 ; JUSB3.13 110.93,173.61 ; JUSB3.13 111.77,173.61 ; JUSB3.13 110.93,176.99 ; JUSB1.11 398.01,70.09 ; JUSB1.11 396.38,70.09 ; JUSB1.11 398.01,69.2 ; JUSB1.11 398.01,68.31 ; JUSB1.11 394.74,69.2 ; JUSB1.11 396.38,68.31 ; JUSB1.11 394.74,68.31 ; JUSB1.11 394.74,70.09 ; 5.53,76.14 JUSBC1.4 ; JUSBC1.4 8.17,74.61 ; JUSBC1.4 8.17,75.38 ; JUSBC1.4 8.17,76.14 ; JUSBC1.4 6.85,74.61 ; JUSBC1.4 6.85,76.14 ; JUSBC1.4 5.53,75.38 ; JUSBC1.10 6.92,68 ; JUSBC1.10 5.58,66.57 ; JUSBC1.10 5.58,68 ; JUSBC1.10 6.92,66.57 ; JUSBC1.10 6.25,68 ; JUSBC1.10 6.25,66.57 ; JUSBC1.10 6.92,67.29 ; JUSBC1.10 5.58,67.29 ; 131.44,173.61 H9.1 ; H9.1 131.44,170.59 ; H9.1 134.46,173.61 ; H9.1 134.46,170.59 ; H9.1 135,172.1 ; H9.1 132.95,174.15 ; H9.1 132.95,170.05 ; H9.1 130.9,172.1 ; JUSB2.12 404.55,30.74 ; JUSB2.12 403.2,28.96 ; JUSB2.12 401.85,28.96 ; JUSB2.12 404.55,29.85 ; JUSB2.12 401.85,29.85 ; JUSB2.12 401.85,30.74 ; JUSB2.12 403.2,30.74 ; JUSB2.12 404.55,28.96 ; 394.26,37.71 JUSB2.7 ; JUSB2.7 394.92,36.21 ; JUSB2.7 394.26,36.39 ; JUSB2.7 394.08,37.05 ; JUSB2.7 395.58,36.39 ; JUSB2.7 394.92,37.89 ; JUSB2.7 395.76,37.05 ; JUSB2.7 395.58,37.71 ; 249.95,0.55 H15.1 ; H15.1 248.44,4.11 ; H15.1 251.46,1.09 ; H15.1 249.95,4.65 ; H15.1 247.9,2.6 ; H15.1 252,2.6 ; H15.1 248.44,1.09 ; H15.1 251.46,4.11 ; 112.38,164.5 JUSB3.11 ; JUSB3.11 112.38,163.2 ; JUSB3.11 113.22,163.2 ; JUSB3.11 114.06,164.5 ; JUSB3.11 114.06,163.2 ; 2.26,79.16 H18.1 ; H18.1 2.69,77.9 ; H18.1 3.95,77.47 ; H18.1 2.69,80.41 ; H18.1 3.95,80.84 ; H18.1 5.21,77.9 ; H18.1 5.64,79.16 ; H18.1 5.21,80.41 ; JUSB1.12 404.55,55.69 ; JUSB1.12 404.55,53.91 ; JUSB1.12 403.2,53.91 ; JUSB1.12 401.85,55.69 ; JUSB1.12 401.85,53.91 ; JUSB1.12 403.2,55.69 ; JUSB1.12 404.55,54.8 ; JUSB1.12 401.85,54.8 ; 127.47,173.61 JUSB3.12 ; JUSB3.12 128.31,176.99 ; JUSB3.12 128.31,173.61 ; JUSB3.12 127.47,176.99 ; JUSB3.12 128.31,175.3 ; 5.48,42.4 H19.1 ; H19.1 8.22,42.4 ; H19.1 5.48,39.66 ; H19.1 8.22,39.66 ; H19.1 6.85,39.19 ; H19.1 5.01,41.03 ; H19.1 6.85,42.87 ; 5.58,57.91 JUSBC1.9 ; JUSBC1.9 6.25,59.34 ; JUSBC1.9 5.58,58.62 ; JUSBC1.9 6.25,57.91 ; JUSBC1.9 5.58,59.34 ; JUSBC1.9 6.92,59.34 ; JUSBC1.9 6.92,58.62 ; JUSBC1.5 3.29,49.7 ; JUSBC1.5 0.31,49.7 ; JUSBC1.5 1.8,49.7 ; JUSBC1.5 1.8,51.37 ; JUSBC1.5 3.29,50.54 ; JUSBC1.5 3.29,51.37 ; JUSB1.4 397.08,66.16 ; JUSB1.4 397.08,64.84 ; JUSB1.4 396.42,64.66 ; JUSB1.4 395.76,64.84 ; JUSB1.4 396.42,66.34 ; JUSB1.4 397.26,65.5 ; 394.74,43.36 JUSB2.11 ; JUSB2.11 398.01,44.25 ; JUSB2.11 398.01,43.36 ; JUSB2.11 394.74,44.25 ; JUSB2.11 396.38,45.14 ; JUSB2.11 396.38,43.36 ; JUSB2.11 394.74,45.14 ; JUSB2.11 398.01,45.14 ; JLOM1.9 153.77,172.11 ; JLOM1.9 154.51,170.42 ; JLOM1.9 154.51,172.11 ; JLOM1.9 153.77,168.73 ; JLOM1.9 154.51,168.73 ; JUSB1.10 398.01,55.69 ; JUSB1.10 394.74,55.69 ; JUSB1.10 396.38,55.69 ; JUSB1.10 398.01,54.8 ; JUSB1.10 398.01,53.91 ; JUSB1.10 396.38,53.91 ; JUSB1.10 394.74,54.8 ; JUSB1.10 394.74,53.91 ; JUSBC1.7 3.29,67.57 ; JUSBC1.7 1.8,67.57 ; JUSBC1.7 3.29,65.9 ; JUSBC1.7 0.31,65.9 ; JUSBC1.7 1.8,65.9 ; JUSBC1.7 3.29,66.73
  GND4 w0.254: 2.34,64.21 H16.1 ; H16.1 4.86,64.21 ; H16.1 1.91,62.95 ; H16.1 5.29,62.95 ; H16.1 3.6,64.64 ; H16.1 3.6,61.27 ; H16.1 2.34,61.7 ; H16.1 4.86,61.7 ; 323.58,63.43 H17.1 ; H17.1 323.58,66.17 ; H17.1 326.32,63.43 ; H17.1 323.11,64.8 ; H17.1 326.79,64.8 ; H17.1 324.95,66.64 ; H17.1 324.95,62.96 ; H17.1 326.32,66.17 ; 226.16,20.76 H12.1 ; H12.1 229.54,20.76 ; H12.1 226.16,17.38 ; H12.1 230.15,19.07 ; H12.1 225.55,19.07 ; H12.1 227.85,21.37 ; H12.1 227.85,16.77 ; H12.1 229.54,17.38 ; JUSB1.11 398.01,69.2 ; JUSB1.11 394.74,68.31 ; JUSB1.11 396.38,70.09 ; JUSB1.11 398.01,68.31 ; JUSB1.11 396.38,68.31 ; JUSB1.11 394.74,70.09 ; JUSB1.11 394.74,69.2 ; JUSB1.11 398.01,70.09 ; H15.1 249.95,4.65 ; H15.1 251.46,4.11 ; H15.1 247.9,2.6 ; H15.1 252,2.6 ; H15.1 251.46,1.09 ; H15.1 249.95,0.55 ; H15.1 248.44,1.09 ; H15.1 248.44,4.11 ; 401.85,45.14 JUSB2.13 ; JUSB2.13 401.85,43.36 ; JUSB2.13 403.2,45.14 ; JUSB2.13 404.55,44.25 ; JUSB2.13 403.2,43.36 ; JUSB2.13 401.85,44.25 ; JUSB2.13 404.55,43.36 ; JUSB2.13 404.55,45.14 ; 110.76,108.45 JDG1.8 ; JDG1.8 111.75,107.74 ; JDG1.8 110.76,107.74 ; JDG1.8 112.74,107.74 ; JDG1.8 110.76,109.16 ; JDG1.8 112.74,108.45 ; JDG1.8 112.74,109.16 ; JDG1.8 111.75,109.16 ; 401.85,68.31 JUSB1.13 ; JUSB1.13 403.2,68.31 ; JUSB1.13 404.55,69.2 ; JUSB1.13 401.85,69.2 ; JUSB1.13 404.55,70.09 ; JUSB1.13 401.85,70.09 ; JUSB1.13 404.55,68.31 ; JUSB1.13 403.2,70.09 ; JDG1.6 112.74,96.34 ; JDG1.6 110.76,96.34 ; JDG1.6 110.76,97.05 ; JDG1.6 111.75,97.76 ; JDG1.6 110.76,97.76 ; JDG1.6 111.75,96.34 ; JDG1.6 112.74,97.76 ; JDG1.6 112.74,97.05 ; 392.25,0.95 H1.1 ; H1.1 393.76,1.49 ; H1.1 390.74,4.51 ; H1.1 394.3,3 ; H1.1 392.25,5.05 ; H1.1 390.74,1.49 ; H1.1 393.76,4.51 ; H1.1 390.2,3 ; JUSBC1.4 8.17,76.14 ; JUSBC1.4 6.85,74.61 ; JUSBC1.4 5.53,76.14 ; JUSBC1.4 5.53,75.38 ; JUSBC1.4 8.17,75.38 ; JUSBC1.4 8.17,74.61 ; JUSBC1.4 6.85,76.14 ; 293.9,90.8 H11.1 ; H11.1 294.44,92.31 ; H11.1 294.44,89.29 ; H11.1 297.46,89.29 ; H11.1 297.46,92.31 ; H11.1 298,90.8 ; H11.1 295.95,88.75 ; H11.1 295.95,92.85 ; 114.86,107.74 JDG1.9 ; JDG1.9 116.84,108.45 ; JDG1.9 116.84,107.74 ; JDG1.9 114.86,109.16 ; JDG1.9 115.85,107.74 ; JDG1.9 115.85,109.16 ; JDG1.9 116.84,109.16 ; JDG1.9 114.86,108.45 ; JUSBC1.1 6.25,51.75 ; JUSBC1.1 5.54,51.75 ; JUSBC1.1 6.96,51.75 ; JUSBC1.1 5.54,50.84 ; JUSBC1.1 6.96,49.77 ; JUSBC1.1 6.25,49.77 ; JUSBC1.1 5.54,49.77 ; SW1.4 166.63,101.22 ; SW1.4 166.63,102.78 ; SW1.4 165.85,100.98 ; SW1.4 165.85,103.02 ; SW1.4 165.07,101.22 ; SW1.4 165.07,102.78 ; SW1.4 164.83,102 ; JUSB1.4 397.08,66.16 ; JUSB1.4 396.42,64.66 ; JUSB1.4 395.76,64.84 ; JUSB1.4 396.42,66.34 ; JUSB1.4 397.26,65.5 ; JUSB1.4 397.08,64.84 ; H21.1 121.52,136.85 ; H21.1 117.96,138.36 ; H21.1 120.01,140.4 ; H21.1 121.52,139.86 ; H21.1 120.01,136.31 ; H21.1 118.5,136.85 ; H21.1 118.5,139.86 ; H21.1 122.06,138.36 ; JUSB1.12 403.2,55.69 ; JUSB1.12 401.85,55.69 ; JUSB1.12 404.55,54.8 ; JUSB1.12 401.85,54.8 ; JUSB1.12 404.55,55.69 ; JUSB1.12 403.2,53.91 ; JUSB1.12 404.55,53.91 ; JUSB1.12 401.85,53.91 ; H22.1 155.99,151.03 ; H22.1 152.97,151.03 ; H22.1 152.97,154.05 ; H22.1 152.43,152.54 ; H22.1 154.48,154.58 ; H22.1 154.48,150.49 ; H22.1 156.53,152.54 ; H22.1 155.99,154.05 ; H5.1 64.76,4.11 ; H5.1 61.74,4.11 ; H5.1 63.25,0.55 ; H5.1 63.25,4.65 ; H5.1 64.76,1.09 ; H5.1 61.74,1.09 ; H5.1 65.3,2.6 ; H5.1 61.2,2.6 ; JDG1.7 115.85,97.76 ; JDG1.7 114.86,97.76 ; JDG1.7 114.86,96.34 ; JDG1.7 116.84,97.76 ; JDG1.7 115.85,96.34 ; JDG1.7 116.84,97.05 ; JDG1.7 116.84,96.34 ; JDG1.7 114.86,97.05 ; 396.42,39.71 JUSB2.4 ; JUSB2.4 397.08,41.21 ; JUSB2.4 397.08,39.89 ; JUSB2.4 396.42,41.39 ; JUSB2.4 397.26,40.55 ; JUSB2.4 395.76,39.89 ; 6.85,49.77 JUSBC1.3 ; JUSBC1.3 8.17,51.3 ; JUSBC1.3 5.53,49.77 ; JUSBC1.3 8.17,50.54 ; JUSBC1.3 5.53,50.54 ; JUSBC1.3 6.85,51.3 ; JUSB1.10 396.38,55.69 ; JUSB1.10 396.38,53.91 ; JUSB1.10 398.01,53.91 ; JUSB1.10 398.01,55.69 ; JUSB1.10 394.74,53.91 ; JUSB1.10 394.74,55.69 ; JUSB1.10 398.01,54.8 ; JUSB1.10 394.74,54.8 ; 403.2,28.96 JUSB2.12 ; JUSB2.12 404.55,28.96 ; JUSB2.12 401.85,28.96 ; JUSB2.12 404.55,29.85 ; JUSB2.12 401.85,30.74 ; JUSB2.12 403.2,30.74 ; JUSB2.12 404.55,30.74 ; JUSB2.12 401.85,29.85 ; JUSB2.7 395.58,37.71 ; JUSB2.7 394.92,37.89 ; JUSB2.7 395.58,36.39 ; JUSB2.7 394.08,37.05 ; JUSB2.7 394.92,36.21 ; JUSB2.7 395.76,37.05 ; JUSB2.7 394.26,37.71 ; JUSB2.7 394.26,36.39 ; H18.1 3.95,80.84 ; H18.1 3.95,77.47 ; H18.1 5.64,79.16 ; H18.1 2.26,79.16 ; H18.1 2.69,77.9 ; H18.1 2.69,80.41 ; H18.1 5.21,77.9 ; H18.1 5.21,80.41 ; 1.8,74.54 JUSBC1.8 ; JUSBC1.8 3.29,75.38 ; JUSBC1.8 3.29,74.54 ; JUSBC1.8 3.29,76.21 ; JUSBC1.8 1.8,76.21 ; 110.93,176.99 JUSB3.13 ; JUSB3.13 110.93,175.3 ; JUSB3.13 110.93,173.61 ; JUSB3.13 111.77,173.61 ; JUSB3.13 111.77,176.99 ; 136.99,172.11 JLOM1.10 ; JLOM1.10 137.72,168.73 ; JLOM1.10 136.99,170.42 ; JLOM1.10 136.99,168.73 ; JLOM1.10 137.72,172.11 ; H6.1 5.21,48.01 ; H6.1 3.95,45.07 ; H6.1 5.21,45.5 ; H6.1 3.95,48.44 ; H6.1 2.26,46.76 ; H6.1 2.69,48.01 ; H6.1 5.64,46.76 ; H6.1 2.69,45.5 ; JUSB3.4 116.81,163.81 ; JUSB3.4 115.23,164.5 ; JUSB3.4 115.43,165.19 ; JUSB3.4 116.81,165.19 ; JUSB3.4 117.01,164.5 ; JUSB3.4 116.12,165.39 ; H14.1 403.75,76.07 ; H14.1 402.24,75.54 ; H14.1 405.8,74.03 ; H14.1 401.7,74.03 ; H14.1 405.26,75.54 ; H14.1 405.26,72.52 ; H14.1 403.75,71.98 ; H14.1 402.24,72.52 ; 394.26,61.34 JUSB1.7 ; JUSB1.7 394.92,61.16 ; JUSB1.7 394.26,62.66 ; JUSB1.7 395.58,61.34 ; JUSB1.7 395.76,62 ; JUSB1.7 395.58,62.66 ; JUSB1.7 394.92,62.84 ; JUSB1.7 394.08,62 ; JUSB3.7 119.62,163.89 ; JUSB3.7 118.93,162.31 ; JUSB3.7 120.51,163 ; JUSB3.7 118.73,163 ; JUSB3.7 120.31,162.31 ; JUSB3.7 119.62,162.11 ; 262.26,19.18 H8.1 ; H8.1 261.65,20.87 ; H8.1 265.64,22.56 ; H8.1 263.95,23.17 ; H8.1 263.95,18.57 ; H8.1 262.26,22.56 ; H8.1 266.25,20.87 ; H8.1 265.64,19.18 ; 171.37,102.78 SW1.5 ; SW1.5 171.13,102 ; SW1.5 172.15,103.02 ; SW1.5 172.15,100.98 ; SW1.5 172.93,102.78 ; SW1.5 173.17,102 ; SW1.5 172.93,101.22 ; SW1.5 171.37,101.22 ; 5.58,58.62 JUSBC1.9 ; JUSBC1.9 5.58,59.34 ; JUSBC1.9 6.92,59.34 ; JUSBC1.9 5.58,57.91 ; JUSBC1.9 6.92,58.62 ; JUSBC1.9 6.25,57.91 ; JUSBC1.9 6.25,59.34 ; JUSB2.10 398.01,28.96 ; JUSB2.10 396.38,30.74 ; JUSB2.10 396.38,28.96 ; JUSB2.10 398.01,30.74 ; JUSB2.10 394.74,30.74 ; JUSB2.10 394.74,29.85 ; JUSB2.10 394.74,28.96 ; JUSB2.10 398.01,29.85 ; 131.44,170.59 H9.1 ; H9.1 134.46,173.61 ; H9.1 132.95,174.15 ; H9.1 134.46,170.59 ; H9.1 132.95,170.05 ; H9.1 131.44,173.61 ; H9.1 130.9,172.1 ; H9.1 135,172.1 ; 5.58,68 JUSBC1.10 ; JUSBC1.10 6.25,68 ; JUSBC1.10 6.92,66.57 ; JUSBC1.10 5.58,66.57 ; JUSBC1.10 6.25,66.57 ; JUSBC1.10 5.58,67.29 ; JUSBC1.10 6.92,67.29 ; JUSBC1.10 6.92,68 ; JUSB3.11 114.06,163.2 ; JUSB3.11 112.38,164.5 ; JUSB3.11 112.38,163.2 ; JUSB3.11 114.06,164.5 ; JUSB3.11 113.22,163.2 ; 226.16,77.86 H13.1 ; H13.1 229.54,77.86 ; H13.1 230.15,76.17 ; H13.1 227.85,78.47 ; H13.1 226.16,74.48 ; H13.1 229.54,74.48 ; H13.1 225.55,76.17 ; H13.1 227.85,73.87 ; JLOM1.9 154.51,172.11 ; JLOM1.9 154.51,168.73 ; JLOM1.9 153.77,172.11 ; JLOM1.9 154.51,170.42 ; JLOM1.9 153.77,168.73 ; 125.18,164.5 JUSB3.10 ; JUSB3.10 126.02,163.2 ; JUSB3.10 125.18,163.2 ; JUSB3.10 126.86,163.2 ; JUSB3.10 126.86,164.5 ; JUSBC1.7 3.29,67.57 ; JUSBC1.7 1.8,67.57 ; JUSBC1.7 1.8,65.9 ; JUSBC1.7 3.29,65.9 ; JUSBC1.7 3.29,66.73 ; 5.48,42.4 H19.1 ; H19.1 5.48,39.66 ; H19.1 8.22,42.4 ; H19.1 8.69,41.03 ; H19.1 6.85,42.87 ; H19.1 5.01,41.03 ; H19.1 8.22,39.66 ; H19.1 6.85,39.19 ; H7.1 265.64,73.58 ; H7.1 261.65,75.27 ; H7.1 265.64,76.96 ; H7.1 263.95,77.57 ; H7.1 262.26,76.96 ; H7.1 263.95,72.97 ; H7.1 262.26,73.58 ; H7.1 266.25,75.27 ; 139.7,122.58 H3.1 ; H3.1 139.17,121.07 ; H3.1 142.72,119.56 ; H3.1 139.7,119.56 ; H3.1 142.72,122.58 ; H3.1 143.26,121.07 ; H3.1 141.21,123.12 ; H3.1 141.21,119.02 ; JUSB3.12 128.31,176.99 ; JUSB3.12 128.31,173.61 ; JUSB3.12 127.47,173.61 ; JUSB3.12 127.47,176.99 ; JUSB3.12 128.31,175.3 ; JUSBC1.5 1.8,51.37 ; JUSBC1.5 3.29,51.37 ; JUSBC1.5 1.8,49.7 ; JUSBC1.5 3.29,49.7 ; JUSBC1.5 3.29,50.54 ; H4.1 111.32,94.17 ; H4.1 111.79,92.8 ; H4.1 109.95,90.96 ; H4.1 111.32,91.43 ; H4.1 108.58,94.17 ; H4.1 108.58,91.43 ; H4.1 108.11,92.8 ; H4.1 109.95,94.64 ; JUSBC1.2 6.25,76.14 ; JUSBC1.2 5.54,74.16 ; JUSBC1.2 5.54,76.14 ; JUSBC1.2 6.96,76.14 ; JUSBC1.2 6.96,74.16 ; JUSBC1.2 6.25,74.16 ; JUSBC1.2 5.54,75.08 ; 363.75,3.03 JNGFF4.77 ; JNGFF4.77 363.11,4.3 ; JNGFF4.77 363.11,5.57 ; JNGFF4.77 363.11,3.03 ; JNGFF4.77 363.75,5.57 ; 386.25,3.03 JNGFF4.76 ; JNGFF4.76 386.89,5.57 ; JNGFF4.76 386.25,5.57 ; JNGFF4.76 386.89,4.3 ; JNGFF4.76 386.89,3.03 ; JUSBC1.6 1.8,60.01 ; JUSBC1.6 1.8,58.34 ; JUSBC1.6 3.29,59.18 ; JUSBC1.6 3.29,58.34 ; JUSBC1.6 3.29,60.01 ; 394.74,44.25 JUSB2.11 ; JUSB2.11 398.01,45.14 ; JUSB2.11 396.38,43.36 ; JUSB2.11 396.38,45.14 ; JUSB2.11 394.74,45.14 ; JUSB2.11 398.01,44.25 ; JUSB2.11 398.01,43.36 ; JUSB2.11 394.74,43.36
  IN4 w0.508: v2(385.52,13.67) 385.52,14.22 386.89,15.58 386.89,16.78 387.58,17.46 387.58,17.72 v2(387.91,18.05) ; 395.01,28.53 395,28.52 391.61,28.52 v2(391.22,28.14) 391.22,27.4 v2(391.28,27.24) 391.24,27.19 391.24,26.91 391.09,26.76 v2(391.09,26.44) 391.09,25.77 v2(391.03,25.71)
  GND5 w0.203: 153.77,168.73 JLOM1.9 ; JLOM1.9 154.51,168.73 ; JLOM1.9 154.51,170.42 ; JLOM1.9 153.77,172.11 ; JLOM1.9 154.51,172.11 ; 111.75,96.34 JDG1.6 ; JDG1.6 110.76,97.76 ; JDG1.6 112.74,96.34 ; JDG1.6 111.75,97.76 ; JDG1.6 110.76,96.34 ; JDG1.6 112.74,97.05 ; JDG1.6 110.76,97.05 ; JDG1.6 112.74,97.76 ; JUSB3.10 126.86,164.5 ; JUSB3.10 125.18,163.2 ; JUSB3.10 126.86,163.2 ; JUSB3.10 125.18,164.5 ; JUSB3.10 126.02,163.2 ; 152.97,154.05 H22.1 ; H22.1 155.99,151.03 ; H22.1 152.97,151.03 ; H22.1 155.99,154.05 ; H22.1 156.53,152.54 ; H22.1 152.43,152.54 ; H22.1 154.48,150.49 ; H22.1 154.48,154.58 ; 401.7,74.03 H14.1 ; H14.1 405.26,75.54 ; H14.1 402.24,72.52 ; H14.1 402.24,75.54 ; H14.1 403.75,71.98 ; H14.1 403.75,76.07 ; H14.1 405.8,74.03 ; H14.1 405.26,72.52 ; JUSB2.4 397.26,40.55 ; JUSB2.4 397.08,39.89 ; JUSB2.4 396.42,41.39 ; JUSB2.4 397.08,41.21 ; JUSB2.4 396.42,39.71 ; JUSB2.4 395.76,39.89 ; JUSBC1.2 6.96,76.14 ; JUSBC1.2 5.54,74.16 ; JUSBC1.2 6.25,76.14 ; JUSBC1.2 5.54,75.08 ; JUSBC1.2 5.54,76.14 ; JUSBC1.2 6.25,74.16 ; JUSBC1.6 3.29,59.18 ; JUSBC1.6 3.29,58.34 ; JUSBC1.6 1.8,60.01 ; JUSBC1.6 0.31,60.01 ; JUSBC1.6 3.29,60.01 ; JUSBC1.6 1.8,58.34 ; JUSB3.7 120.51,163 ; JUSB3.7 119.62,162.11 ; JUSB3.7 118.73,163 ; JUSB3.7 120.31,162.31 ; JUSB3.7 118.93,162.31 ; JUSB3.7 119.62,163.89 ; 110.93,173.61 JUSB3.13 ; JUSB3.13 111.77,176.99 ; JUSB3.13 110.93,176.99 ; JUSB3.13 111.77,173.61 ; JUSB3.13 110.93,175.3 ; 403.2,43.36 JUSB2.13 ; JUSB2.13 401.85,45.14 ; JUSB2.13 404.55,43.36 ; JUSB2.13 403.2,45.14 ; JUSB2.13 404.55,45.14 ; JUSB2.13 404.55,44.25 ; JUSB2.13 401.85,43.36 ; JUSB2.13 401.85,44.25 ; JUSB1.12 404.55,53.91 ; JUSB1.12 403.2,53.91 ; JUSB1.12 401.85,54.8 ; JUSB1.12 403.2,55.69 ; JUSB1.12 404.55,54.8 ; JUSB1.12 401.85,53.91 ; JUSB1.12 404.55,55.69 ; JUSB1.12 401.85,55.69 ; 323.58,63.43 H17.1 ; H17.1 323.11,64.8 ; H17.1 326.32,66.17 ; H17.1 324.95,62.96 ; H17.1 326.79,64.8 ; H17.1 326.32,63.43 ; H17.1 323.58,66.17 ; H17.1 324.95,66.64 ; 5.53,76.14 JUSBC1.4 ; JUSBC1.4 6.85,76.14 ; JUSBC1.4 5.53,75.38 ; JUSBC1.4 8.17,76.14 ; JUSBC1.4 8.17,75.38 ; JUSBC1.4 6.85,74.61 ; JUSBC1.4 8.17,74.61 ; 401.85,69.2 JUSB1.13 ; JUSB1.13 404.55,69.2 ; JUSB1.13 403.2,68.31 ; JUSB1.13 403.2,70.09 ; JUSB1.13 404.55,68.31 ; JUSB1.13 404.55,70.09 ; JUSB1.13 401.85,70.09 ; JUSB1.13 401.85,68.31 ; JUSB2.11 398.01,43.36 ; JUSB2.11 394.74,45.14 ; JUSB2.11 396.38,45.14 ; JUSB2.11 394.74,44.25 ; JUSB2.11 398.01,44.25 ; JUSB2.11 394.74,43.36 ; JUSB2.11 396.38,43.36 ; JUSB2.11 398.01,45.14 ; SW1.5 172.15,103.02 ; SW1.5 171.37,102.78 ; SW1.5 171.37,101.22 ; SW1.5 171.13,102 ; SW1.5 173.17,102 ; SW1.5 172.15,100.98 ; SW1.5 172.93,102.78 ; SW1.5 172.93,101.22 ; 394.92,36.21 JUSB2.7 ; JUSB2.7 395.58,37.71 ; JUSB2.7 394.26,36.39 ; JUSB2.7 395.76,37.05 ; JUSB2.7 395.58,36.39 ; JUSB2.7 394.08,37.05 ; JUSB2.7 394.92,37.89 ; JUSB2.7 394.26,37.71 ; 394.74,28.96 JUSB2.10 ; JUSB2.10 394.74,30.74 ; JUSB2.10 398.01,30.74 ; JUSB2.10 398.01,28.96 ; JUSB2.10 396.38,28.96 ; JUSB2.10 394.74,29.85 ; JUSB2.10 396.38,30.74 ; JUSB2.10 398.01,29.85 ; H16.1 4.86,61.7 ; H16.1 4.86,64.21 ; H16.1 2.34,61.7 ; H16.1 3.6,64.64 ; H16.1 1.91,62.95 ; H16.1 2.34,64.21 ; H16.1 3.6,61.27 ; H16.1 5.29,62.95 ; H21.1 122.06,138.36 ; H21.1 120.01,140.4 ; H21.1 118.5,136.85 ; H21.1 121.52,136.85 ; H21.1 120.01,136.31 ; H21.1 117.96,138.36 ; H21.1 121.52,139.86 ; H21.1 118.5,139.86 ; 6.25,57.91 JUSBC1.9 ; JUSBC1.9 5.58,57.91 ; JUSBC1.9 6.92,58.62 ; JUSBC1.9 5.58,58.62 ; JUSBC1.9 6.25,59.34 ; JUSBC1.9 6.92,59.34 ; JUSBC1.9 5.58,59.34 ; 394.74,68.31 JUSB1.11 ; JUSB1.11 394.74,69.2 ; JUSB1.11 398.01,68.31 ; JUSB1.11 396.38,70.09 ; JUSB1.11 398.01,69.2 ; JUSB1.11 394.74,70.09 ; JUSB1.11 396.38,68.31 ; JUSB1.11 398.01,70.09 ; H9.1 132.95,174.15 ; H9.1 132.95,170.05 ; H9.1 134.46,173.61 ; H9.1 135,172.1 ; H9.1 131.44,170.59 ; H9.1 131.44,173.61 ; H9.1 130.9,172.1 ; H9.1 134.46,170.59 ; H5.1 64.76,1.09 ; H5.1 64.76,4.11 ; H5.1 61.74,4.11 ; H5.1 61.74,1.09 ; H5.1 63.25,4.65 ; H5.1 61.2,2.6 ; H5.1 65.3,2.6 ; H5.1 63.25,0.55 ; JUSB3.12 127.47,176.99 ; JUSB3.12 128.31,175.3 ; JUSB3.12 127.47,173.61 ; JUSB3.12 128.31,173.61 ; JUSB3.12 128.31,176.99 ; 386.25,3.03 JNGFF4.76 ; JNGFF4.76 386.89,5.57 ; JNGFF4.76 386.89,3.03 ; JNGFF4.76 386.89,4.3 ; JNGFF4.76 386.25,5.57 ; H8.1 265.64,19.18 ; H8.1 265.64,22.56 ; H8.1 261.65,20.87 ; H8.1 263.95,23.17 ; H8.1 263.95,18.57 ; H8.1 262.26,19.18 ; H8.1 266.25,20.87 ; H8.1 262.26,22.56 ; H6.1 5.21,45.5 ; H6.1 3.95,48.44 ; H6.1 2.26,46.76 ; H6.1 2.69,48.01 ; H6.1 5.21,48.01 ; H6.1 5.64,46.76 ; H6.1 3.95,45.07 ; H6.1 2.69,45.5 ; 249.95,0.55 H15.1 ; H15.1 251.46,1.09 ; H15.1 249.95,4.65 ; H15.1 252,2.6 ; H15.1 251.46,4.11 ; H15.1 248.44,1.09 ; H15.1 248.44,4.11 ; H15.1 247.9,2.6 ; 363.11,4.3 JNGFF4.77 ; JNGFF4.77 363.75,3.03 ; JNGFF4.77 363.11,3.03 ; JNGFF4.77 363.75,5.57 ; JNGFF4.77 363.11,5.57 ; JUSBC1.8 3.29,74.54 ; JUSBC1.8 3.29,75.38 ; JUSBC1.8 0.31,76.21 ; JUSBC1.8 1.8,74.54 ; JUSBC1.8 3.29,76.21 ; JUSBC1.8 1.8,76.21 ; H18.1 5.21,80.41 ; H18.1 5.64,79.16 ; H18.1 2.69,77.9 ; H18.1 2.69,80.41 ; H18.1 3.95,80.84 ; H18.1 5.21,77.9 ; H18.1 3.95,77.47 ; H18.1 2.26,79.16 ; H7.1 265.64,76.96 ; H7.1 261.65,75.27 ; H7.1 266.25,75.27 ; H7.1 262.26,73.58 ; H7.1 265.64,73.58 ; H7.1 262.26,76.96 ; H7.1 263.95,72.97 ; H7.1 263.95,77.57 ; 394.74,55.69 JUSB1.10 ; JUSB1.10 396.38,53.91 ; JUSB1.10 398.01,53.91 ; JUSB1.10 398.01,54.8 ; JUSB1.10 394.74,53.91 ; JUSB1.10 396.38,55.69 ; JUSB1.10 398.01,55.69 ; JUSB1.10 394.74,54.8 ; 226.16,17.38 H12.1 ; H12.1 229.54,17.38 ; H12.1 227.85,16.77 ; H12.1 230.15,19.07 ; H12.1 226.16,20.76 ; H12.1 229.54,20.76 ; H12.1 227.85,21.37 ; H12.1 225.55,19.07 ; JUSB3.4 116.12,165.39 ; JUSB3.4 116.81,165.19 ; JUSB3.4 115.43,165.19 ; JUSB3.4 116.81,163.81 ; JUSB3.4 115.23,164.5 ; JUSB3.4 117.01,164.5 ; 109.95,90.96 H4.1 ; H4.1 108.58,94.17 ; H4.1 109.95,94.64 ; H4.1 108.58,91.43 ; H4.1 111.79,92.8 ; H4.1 111.32,91.43 ; H4.1 108.11,92.8 ; H4.1 111.32,94.17 ; JLOM1.10 137.72,172.11 ; JLOM1.10 136.99,170.42 ; JLOM1.10 136.99,168.73 ; JLOM1.10 136.99,172.11 ; JLOM1.10 137.72,168.73 ; 6.85,39.19 H19.1 ; H19.1 8.22,42.4 ; H19.1 5.48,39.66 ; H19.1 8.69,41.03 ; H19.1 8.22,39.66 ; H19.1 5.01,41.03 ; H19.1 5.48,42.4 ; H19.1 6.85,42.87 ; JUSB1.4 397.26,65.5 ; JUSB1.4 396.42,66.34 ; JUSB1.4 397.08,64.84 ; JUSB1.4 397.08,66.16 ; JUSB1.4 395.76,64.84 ; JUSB1.4 396.42,64.66 ; JUSBC1.7 3.29,67.57 ; JUSBC1.7 1.8,67.57 ; JUSBC1.7 3.29,65.9 ; JUSBC1.7 3.29,66.73 ; JUSBC1.7 0.31,65.9 ; JUSBC1.7 1.8,65.9 ; H3.1 142.72,119.56 ; H3.1 141.21,119.02 ; H3.1 139.7,119.56 ; H3.1 141.21,123.12 ; H3.1 143.26,121.07 ; H3.1 142.72,122.58 ; H3.1 139.7,122.58 ; H3.1 139.17,121.07 ; 114.86,97.76 JDG1.7 ; JDG1.7 114.86,96.34 ; JDG1.7 114.86,97.05 ; JDG1.7 116.84,96.34 ; JDG1.7 116.84,97.76 ; JDG1.7 116.84,97.05 ; JDG1.7 115.85,96.34 ; JDG1.7 115.85,97.76 ; 294.44,92.31 H11.1 ; H11.1 295.95,92.85 ; H11.1 297.46,89.29 ; H11.1 293.9,90.8 ; H11.1 297.46,92.31 ; H11.1 295.95,88.75 ; H11.1 294.44,89.29 ; H11.1 298,90.8 ; JUSBC1.1 6.96,49.77 ; JUSBC1.1 5.54,51.75 ; JUSBC1.1 5.54,50.84 ; JUSBC1.1 6.25,49.77 ; JUSBC1.1 5.54,49.77 ; JUSBC1.1 6.25,51.75 ; 226.16,74.48 H13.1 ; H13.1 229.54,74.48 ; H13.1 230.15,76.17 ; H13.1 227.85,73.87 ; H13.1 226.16,77.86 ; H13.1 225.55,76.17 ; H13.1 229.54,77.86 ; H13.1 227.85,78.47 ; 394.92,61.16 JUSB1.7 ; JUSB1.7 395.58,62.66 ; JUSB1.7 394.92,62.84 ; JUSB1.7 394.08,62 ; JUSB1.7 395.58,61.34 ; JUSB1.7 394.26,62.66 ; JUSB1.7 394.26,61.34 ; JUSB1.7 395.76,62 ; 110.76,109.16 JDG1.8 ; JDG1.8 112.74,108.45 ; JDG1.8 110.76,108.45 ; JDG1.8 111.75,107.74 ; JDG1.8 110.76,107.74 ; JDG1.8 112.74,107.74 ; JDG1.8 112.74,109.16 ; JDG1.8 111.75,109.16 ; JUSB3.11 114.06,164.5 ; JUSB3.11 112.38,164.5 ; JUSB3.11 113.22,163.2 ; JUSB3.11 114.06,163.2 ; JUSB3.11 112.38,163.2 ; JUSB2.12 403.2,30.74 ; JUSB2.12 404.55,28.96 ; JUSB2.12 401.85,29.85 ; JUSB2.12 404.55,30.74 ; JUSB2.12 403.2,28.96 ; JUSB2.12 404.55,29.85 ; JUSB2.12 401.85,28.96 ; JUSB2.12 401.85,30.74 ; 390.74,1.49 H1.1 ; H1.1 390.74,4.51 ; H1.1 392.25,0.95 ; H1.1 393.76,4.51 ; H1.1 393.76,1.49 ; H1.1 392.25,5.05 ; H1.1 390.2,3 ; H1.1 394.3,3 ; 115.85,107.74 JDG1.9 ; JDG1.9 114.86,107.74 ; JDG1.9 116.84,107.74 ; JDG1.9 114.86,109.16 ; JDG1.9 114.86,108.45 ; JDG1.9 116.84,108.45 ; JDG1.9 115.85,109.16 ; JDG1.9 116.84,109.16 ; 5.58,66.57 JUSBC1.10 ; JUSBC1.10 6.25,66.57 ; JUSBC1.10 6.92,66.57 ; JUSBC1.10 6.92,67.29 ; JUSBC1.10 5.58,67.29 ; JUSBC1.10 5.58,68 ; 0.31,49.7 JUSBC1.5 ; JUSBC1.5 3.29,49.7 ; JUSBC1.5 3.29,50.54 ; JUSBC1.5 1.8,51.37 ; JUSBC1.5 1.8,49.7 ; JUSBC1.5 3.29,51.37 ; SW1.4 165.85,103.02 ; SW1.4 165.85,100.98 ; SW1.4 166.63,102.78 ; SW1.4 165.07,101.22 ; SW1.4 165.07,102.78 ; SW1.4 164.83,102 ; SW1.4 166.63,101.22 ; JUSBC1.3 8.17,50.54 ; JUSBC1.3 6.85,49.77 ; JUSBC1.3 6.85,51.3 ; JUSBC1.3 5.53,50.54 ; JUSBC1.3 5.53,49.77
  BOTTOM w0.102: v2(33.03,38.6) 33.03,40.95 34.19,42.11 UT1.E23 ; 32.66,41.85 32.66,41.59 31.89,40.82 31.09,40.82 CT21.2
  BOTTOM w0.127: DT52.2 v2(14.87,74.86) ; DT52.2 v2(14.26,74.29) ; DT52.2 v2(15.43,74.29) ; DT54.2 v2(14.32,72.79) ; DT54.2 v2(14.87,72.24) ; DT54.2 v2(15.44,72.79) ; v2(12.86,58.29) DT17.2 ; DT17.2 v2(11.76,58.29) ; DT17.2 v2(12.32,58.84) ; v2(12.31,64.06) DT45.2 ; DT45.2 v2(12.31,65.19) ; DT45.2 v2(12.86,64.64) ; v2(10.81,65.19) DT44.2 ; DT44.2 v2(10.81,64.09) ; DT44.2 v2(10.25,64.64) ; v2(12.86,56.79) DT18.2 ; DT18.2 v2(11.76,56.79) ; DT18.2 v2(12.32,56.29) ; v4(157.55,144.54) 157.56,144.53 v2(158.23,144.53) ; v2(16.2,50.49) DT14.2 ; DT14.2 v2(16.76,51.05) ; DT14.2 v2(17.32,50.49) ; DT13.2 v2(16.76,48.44) ; DT13.2 v2(16.21,49) ; DT13.2 v2(17.31,49)
  BOTTOM w0.178: UT1.AB8 UT1.AC8 42.99,49.35 v2(43.05,49.42) ; UT1.R20 38.72,43.61 v2(39.03,43.3) 39.34,43.61 UT1.T20 ; UT1.N23 UT1.N22 37.87,43.15 UT1.M20 36.95,43.15 UT1.L22 UT1.L23 36.95,42 v2(37.01,41.95) ; UT1.V11 v2(40.33,48.48) 40.33,48.49 UT1.V9 ; UT1.L12 36.76,47.51 v2(37.09,47.84) UT1.M12 ; UT1.Y13 v2(40.99,47.19) UT1.W13 ; UT1.D8 33.51,49.45 v2(33.2,49.13) 33.2,49.12 UT1.D9 ; v2(43,50.36) 42.92,50.27 UT1.AC6 UT1.AB6 ; UT1.N12 v2(38.39,47.19) UT1.R12 ; UT1.A4 UT1.B4 33.29,51.19 ; UT1.AB16 UT1.AC16 42.99,45.67 v2(43.05,45.61) ; 34.61,47.31 UT1.F12 ; UT1.AB12 UT1.AC12 43.17,47.51 43.51,47.18 v2(43.54,47.18) ; UT1.M2 UT1.M1 ; UT1.L15 v2(37.09,45.89) UT1.M15 ; UT1.G23 UT1.G22 35.11,43.31 UT1.F20 ; UT1.J20 36.09,43.61 v2(35.79,43.31) ; UT1.N20 v2(38.39,43.94) ; v2(38.39,43.94) UT1.N19 ; v2(38.39,43.94) UT1.R19 ; UT1.N15 v2(38.39,45.89) UT1.R15 ; UT1.L20 v2(36.44,43.94) UT1.J19 ; UT1.AA23 UT1.AA22 ; UT1.R4 v2(39.03,51.73) ; UT1.R9 v2(38.39,48.49) ; UT1.U23 UT1.U22 ; v2(33.84,47.19) UT1.E12 34.36,47.31 ; v2(43.13,48.43) UT1.AC10 UT1.AB10 ; UT1.W23 UT1.W22 ; UT1.H20 35.48,43.61 v2(35.79,43.31) ; UT1.B14 UT1.A14 ; v2(42.95,43.75) 42.86,43.83 UT1.AC20 UT1.AB20 ; UT1.E9 v2(34.49,48.49) UT1.F9 ; v2(31.69,48.58) 31.84,48.43 UT1.A10 UT1.B10 ; UT1.W11 v2(40.34,47.84) 40.66,47.51 UT1.W12 ; v2(33.73,53.23) UT1.D1 ; v2(31.49,45.77) 31.49,45.72 31.53,45.67 UT1.A16 UT1.B16 ; UT1.R18 v2(38.39,45.24) UT1.N18 ; UT1.F11 v2(34.49,47.84) UT1.E11 ; v2(31.41,44.62) 31.54,44.75 UT1.A18 UT1.B18 ; v2(35.79,43.31) 36.03,43.06 UT1.J22 UT1.J23 ; UT1.E23 UT1.E22 ; UT1.B12 UT1.A12 ; UT1.F2 UT1.F1 ; UT1.AC23 42.78,42.45 v2(43.16,42.83) 43.07,42.91 UT1.AC22 UT1.AB22 ; UT1.H1 UT1.J1 36.03,52.84 v2(35.81,53.06) ; UT1.Y12 v2(40.99,47.84) UT1.Y11 ; 39.69,49.79 39.69,49.79 UT1.T6 ; v2(42.98,46.25) 42.64,46.59 UT1.AC14 UT1.AB14 ; UT1.R23 UT1.R22 ; UT1.A6 UT1.B6 ; UT1.B1 UT1.B2 ; UT1.B20 UT1.A20 31.66,43.83 v2(31.43,43.61) ; UT1.AB18 UT1.AC18 42.69,44.75 v2(42.93,44.52) ; UT1.A2 UT1.A1 ; UT1.E13 v2(33.84,46.54) UT1.D13 ; UT1.V12 v2(40.34,47.19) UT1.V13 ; UT1.L8 36.76,49.46 v2(37.09,49.79) UT1.M6 ; UT1.Y9 v2(40.99,48.49) UT1.W9 ; UT1.B8 UT1.A8
  BOTTOM w0.203: UT1.N9 v2(38.39,48.49) ; UT1.J15 36.42,45.91 v2(36.42,45.89) 36.11,45.58 UT1.J16 ; v2(141.07,15.76) 141.07,15.73 141.3,15.51 UZ12.9
  BOTTOM w0.254: CC209.1 239.2,37.96 v2(238.84,38.32) ; v2(318.04,32.26) 318.26,32.04 JNGFF3.1 ; JNGFF5.63 317.77,39.85 317.52,40.11 v2(317.52,40.19) ; v2(126.77,96.26) 126.78,96.27 JNGFF6.51 ; JNGFF2.49 159.24,109.01 v2(159,109.25) ; UI5.10 v2(387.55,43.72) ; v2(147.72,108.15) 147.72,107.04 JNGFF2.11 ; JNGFF6.57 v2(125.28,98.72) ; JDIMM1.107 172.85,42.23 172.26,41.65 v2(172.18,41.65) ; JNGFF4.27 377.75,11.22 v2(377.77,11.24) ; RT568.2 27.32,35.12 ; UI5.21 v2(381.6,43.72) ; PC2106.2 80.74,28.82 v2(80.67,28.89) ; v2(12.33,55.65) 12.04,55.65 CT109.2 ; v2(138.03,15.76) 138.02,15.76 137.8,15.54 UZ12.16 ; v2(353.64,13.93) 353.81,13.77 UZ58.5 ; JNGFF2.65 163.24,108.1 162.81,108.52 v2(162.81,109.64) ; JNGFF4.73 366.25,10.96 v2(366.01,11.2) ; JNGFF2.31 154.74,108.83 v2(154.85,108.94) ; v2(116.46,113.63) 116.5,113.58 JNGFF1.16 ; JNGFF2.63 162.74,107.93 162.18,108.5 v2(162.18,109.64) ; UZ12.23 137.75,18.54 v2(138.03,18.81) ; v2(29.74,14.04) 29.73,14.04 UR4.5 ; JNGFF6.15 v2(135.78,96.29) ; v2(133.08,37.11) 133.09,37.1 134.06,37.1 ; JNGFF6.9 v2(137.28,96.25) ; v2(378.03,54.24) 378.17,54.39 UI4.21 ; UI4.10 v2(383.83,54.39) ; JNGFF4.51 v2(371.75,11.17) ; v2(156.41,72.66) 156.54,72.78 UE12.15 ; CH64.2 135.81,30.43 135.36,30.43 v2(135.34,30.4) ; v2(15.09,64.58) DT12.3 ; v2(132.87,96.36) 132.78,96.44 JNGFF6.27 ; JNGFF2.43 157.74,109.08 v2(157.88,109.22) ; RD37.2 205.79,59.81 206.28,60.3 v2(206.28,60.41) ; JXDP1.62 256.93,17.02 v2(256.93,17.03) ; v2(155.34,61.23) 155.47,61.23 156.01,60.69 UE3.3 ; v2(126.55,83.99) 126.83,83.71 UZ59.5 ; v2(317.65,38.63) 317.88,38.85 JNGFF5.67 ; JXDP1.25 249.08,16.77 v2(248.99,16.87) ; JNGFF4.45 v2(373.25,11.17) ; JNGFF4.33 376.25,11.13 v2(376.45,11.33) ; v2(317.55,39.34) 317.57,39.36 JNGFF5.65 ; JNGFF2.37 156.24,109.36 v2(156.23,109.37) ; v2(379.41,11.36) 379.25,11.2 JNGFF4.21 ; v2(382.5,9.01) 382.5,9.03 382.25,9.28 JNGFF4.9 ; v2(141.42,21.01) 141.42,20.91 141.3,20.78 UZ12.32 ; JDIMM1.69 172.87,32.73 172.54,32.4 172.54,32.36 172.24,32.07 171.79,32.07 171.41,32.44 v2(171.41,32.53) ; JNGFF4.3 383.75,10.91 v2(384.14,11.31) 384.25,11.2 JNGFF4.1 ; v2(318.26,65.52) 318.05,65.31 CN205.2 ; JNGFF6.39 129.78,98.73 v2(130.15,99.09) ; JNGFF6.33 131.28,98.49 v2(132.01,99.21) ; UZ7.5 168.63,136.27 v2(168.85,136.05) ; 34.49,45.24 UT1.E18 ; v2(153.75,60.13) 153.75,60.43 153.48,60.69 UE4.3 ; JNGFF4.71 v2(366.75,11.32) ; JDIMM3.98 196.57,39.97 196.99,40.39 v2(196.99,41.49) 196.47,40.97 JDIMM3.102 ; CZ531.2 110.87,115.68 CZ530.2 ; UR1.13 v2(20.29,12.98) ; JNGFF2.19 151.74,105.65 v2(151.8,105.59) ; JNGFF6.21 134.28,96.63 v2(134.06,96.41) ; JNGFF4.57 v2(370.25,11.17) ; JNGFF4.15 v2(380.75,11.17) ; JNGFF4.39 v2(374.75,11.17) ; JNGFF6.45 v2(128.28,96.3) ; v2(153.76,108.61) 153.24,108.09 JNGFF2.25
  BOTTOM w0.305: v2(183.26,21.75) 183.02,21.98 JDIMM1.26 ; JDIMM3.90 195.59,37.98 197.16,37.98 197.66,38.47 v2(197.66,38.77) ; JNGFF1.49 124.75,105.93 v2(124.96,106.14) ; 45.08,26.65 45.37,26.65 45.53,26.81 v2(45.67,26.81) ; 45.08,26.65 CT380.1 ; 45.08,26.65 44.45,26.65 RT585.2 44.07,26.69 44.03,26.73 RT575.1 ; v2(126.24,106.11) 126.26,106.1 JNGFF1.55 ; JNGFF1.31 120.26,106.18 v2(120.24,106.19) ; v2(247.21,16.6) 247.28,16.52 JXDP1.31 ; v2(171.57,18.42) 172.25,17.73 JDIMM1.9 ; v2(248.8,19.36) 248.78,19.34 JXDP1.26 ; JXDP1.49 241.88,15.08 v2(241.59,14.79) ; JDIMM1.85 171.89,36.73 v2(171.46,36.31) ; JXDP1.19 250.88,16.62 v2(251.07,16.8) ; JDIMM3.106 196.72,41.97 196.78,42.03 197.24,42.03 197.59,41.68 v2(197.59,41.46) ; JDIMM1.23 172.32,21.23 v2(171.88,21.67) ; v2(318.11,18.01) 318.14,18.04 JNGFF3.57 ; v2(198.11,32.02) 198.11,31.67 197.81,31.37 195.7,31.37 JDIMM3.64 ; JNGFF3.33 v2(318.12,24.04) ; JDIMM3.27 186.03,22.23 v2(185.52,21.71) 186,21.23 JDIMM3.23 ; JDIMM1.61 172.46,30.73 v2(172.3,30.9) 172.3,31.31 172.73,31.73 JDIMM1.65 ; JDIMM1.235 172.36,76.23 172.07,75.95 v2(172.07,75.45) 172.29,75.23 JDIMM1.231 ; JDIMM3.252 196.39,80.47 v2(197.07,79.79) 196.76,79.47 JDIMM3.248 ; v2(196.96,78.75) 196.69,78.47 JDIMM3.244 ; v2(318.08,21.17) 318.21,21.04 JNGFF3.45 ; v2(197.7,36.75) 197.7,36.47 197.2,35.98 195.59,35.98 JDIMM3.82 ; JDIMM1.36 182.98,24.48 183.22,24.25 v2(183.26,24.25) ; 306.13,25.74 306.13,25.61 ; 306.13,25.61 306.13,25.62 ; 306.13,25.61 LGA1.6 ; JDIMM3.77 186.14,34.72 v2(185.46,34.04) ; JNGFF3.9 318.16,30.04 v2(318.06,30.14) ; JNGFF1.61 127.75,106.1 v2(127.74,106.11) ; JDIMM1.77 172.08,34.73 v2(172.06,34.76) ; v2(170.43,25.79) 171.44,24.77 172.21,24.77 172.74,24.23 JDIMM1.35 ; JDIMM3.81 186.44,35.72 185.56,36.61 185.56,37.14 v2(185.4,37.31) ; JDIMM1.6 183.14,16.98 v2(183.6,16.52) 183.07,15.98 JDIMM1.2 ; v2(96.16,16.2) 96.16,15.98 96.33,15.81 JESPI.9 ; v2(171.95,25.83) 172.35,26.23 JDIMM1.43 ; v2(185.39,57.32) 185.39,56.86 185.01,56.47 CD29.2 ; v2(197.74,30.55) 196.67,29.47 JDIMM3.56 ; JDIMM1.81 171.32,35.73 v2(170.74,36.31) ; JDIMM3.72 196.47,33.47 197.52,34.52 v2(197.52,34.78) ; JNGFF5.33 318.86,49.35 319.98,49.35 v2(319.99,49.35) ; JDIMM1.72 182.81,33.48 184.31,31.98 v2(184.31,31.79) ; v2(196.99,65.61) 196.86,65.47 JDIMM3.192 ; JNGFF5.27 318.86,50.85 v2(320.03,50.85) ; JDIMM1.167 172.15,59.23 171.77,59.61 v2(171.77,60.11) 171.9,60.23 JDIMM1.171 ; v2(186.03,37.32) 186.43,37.72 JDIMM3.89 ; v2(197.38,28) 197.38,28.19 197.1,28.48 195.59,28.48 JDIMM3.52 ; JXDP1.2 255.98,18.93 v2(256.35,19.3) ; JDIMM3.47 185.24,27.22 184.52,26.51 v2(184.52,26.25) ; JNGFF3.39 317.89,22.54 v2(317.85,22.51) ; v2(171.82,64.14) 172.22,63.73 JDIMM1.185 ; JDIMM3.44 197.14,26.47 v2(197.37,26.24) ; JDIMM1.40 183.42,25.48 183.86,25.93 v2(183.86,26.27) ; v2(171.5,15.21) 172.03,15.73 JDIMM1.1 ; JDIMM3.9 185.86,17.72 v2(185.62,17.96) ; JDIMM3.5 184.45,16.72 v2(184.29,16.56) ; JXDP1.37 v2(245.48,16.46) ; JDIMM1.213 172.16,70.73 ; 172.16,70.73 171.9,70.99 171.9,71.42 172.21,71.73 JDIMM1.217 ; 172.16,70.73 172.15,70.73 171.55,70.13 v2(171.55,69.64) 171.65,69.73 JDIMM1.209 ; JDIMM1.22 183.46,20.98 183.96,20.48 v2(183.96,20.01) ; v2(206.57,57.84) 206.62,57.84 207.38,58.6 CD96.2 ; JDIMM1.57 171.96,29.73 171.5,29.27 v2(171.5,29.25) ; JDIMM1.251 172.37,80.23 v2(172.16,80.02) 172.16,79.54 172.46,79.23 JDIMM1.247 ; JAPS1.12 109.6,65.52 v2(109.44,65.36) 109.52,65.36 110.36,64.52 JAPS1.14 ; RE93.2 v2(155.01,76.85) ; v2(144.98,46.66) 145.1,46.78 CC331.2 ; JNGFF1.37 121.75,103.8 v2(121.61,103.66) ; v2(137.04,131) 136.99,131.05 CV954.2 ; v2(171.5,62.72) 171.51,62.73 JDIMM1.181 ; v2(129.94,102.87) 129.94,103.01 129.26,103.7 JNGFF1.67 ; v2(171.5,27.55) 171.81,27.23 JDIMM1.47 ; v2(171.22,38.01) 171.5,37.73 JDIMM1.89 ; JAPS1.10 111.37,66.52 111.74,66.88 113.05,66.88 113.05,67.4 v2(113.05,67.4) 112.93,67.52 JAPS1.8 ; JNGFF5.1 317.87,57.35 v2(317.7,57.52) ; JDIMM3.19 186.1,20.23 v2(185.85,19.98) 186.6,19.23 JDIMM3.15 ; JNGFF5.51 317.58,44.85 v2(317.57,44.87) ; v2(319.99,53.85) 318.86,53.85 JNGFF5.15 ; v2(198.11,26.24) 198.11,26.23 197.36,25.47 JDIMM3.40 ; JNGFF3.15 318.04,28.54 v2(317.98,28.48) ; JXDP1.7 254.48,16.61 v2(254.44,16.65) ; JNGFF1.43 123.26,102.83 v2(123.05,102.63) ; JDIMM1.103 172.65,41.23 172.45,41.03 v2(172.45,40.98) ; JDIMM3.57 186.25,29.72 185.95,30.02 v2(185.7,30.02) ; JDIMM3.48 195.59,27.48 197.77,27.48 198.08,27.78 v2(198.08,27.99) ; RT567.2 24.83,35.89 v2(24.99,35.73) ; JDIMM1.175 171.96,61.23 v2(171.5,61.69) ; v2(118.67,103.7) 118.75,103.79 JNGFF1.25 ; v2(197.02,38.76) 196.93,38.76 196.72,38.98 195.59,38.98 JDIMM3.94 ; v2(171.18,25.83) 171.72,25.29 172.41,25.29 172.47,25.23 JDIMM1.39 ; JNGFF3.21 318.17,27.04 v2(318.06,27.15) ; JCCG1.10 17.83,45.56 v2(17.74,45.65) ; JDIMM1.227 172.5,74.23 172.2,73.94 v2(172.2,73.7) 172.2,73.52 172.49,73.23 JDIMM1.223 ; v2(172.04,32.56) 172.04,33.11 172.66,33.73 JDIMM1.73 ; v2(197.4,22.02) 197.35,21.97 JDIMM3.26 ; v2(319.99,55.35) 318.86,55.35 JNGFF5.9 ; v2(238.11,14.41) 237.92,14.41 237.63,14.7 JXDP1.63 237.63,16.89 237.33,17.19 RC139.2 ; JXDP1.59 238.88,15.16 v2(238.55,14.83) 238.28,15.1 JXDP1.61 ; JDIMM1.93 170.85,38.73 170.61,38.5 v2(170.61,38.01) ; v2(172.18,77.08) 172.34,77.23 JDIMM1.239 ; JDIMM1.86 181.88,37 182.88,37 184,35.88 v2(184,35.28) ; v2(253.4,16.85) 253.29,16.85 252.68,16.25 JXDP1.13 ; v2(317.47,43.35) 318.85,43.35 JNGFF5.57 ; JDIMM1.30 183.34,22.98 183.87,22.45 v2(183.87,21.67) ; v2(245.46,17.69) 245.46,17.85 245.18,18.13 JXDP1.38 ; JDIMM1.51 171.43,28.23 v2(170.74,27.55) ; JXDP1.32 246.98,17.83 v2(246.99,17.83) ; JXDP1.20 250.58,19.18 250.66,19.26 v2(250.66,19.38) ; RT537.2 18.51,39.57 18.27,39.82 v2(17.6,39.82) ; v2(318.11,19.52) 318.13,19.54 JNGFF3.51 ; v2(254.33,19.32) 254.18,19.17 JXDP1.8 ; JDIMM1.10 183.56,17.98 v2(183.72,17.82) ; v2(197.48,31.89) 196.89,32.48 195.59,32.48 JDIMM3.68 ; JDIMM3.2 195.59,15.98 197.18,15.98 v2(197.37,15.78) ; JDEG1.10 113.46,53.81 113.74,53.53 113.74,52.91 v2(114.34,52.31) ; v2(171.5,40.09) 171.65,40.23 JDIMM1.99 ; JDIMM1.68 183.01,32.48 183.5,31.99 v2(183.5,31.9) ; v2(191.91,59.57) 191.91,59.78 192.35,60.22 193.21,60.22 193.96,59.47 JDIMM3.168 ; JDIMM1.205 v2(171.73,68.73) ; JDIMM3.43 185.19,26.22 v2(185.18,26.24) ; v2(186.17,28.3) 186.25,28.22 JDIMM3.51 ; JDIMM1.5 171.58,16.73 171.5,16.81 v2(171.5,16.98) ; v2(183.31,35.28) 183.23,35.35 183.23,35.75 183,35.98 JDIMM1.82 ; v2(198.22,20.14) 198.22,20.05 197.14,18.98 195.59,18.98 JDIMM3.14 ; JDIMM3.35 185.64,24.22 v2(185.62,24.24) 186.6,25.22 JDIMM3.39 ; 307.58,24.74 LGA1.7 ; JNGFF5.45 318.86,46.35 v2(319.99,46.35) ; JNGFF3.27 318.11,25.54 v2(318.04,25.48) ; JDIMM3.36 197.1,24.47 v2(197.48,24.09) 197.48,24.16 ; v2(320.01,47.85) 318.86,47.85 JNGFF5.39 ; v2(41.46,25.6) 41.86,25.6 41.94,25.68 UT12.3 ; v2(41.2,26.61) 41.2,27.27 PQ2106.1 ; JNGFF1.22 118,113.53 v2(118.23,113.76) ; JDIMM1.15 172.21,19.23 171.51,19.93 v2(171.51,20.03) 171.71,20.23 JDIMM1.19 ; 305.63,25.81 LGA1.5 ; v2(171.5,23.71) 171.98,23.23 JDIMM1.31 ; JDIMM3.69 186.23,32.72 v2(185.32,31.81) 185.71,31.42 185.71,31.1 186.08,30.72 JDIMM3.61 ; v2(198.24,17.81) 198.24,17.79 197.42,16.98 195.59,16.98 JDIMM3.6 ; v2(183.31,28.25) 183.31,28.25 183.07,28.48 JDIMM1.52 ; JNGFF3.3 318.1,31.54 v2(318.03,31.48) ; v2(186.18,38.59) 186.31,38.72 JDIMM3.93 ; v2(110.69,106.5) 110.75,106.44 JNGFF1.1 ; JNGFF5.21 318.86,52.35 v2(319.99,52.35) ; 195.59,30.48 JDIMM3.60 195.63,30.44 196.82,30.44 196.84,30.46 196.86,30.46 v2(196.95,30.55) ; v2(198.09,24.09) 198.09,23.71 197.35,22.97 JDIMM3.30 ; JDIMM1.193 172.55,65.73 172.17,65.36 171.74,65.36 171.54,65.56 v2(171.5,65.59) 171.5,65.73 172.51,66.73 JDIMM1.197 ; 307.57,24.24 LGA1.8 ; JXDP1.14 252.38,18.97 252.58,19.17 v2(252.58,19.2) ; JDIMM3.22 197.14,20.97 v2(198.21,22.05) ; JDIMM1.44 183.03,26.48 v2(183.27,26.25) ; JDIMM1.27 171.68,22.23 ; v2(189.69,14.84) 189.16,14.84 188.28,15.72 JDIMM3.1 ; JDIMM1.189 171.6,64.73 171.16,65.18 v2(170.74,65.59) ; CE11.2 134.59,81.5 134.59,81.88 135.11,82.4 v2(135.11,82.43) ; JNGFF5.3 317.85,56.85 v2(317.68,56.68) ; v2(196.92,34.78) 196.73,34.98 195.59,34.98 JDIMM3.78 ; v2(197.45,17.84) 197.43,17.82 197.38,17.82 197.23,17.98 195.59,17.98 JDIMM3.10 ; v2(197.06,36.77) 196.85,36.98 195.59,36.98 JDIMM3.86 ; JXDP1.50 v2(241.58,19.26) ; v2(171.58,67.26) 171.58,67.32 171.99,67.73 JDIMM1.201
  BOTTOM w0.33: v2(147.45,46.57) 147.45,47.16 148.16,47.87 CC311.2 ; v2(148.77,51.77) 148.5,51.5 CC330.2 ; RH608.2 126.17,43.89 v2(126.05,43.89)
  BOTTOM w0.356: CT379.2 v2(49.35,22.37) ; RH65.2 111.53,34.15 CH350.2 ; v2(237.37,18.67) 235.58,18.67 235.34,18.43 CC305.2 ; CD95.2 201.55,58.83 202.11,58.83 CD94.2 202.11,58.17 v2(202.41,57.87) ; RH733.2 123.31,42.65 CC310.2 124.18,42.65 v2(124.57,42.25) ; v2(302.44,78.67) 302.44,78.46 302.78,78.12 CV62.2 ; RT587.2 37.59,24.7 38.86,25.97 CT378.1 ; v2(138,32.27) 137.84,32.43 CH66.2 136.1,32.43 CC328.2 ; CC308.2 240.33,22.37 RC136.2 ; CE53.2 155.59,63.65 v2(155.42,63.82) ; v2(28.85,30.57) 28.22,29.94 RT524.2 ; 364.11,11.81 363.95,11.81 363.52,12.23 CZ540.2 363.22,12.22 363.22,11.8 362.96,11.54 362.96,11.52 362.92,11.47 362.92,11.46 362.83,11.37 RZ541.2 ; CR200.2 14.8,8.96 CR244.1 13.97,8.96 13.95,8.94 13.89,8.94 13.5,8.55 v2(13.5,8.38) ; v2(154.45,141.1) 154.53,141.18 CL10.2 ; CL11.2 151.8,141.21 v2(151.91,141.1) ; v2(204.21,57.8) 203.89,58.13 CD97.2 ; v2(237.94,94.02) 237.94,93.25 237.49,92.79 CV805.2 ; v2(168.95,52.46) 169.1,52.46 169.47,52.08 CD21.2 ; v2(121.44,160.28) 121.44,160.63 CZ37.2 ; v2(147.65,53.48) 147.27,53.86 CH29.2 ; v2(132.09,74.62) 132.38,74.33 CE20.2 ; CZ92.2 13.2,3.88 12.58,3.26 v2(12.58,1.84) ; v2(140.09,79.96) 139.71,79.58 CE31.2 139.14,79.36 CE13.2 ; v2(229.28,93.48) 229.28,93.81 229.71,94.25 CV903.2 ; CD52.2 CD18.2 v2(166.82,48.15) ; CH9.2 123.01,23.78 v2(122.93,23.87) ; CC306.2 241.18,21.69 CC303.2 241.18,23.31 v2(241.18,23.32) ; v2(156.51,120.42) 156.47,120.47 156.47,121.25 CV817.2 ; RR205.2 18.48,22.28 v2(18.62,22.42) ; v2(183.54,52.13) 183.54,52.82 183.89,53.18 CD20.2 CD84.2 ; RE737.1 138.34,68.58 v2(138.63,68.58) 138.72,68.49 CE19.2 ; CH67.2 118.39,47.13 v2(118.37,47.15) ; v2(43.03,36.44) 42.47,35.88 42.34,35.88 42.31,35.85 PR2109.2 ; CT364.2 v2(13.31,70.6) ; CE23.2 139.56,74.78 139.27,75.07 138.3,75.07 RE736.1 ; v2(38.94,56.78) 39.27,56.78 RT509.2 ; CD19.2 v2(168.98,55.39) ; CZ17.2 CZ18.2 144.17,117.49 144.17,118.16 144.03,118.3 v2(144.03,118.4) ; v2(243.23,23.2) 243.3,23.14 CC32.2 ; CH20.2 CC331.2 ; CC329.2 118.31,46.03 v2(118.31,46.03) ; v2(237.31,22.05) 237.41,22.15 CC304.2 ; v2(137.04,131) 137.48,131 CZ509.2 ; CE340.2 156.92,68.49 v2(157.53,67.88) ; v2(126.53,46.97) 126.53,47.24 126.2,47.56 CH37.2 125.78,47.87 RH611.1 ; v2(149.17,119.01) 149.51,119.01 149.93,118.59 CV814.2 ; CR236.1 v2(11.06,8.49) ; CZ91.2 14.25,7.46 v2(13.95,7.17) ; CH34.2 146.99,39.99 v2(147.39,40.4) ; v2(12.27,52.44) 12.24,52.47 CT101.2 ; CZ527.2 395.23,13.93 v2(395.15,14.02) ; v2(278.5,71.54) 278.5,72.53 CZ100.2 ; CD49.2 v2(168.98,54.37) ; CD22.2 v2(171.02,48.15) ; CE343.2 155.78,76.72 v2(155.65,76.85) ; v2(59.71,40.67) 59.71,41.94 CV909.2 ; JTAG1.2 153.21,73.51 152.85,73.87 152.85,74.31 153.41,74.31 v2(153.82,74.72) ; v2(145.99,48.42) 147.03,48.42 147.39,48.78 CH31.2 ; v2(35.45,20.49) 35.48,20.51 35.48,20.77 35.02,21.22 CT370.1 ; CC210.1 v2(241.12,60.85) ; v2(184.43,48.43) 184.29,48.57 CD79.2 ; CT343.2 14.08,34.23 14.76,33.55 v2(14.93,33.55) ; CT384.1 46.82,25.5 v2(46.62,25.71) 46.49,25.58 RT577.1 ; CD15.2 v2(170.51,41.42) ; RT523.2 v2(28.01,28.59) ; CR255.2 29.96,18.58 v2(30.05,18.49) ; v2(387.87,54.89) DI1.3 v2(390.26,54.89) ; RT618.2 22.74,40.94 v2(22.7,40.99) 21.92,40.99 RT617.2 ; CV815.2 160.08,121.34 v2(160.35,121.61) ; CV64.2 294.89,78.67 v2(295.89,78.67) 296.24,78.32 CV63.2 ; CV20.2 112.28,119.78 v2(111.83,120.22) ; CD17.2 v2(168.86,53.23) ; CE14.2 132.17,72.42 v2(131.34,71.59) ; v2(167.79,44.01) 167.59,44.21 CD55.2 CD5.2 ; DT1.1 v2(20.37,52.4) ; v2(197.4,20.12) 197.25,19.97 JDIMM3.18 ; CH32.2 146.58,51.4 CH46.2 ; CH65.2 CH63.2 ; v2(378.81,59.94) CI60.2 ; CD54.2 v2(170.13,48.15) ; v2(275.22,69.36) CC323.2 ; v2(183.32,45.77) 183.32,45.97 183.78,46.43 184.22,46.43 184.59,46.07 CD86.2 185.09,46.48 185.09,46.99 CD24.2 ; CR256.1 v2(29.74,14.04) ; UD1.3 v2(150.43,13.45) ; CE342.2 v2(164.92,74.06) ; CD48.2 v2(169.62,41.42) ; CD53.2 v2(168.98,50.94)
  BOTTOM w0.381: UE5.3 153.21,64.03 v2(152.89,63.71) ; UV61.3 288.29,76.52 287.91,76.9 v2(287.91,77.08) ; v2(38.94,56.78) 38.91,56.81 RT508.2 ; v2(19.1,7.2) 18.54,7.76 CZ90.2 ; CR222.2 v2(21.32,10.01) ; v2(34.49,11.7) 34.43,11.76 PQ2110.4 ; v2(37.26,56.75) 37.26,56.76 37.26,57.45 RT33.2 ; PQ8.4 62.42,29.49 v2(62.05,29.86) ; PC2025.2 47.95,14.59 48.05,14.7 v2(48.05,14.72) ; v2(53.67,22.62) 53.42,22.38 PU2001.4 ; v2(251.34,49.23) 251.42,49.15 PC1362.2 PC1363.2 ; v2(133.08,30.4) 132.94,30.4 132.59,30.76 CH62.2 ; CH33.2 126.25,26.47 v2(126.51,26.72) ; CR225.1 32.2,26.34 CR224.1 33.03,25.67 v2(33.06,25.7) ; CR248.1 20.75,21.52 CR247.2 ; v2(124.76,22.11) 124.76,22.87 CH65.2 ; v2(381.73,24.98) 382.13,25.38 CA45.2 ; RH424.2 128.15,20.82 128.15,21.77 RH640.2 ; CR251.2 23.59,17.56 CR250.1 24.26,17.67 24.26,17.91 v2(23.98,18.19) ; CI69.2 381.53,48.16 v2(381.45,48.24) ; UV68.3 278.31,79.12 278.09,79.34 UV60.3 278.09,80.16 v2(278.42,80.49) ; v2(122.93,23.87) v2(122.93,24.46) ; JESPI.11 101.33,11.64 v2(101.67,11.29) ; CE25.2 145.88,70.79 v2(146.38,70.3) ; v2(352.71,12.58) 352.71,13.85 v2(352.68,13.88) ; UV62.3 287.88,79.12 287.45,79.54 v2(287.45,79.82) ; CZ200.2 152.02,18.7 151.91,18.8 150.45,18.8 150.01,18.36 UZ34.3 149.95,17.8 149.32,17.17 v2(149.27,17.17) ; v2(355.15,7.79) 355.15,8.23 354.97,8.42 CN192.2 ; PQ2008.4 37.52,21.37 v2(38.5,20.39) 38.82,20.07 PQ2008.1 ; v2(42.9,13.32) 42.92,13.32 43,13.4 43.08,13.4 43.69,12.78 PQ2111.1 ; UZ6.3 v2(103.31,14.47) ; RV812.2 287.53,82.05 UV63.3 ; v2(352.77,9.83) 352.8,9.87 C206.2 ; CC332.2 145.09,46.55 v2(144.98,46.66) ; RH632.2 122.27,30.15 v2(122.27,30.75) 121.47,30.75 CH347.2 121,30.28 RH638.2 120.56,30.29 CH343.2 ; CR234.2 17.42,8.78 v2(17.63,8.58) ; CT347.2 CT349.2 18.65,28.31 v2(18.81,28.46) ; RH635.2 109.19,12.45 CH342.2 ; v2(52.39,32.53) 52.71,32.2 PQ9.1 53.09,31.92 PR76.2 ; v2(390.17,42.95) DI6.3 392.8,42.95 v2(392.92,42.83) ; v2(280.36,74.56) 280.36,74.5 279.82,73.96 UV69.3 ; PU2004.4 80.87,25.7 80.46,25.29 v2(80.46,24.91) ; v2(140.36,37.84) 140.24,37.95 140.24,38.16 139.66,38.74 CH38.2 ; CV810.2 286.59,84.28 v2(286.9,83.96) ; 128.93,68.53 128.4,69.05 v2(128.12,69.05) ; 128.93,68.53 CE4.2 ; 128.93,68.53 RE313.2 ; v2(16.76,21.07) 16.62,21.21 CR217.2 ; CR230.2 22.93,11.54 CR229.1 23.47,11.52 v2(23.51,11.48) ; v2(35,13.22) 35.16,13.06 PQ2110.1 ; v2(137.87,21.58) 138.17,21.88 138.17,22.06 138.68,22.57 RZ62.2 ; v2(41.46,25.6) 41.08,25.97 41.07,25.97 RT573.1 ; PC2007.2 PC2008.2 49.35,15.84 49.32,15.81 v2(49.32,15.81) ; PC2011.2 49.44,22.27 v2(49.35,22.37) ; v2(146.91,118.71) 145.77,118.71 CZ198.2 ; CT377.2 40.03,24.07 CT383.1 40.05,23.74 40.37,23.42 RT610.1 40.82,23.42 40.9,23.51 v2(41.22,23.51) ; CZ63.2 336.65,53.48 v2(336.83,53.66) ; CV809.2 291.79,78.86 v2(291.28,79.36) ; CA47.2 380.03,25.25 v2(379.76,24.98) ; PQ8.1 v2(63.72,26.56) ; v2(118.37,44.23) 118.37,43.86 118.79,43.45 CC327.2 ; UT10.3 35.24,24.87 35.38,25.01 v2(36.14,25.01) 36.26,25.12 RT571.1 36.83,25.12 37.25,24.7 RT587.2 ; UH7.3 109.41,32.14 v2(109.8,32.53) ; v2(279.11,83.81) 279.22,83.7 279.22,83.14 278.93,82.84 CV811.2 ; v2(116.81,28.44) 116.81,28.87 CH345.2 116.47,29.85 RH639.2 116.57,30.3 116.69,30.42 CH344.2 116.81,30.81 RH629.2 ; CH21.2 131.71,40.72 v2(131.49,40.5) ; CT342.2 23.79,39.24 v2(23.76,39.27) ; PQ9.4 50.81,30.3 50.83,30.28 50.83,30.23 51.1,29.96 PQ7.1 51.1,28.98 v2(51.36,28.72) ; PQ2111.4 42.37,11.48 43,10.85 43,10.66 v2(43.48,10.17) ; PQ2102.1 34.81,27.21 v2(34.77,27.17) ; v2(13.86,54.19) DT7.3 ; CE19.2 CE15.2 ; CE23.2 139.92,74.61 v2(140.46,74.07) ; v2(39.19,18.79) 39.27,18.71 39.27,17.59 39.01,17.34 PU2003.4 ; RH630.1 129.61,44.39 129.61,43.48 v2(129.31,43.17) ; CZ82.2 v2(106.28,13.87) ; v2(136.92,40.92) 136.99,40.99 CH44.2 ; RT584.1 RT583.1 23.24,25.86 v2(23.29,25.81) ; PQ2112.1 38.17,10.21 v2(38.45,9.92) ; CH321.2 101.41,26.63 101.13,26.91 v2(101.13,27.09) 100.95,27.27 CH270.2 ; 11.85,67.07 v2(12.31,66.61)
  BOTTOM w0.406: v2(307.71,21.8) 307.58,21.92 QN1.1 ; QN1.4 304.24,20.62 v2(304.11,20.5) ; PR2035.2 52.86,14.48 PC2012.2 ; PQ2007.1 71.62,26.76 71.87,27 71.87,27.61 72.31,28.06 PQ2007.4 73.02,28.4 73.02,28.67 73.48,29.12 PC2018.2 ; 42.97,20.03 42.24,20.77 41.89,20.77 41.49,21.17 PQ2009.4 ; DT3.1 15.19,60.59 v2(15.44,60.85) ; PQ2112.4 39.36,11.51 v2(38.63,12.23)
  BOTTOM w0.432: QV23.1 137.63,136.46 138.01,136.08 RV908.2 ; v2(24.08,41.75) 23.63,42.2 JCCG1.11 ; v2(16.1,41.98) 16.32,42.2 JCCG1.12 ; QV23.4 v2(136.33,139.41)
  BOTTOM w0.457: CV933.2 RV896.1 ; RT36.2 42.95,43.74 v2(42.95,43.75) ; CT353.1 26.82,37.58 26.44,37.96 RT536.2 26.49,38.32 26.93,38.32 v2(27.1,38.48)
  BOTTOM w0.508: PC2020.2 34.81,14.81 PR2061.2 34.03,14.29 v2(33.82,14.08) ; v2(40.84,59.76) 40.84,59.63 RT23.2 ; CC165.2 CC167.2 217.99,55.89 v2(214.59,55.89) ; v2(59.54,10.81) 59.09,11.25 PC138.2 ; v2(252.28,22.66) 252.28,22.12 RC438.2 ; v2(13.28,62.87) 13.6,62.55 DT2005.2 ; CZ81.2 30.59,8.24 v2(30.81,8.02) ; CZ102.1 164.06,30.28 v2(164.46,29.87) ; v2(171.02,56.77) 170.82,56.77 170.3,57.3 RD12.2 ; RH372.2 117.76,38.13 v2(117.74,38.15) ; PR2108.2 38.64,35.87 v2(37.81,36.7) ; PC2018.2 74.29,29.12 PC2015.2 74.54,29.57 74.22,29.89 v2(74.22,30.47) ; CI61.2 382.79,49.61 v2(383.36,50.18) ; PC1120.2 303.15,39.64 v2(303.15,40.43) 302.66,40.43 302.16,39.92 PC1126.2 ; RA209.2 390.63,26.95 391.09,26.49 v2(391.09,26.44) ; RV813.2 285.47,80.12 285.93,79.67 v2(285.93,79.59) ; CZ75.2 145.7,17.07 v2(145.99,16.78) ; CT351.1 24.37,39.11 24.2,39.27 v2(23.76,39.27) ; UC5.4 120.34,14.82 v2(120.29,14.87) ; v2(388.85,30.63) 389.47,30.01 RA223.1 ; v2(355.98,12.82) 356.39,13.22 C207.2 ; CC325.2 266.9,12.92 v2(266.77,12.79) ; v2(383.02,60.1) 382.49,60.1 381.99,59.59 RI75.1 ; v2(168.4,23.93) 168.44,23.89 CD9.2 ; CD74.2 200.04,39.1 v2(199.69,38.75) ; CC29.2 245.84,22.6 245.44,23 v2(245.15,23) ; v2(93.93,63.39) 94.37,62.94 PD2.2 ; QT7.3 34.34,30.34 v2(34.34,29.91) ; RC122.2 259.54,14.8 259.88,14.47 v2(259.88,14.04) ; CT21.2 29.44,39.8 29.44,40.24 ; v2(253.5,14.62) 253.46,14.59 253.46,13.53 RC321.2 ; 96.21,50.94 96.77,50.94 PC4.2 ; v2(216.87,35.52) 216.91,35.57 216.94,35.57 217.05,35.68 217.66,35.68 CC81.2 CC84.2 ; v2(170.95,90.5) 170.94,90.49 CD3.2 ; v2(305.27,42.55) 305.37,42.44 PC1106.1 ; v2(305.27,42.55) 305.27,42 305.74,41.53 PR1120.2 ; v2(305.27,42.55) 305.27,43.05 305.5,43.29 PR1112.1 ; JNGFF3.68 v2(318.08,33.14) ; PC403.2 164.08,88.01 v2(163.64,88.45) ; JSIM1.12 116.92,146.33 v2(116.56,145.97) ; DT59.1 21.61,64.63 v2(21.61,63.26) ; JAPS1.20 v2(114.02,59.51) 114.22,59.31 JDEG1.11 ; v2(43.01,57.28) 43.13,57.16 RT505.2 ; CD99.2 184.87,89.87 CD98.2 185.34,89.63 185.77,90.06 186.13,90.06 ; CR248.1 20.75,22.74 v2(21.34,23.32) ; CH32.2 146.86,52.36 v2(148.71,52.36) ; v2(16.51,51.77) 16.69,51.95 DT2004.2 ; v2(154.33,120.42) 154.96,121.06 CV955.2 ; CD77.2 203.2,55.35 CD89.2 203.48,54.24 v2(203.56,54.16) ; v2(292.55,29.86) 291.29,29.86 291.1,29.67 JRTC1.4 ; CD11.2 168.92,68.02 v2(169.24,68.34) ; PC1118.1 304.1,45.39 PR1132.1 303.27,44.8 v2(303.15,44.67) 302.89,44.67 302.38,45.18 PC1123.1 ; CT354.2 9.14,35.19 v2(8.94,35.4) ; v2(121.16,22.54) 121.22,22.6 CH322.2 ; v2(77.48,22.32) 77.36,22.44 77.36,22.55 77.16,22.75 PR2053.2 PC2017.2 ; CR234.2 17.35,9.36 CR235.2 ; CV812.2 286.02,76.59 v2(285.67,76.24) ; CC170.2 217.52,51.83 v2(217.07,51.38) ; v2(160.35,140.17) 159.75,139.56 RL3.2 ; PC1137.2 305.79,44.15 v2(305.27,44.67) ; v2(390.24,17.08) CA4.1 ; RZ25.2 387.26,11.58 v2(387.42,11.42) ; RC440.2 v2(251.28,22.65) ; v2(29.23,25.49) 29.23,26.05 QT8.3 ; v2(49.73,2.17) 49.75,2.19 PC119.2 ; PC307.2 297.67,62.76 297.84,62.93 v2(297.84,63.06) ; PC127.2 50.94,2.24 v2(51,2.17) ; CC171.2 217.07,43.96 v2(216.98,43.87) ; v2(217.08,39.23) 217.11,39.26 CC166.2 ; v2(216.15,51.38) 216.15,52.87 216.9,53.62 CC83.2 ; RC219.1 255.29,13.71 254.9,14.09 v2(254.9,14.58) ; v2(159.46,70.5) 159.35,70.39 RE568.2 ; CT348.1 24.36,26.71 v2(24.62,26.98) ; v2(242.18,14.1) 242.63,13.66 CC28.2 ; v2(141.13,55.21) 141.06,55.29 RH435.1 ; v2(56.59,25.61) 56.43,25.61 56.08,25.26 56.08,25.05 55.26,24.23 PC2010.2 54.23,24.23 PR2032.2 ; PC308.2 298.89,62.88 298.93,62.92 v2(298.93,63.11) ; PC2012.2 52.87,13.79 v2(52.85,13.77) ; RC323.2 246.3,13.98 v2(246.3,14.48) ; JSIM1.7 122.8,159.54 v2(123.4,160.14) 123.38,160.16 CZ40.2 ; PC2024.2 45.85,15.62 v2(46.68,15.62) ; RH110.1 137.88,46.13 v2(137.87,46.12) ; CZ60.2 148.62,19.87 CZ59.2 148.81,18.98 v2(149.24,19.41) ; v2(128.03,54.81) 128.03,54.87 128.47,55.31 128.47,56.2 RH1.1 ; v2(49.86,45.61) RV881.2 RV882.2 ; v2(216.29,39.22) 216.29,40.4 216.8,40.91 CC164.2 CC168.2 ; CE40.2 147.66,64.4 147.17,63.91 v2(147.17,62.55) 147.27,62.45 147.27,62.12 147.65,61.74 CE62.2 ; v2(20.02,37.73) 20.23,37.94 CT350.1 ; v2(197.74,30.55) 198.97,30.55 CD72.2 ; RC436.2 v2(251.79,14.38) ; CZ39.2 v2(129.64,160.7) ; v2(39.19,18.79) 38.68,18.79 PC2019.2 ; v2(217.02,49.93) 217.03,49.93 CC161.2 CC172.2 CC163.2 ; RI77.1 v2(375.56,55.77) ; v2(24.73,14.22) 24.68,14.27 CR219.1 ; v2(236.71,12.33) 236.76,12.38 CC307.2 ; QE12.3 151.9,75.9 151.62,75.62 v2(151.62,75.45) ; v2(301.32,28.08) 301.27,28.13 PC24.2 ; v2(92.71,20.16) 92.71,21 JSPI1.21 ; RI91.1 v2(386.09,49.21) ; v2(207.12,54.26) 207.01,54.37 CD90.2 RD32.2 206.37,55.59 206.16,55.8 RD33.2 205.37,56.23 CD88.2 ; CZ56.2 135.56,15.62 136.03,16.1 v2(136.06,16.1) ; PR1152.2 300.52,41.42 301.02,40.91 v2(301.02,40.43) 300.62,40.02 PR1153.2 ; RA221.1 382.26,14.76 381.31,14.76 v2(381.18,14.9) ; JSPI1.22 92.42,18.17 v2(93.22,17.37) ; PR2033.2 52.51,24.31 PC2009.2 52.54,24.73 v2(52.7,24.89) ; CI68.2 v2(387.8,39.32) ; RD80.1 168.09,63.94 RD90.1 v2(167.33,62.7) ; v2(127.73,72.2) 127.88,72.36 128.26,72.36 128.58,72.67 CE3.2 129.05,72.99 129.25,73.19 RZ537.2 ; v2(124.47,28.93) 124.19,28.64 123.28,28.64 RH83.2 ; v2(249.96,14.38) 250.01,14.33 RC181.2 ; v2(386.21,13.67) 386.21,14.28 RA220.2 ; JRTC1.2 294.9,27.25 v2(295.09,27.45) ; JDEG1.12 114.83,52.81 v2(114.34,52.31) ; v2(144.78,41.24) 145.02,41 CH47.2 ; v2(23.62,4.76) 24.41,4.76 24.88,4.3 RR239.1 ; PC313.2 309.45,56.1 v2(309.43,56.09) ; PC1127.2 295.17,46.5 PR1167.2 v2(295.15,45.79) ; CD34.2 153.62,15.52 v2(153.64,15.5) ; RV812.2 288.41,82.42 v2(288.54,82.29) ; v2(338.76,48.63) 338.16,48.63 338.1,48.57 CZ71.2 ; v2(38.63,12.23) 38.54,12.32 PC2022.2 PC2021.2 ; v2(248.47,22.79) 248.47,22.18 RC443.2 ; v2(116.93,25.38) 116.93,25.69 116.98,25.73 RH308.2 ; v2(164.44,59.5) 164.38,59.45 CD16.2 ; v2(168.68,83.43) 168.16,82.91 JDIMM2.262 165.77,83.36 166.88,84.47 v2(168.65,84.47) ; CH268.1 117.1,43.11 117.1,42.88 117.57,42.41 v2(118.4,42.41) 118.59,42.41 118.62,42.43 RH401.2 ; v2(111.9,115.9) 111.78,116.02 CZ531.2 ; v2(128.95,19.24) 128.45,19.24 128.26,19.43 RH424.2 ; PC2.2 94.88,64.02 v2(94.56,64.02) ; v2(168.88,74.06) 169.21,74.06 169.66,74.5 169.66,75.22 CD13.2 ; v2(198.77,31.89) 198.89,32.02 CD108.2 ; YT1.2 32.42,37.62 CT20.2 v2(33.03,38.6) ; v2(15.27,23.78) 15.27,23.2 CR218.2 ; PR1156.2 300.5,43.07 v2(301.02,42.55) 300.78,42.31 PR1158.2 ; v2(51.64,38.37) 51.84,38.17 RV861.1 ; v2(136.33,139.41) 135.62,139.41 RV911.2 ; v2(166.91,56.93) 166.89,56.96 CD26.2 166.67,57.78 RD11.2 ; v2(164.82,106) 164.82,107.77 JNGFF2.69 ; PR1155.2 300.97,44.72 v2(301.02,44.67) ; v2(55.57,40.91) RV856.2 54.79,41.59 RV876.2 ; PR64.2 300.86,33.45 v2(301.14,33.73) 301.92,32.95 PQ26.3 ; v2(46.41,12.94) 46.65,13.18 PC2026.2 ; RH364.2 144.63,52.64 v2(144.14,53.13) 143.69,53.58 RH365.2 ; PR2146.2 PC2105.2 84.54,27.95 v2(84.76,27.74) 85.08,27.42 85.56,27.42 PD3.1 ; JRTC1.3 v2(297.45,27.19) ; v2(317.6,37.76) 317.61,37.76 JNGFF5.69 ; v2(129.66,162.63) 129.02,161.98 CZ38.2 ; PC2014.2 v2(49.56,13.5) ; v2(150.86,68.63) CE59.2 CE60.2 ; UR3.4 20.9,2.17 v2(20.65,1.92) ; PR2062.2 47.79,18.77 v2(48.5,18.07) ; JSIM1.10 116.76,157.33 v2(116.56,157.53) ; YT1.4 30.01,35.48 v2(31.32,34.18) ; CR245.1 CR246.1 22.58,24.61 v2(22.61,24.64) ; v2(238.82,36.49) 238.82,36.49 CC334.2 ; v2(20.73,70.14) 21.34,70.14 CT368.2 CT367.2 ; RV818.2 v2(287.82,74.34) ; CA68.2 CA67.2 393.47,13.73 v2(393.72,13.98) 393.84,13.87 RA227.1 ; v2(295.89,81.21) 295.43,81.68 CV61.2 ; 364.11,11.81 CZ130.2 364.31,11.98 364.31,12.36 v2(364.51,12.56) ; v2(303.45,82.21) 303.35,82.31 RV131.1 ; R128.2 v2(169.1,140.99) ; CZ58.2 CZ57.2 v2(152.68,23.76) ; v2(382.13,31.25) 382.33,31.45 RA226.1 ; CR214.1 10.95,25.13 CR215.2 10.92,25.29 9.55,26.66 v2(9.55,26.71) ; RT506.2 43.09,58.19 43.55,58.65 v2(43.55,58.92) ; v2(27.84,27.1) 27.1,26.36 QT9.3 ; RH610.1 123.09,49.24 v2(122.37,49.24) 121.89,49.24 121.61,48.96 121.61,48.78 CH323.2 ; RE736.1 RE738.1 ; RV896.1 71.28,55.99 v2(71.28,55.25) ; PR2144.2 PC2104.2 81.61,24.53 81.23,24.14 80.83,24.14 80.55,24.42 80.55,24.62 80.46,24.71 v2(80.46,24.91) ; v2(142.73,79.71) 142.61,79.59 RV905.2 ; v2(9.57,29.18) 10.08,29.18 10.26,29.35 RT527.2 ; v2(107.8,10.85) 108.62,11.67 CH342.2 ; CC185.2 217.92,60.19 CC82.2 217.15,61.48 v2(215.6,63.02) 215.6,65.01 218.98,68.38 CC301.2 ; RV56.2 298.4,78.56 v2(298.51,78.67) ; v2(270.85,69.53) 270.39,69.99 RC179.2 RC178.2 ; UC6.4 110.59,24.58 111.24,23.93 v2(111.24,23.89) 111.26,23.91 RH334.1 ; v2(302.44,81.21) 302.65,81.42 CV60.2 ; RV880.2 RV883.2 49.91,43.58 v2(49.88,43.6) ; v2(305.27,40.43) 305.71,39.98 PR1135.2 ; RD83.1 v2(169.79,60) ; CH22.2 128.15,43.07 v2(128.19,43.11) ; v2(249.11,22.77) 249.38,22.49 249.38,22.16 RC442.2 ; v2(24.46,11.44) 24.03,11.01 RR232.2 ; v2(54.28,28.54) 54.43,28.69 PC20.2 PR58.1 ; RV894.2 71.76,57.79 70.92,58.64 v2(70.43,58.64) ; PR115.2 v2(54.55,2.83) ; v2(129.18,86.67) 128.75,86.67 C199.2 127.11,86.01 C209.2 ; PR2056.2 74.67,25.44 v2(75,25.11) 74.55,25.11 74.09,24.65 PC2016.2 ; v2(118.36,40.32) 118.58,40.32 118.72,40.45 RH349.2 RH554.2 ; RV857.2 RV858.2 v2(57.73,40.91) ; PR2059.2 v2(35.45,20.49) ; DT4.1 15.29,48.02 v2(15.64,47.67) ; v2(131.49,35.57) 131.31,35.75 RH556.2 ; v2(385.69,57.48) 385.69,56.82 RI76.1 ; CT352.2 14.2,36.04 v2(13.99,35.84) ; v2(55.35,13.75) PC2013.2 54.52,14.49 PR2034.2 ; CR227.1 14.02,25.16 CR228.1 13.99,23.98 v2(14,23.97) ; CR223.1 21.55,10.93 v2(21.92,10.56) ; JESPI.12 v2(94.22,12.55) ; v2(111.77,121.17) 112.28,120.66 CV851.1 CV853.2 ; v2(30.05,30.24) 30.11,30.3 30.13,30.3 30.89,31.06 QT6.3 ; v2(31.51,13.22) 31.19,13.22 30.2,12.24 CZ80.2 ; RI92.1 v2(389.85,45.62) ; C191.2 167.02,133.28 v2(166.99,133.26) ; v2(109.67,107.38) 109.65,107.36 JNGFF1.68 ; RZ539.2 334.08,23.25 v2(334.01,23.32) 334.51,23.32 334.87,22.95 RZ538.2 ; RC437.2 253.98,22.53 v2(254.01,22.56) ; RD18.2 RD79.1 180.22,89.92 180.22,90.82 v2(180.35,90.95) ; CA227.2 390.74,25.71 v2(391.03,25.71) ; RE86.2 v2(118.78,57.11) ; v2(138.69,135.65) 138.44,135.9 RV908.2 ; v2(17.47,55.39) 17.09,55.77 DT2002.2 ; CD61.2 v2(167.2,61.99) ; CV852.2 118.28,120.54 v2(118.7,120.12) ; QT5.3 14.67,38.38 15.39,37.66 v2(15.82,37.66) ; PC2103.2 88.1,31.45 v2(89.33,30.22) ; v2(128.26,32.95) 127.98,32.67 RH379.2 ; v2(127.58,82.18) 127.79,82.39 128.43,82.39 128.66,82.62 128.68,82.62 128.87,82.81 v2(128.87,82.85) ; v2(168.99,71.36) 169,71.37 CD44.2 ; v2(85.93,24.3) 86.06,24.43 PQ16.3 ; CD33.2 169.77,78.49 CD32.2 171.23,78.49 v2(171.47,78.73) ; v2(110.28,35.07) 111.39,35.07 111.73,34.73 RH65.2 ; RI93.1 v2(377.9,45.75) ; C195.2 v2(168.14,133.89) ; RC441.2 v2(250.33,22.8) ; v2(93.06,59.83) 93.06,59.17 92.65,58.76 PJPDC1.11 87.64,58.76 87.07,59.32 86.58,59.32 v2(86.31,59.6) ; RL9.2 161.29,137 v2(161.31,137.02) ; v2(44.14,57.25) RT507.2 ; JAPS1.19 114.02,73.02 114.55,72.48 v2(114.55,72.24) ; CA12.2 CA1.1 388.2,15.05 v2(386.85,13.7) ; JSIM1.11 131.71,146.52 v2(131.71,147.42) ; RC136.2 239.47,22.41 239.47,22.75 v2(239.21,23) ; CD60.2 166.25,61.75 v2(166.47,61.97) ; CV16.2 v2(111.85,148.34) ; JSIM1.9 v2(133.47,157.33) ; DT2006.2 16.93,62.96 v2(16.46,63.44) ; PC129.2 53.71,2.8 v2(53.7,2.8)
  vias: v2(0.97,70.53) v2(0.95,54.25) v2(1.15,74.06) v2(1.18,73.13) v2(1.13,68.17) v2(1.36,57.86) v2(1.72,62.68) v2(1.94,46.69) v2(2,78.88) v2(2.38,74) v2(2.37,73.28) v2(2.48,57.85) v2(2.66,61.18) v2(2.68,36.64) v2(2.68,29.02) v2(2.68,21.4) v2(2.65,14.15) v2(2.77,64.81) v2(2.83,53.98) v2(2.99,77.41) v2(2.93,48.72) v2(3.1,80.99) v2(3.29,44.69) v2(4.29,61.13) v2(4.34,43.73) v2(4.46,40.91) v2(4.6,17.68) v2(4.9,64.51) v2(4.89,48.67) v2(4.83,28.31) v2(4.95,80.86) v2(5.2,77.69) v2(5.31,45.2) v2(5.46,62.42) v2(5.55,8.45) v2(5.67,67.95) v2(5.69,51.75) v2(5.74,42.97) v2(5.92,79.54) v2(6.06,47.2) v2(6.09,38.93) v2(7.06,74.26) v2(7.03,60.19) v2(7.06,58.08) v2(7.19,67.71) v2(7.31,51.49) v2(7.69,42.92) v2(8,76.11) v2(8.23,39.33) v2(8.48,19.85) v2(8.55,79.35) v2(8.74,21.48) v2(8.86,41.44) v2(9.8,16.09) v2(9.8,14.21) v2(10.02,5.31) v2(11.35,3.27) v2(11.97,39.83) v2(13.05,18.94) v2(13.18,39.94) v2(15.53,18) v2(15.53,16.03) v2(15.53,14.06) v2(15.67,77.61) v2(16.43,0.45) v2(17.27,54.7) v2(17.5,16.03) v2(17.5,14.06) v2(18.54,32.98) v2(18.51,32.38) v2(19.06,51.54) v2(19.17,31.71) v2(19.47,18) v2(19.47,16.03) v2(19.47,14.06) v2(20.1,72.75) v2(20.34,31.64) v2(20.95,31.66) v2(21.21,47.23) v2(21.46,28.91) v2(21.56,32.86) v2(21.84,46.73) v2(22.32,46.27) v2(24.05,0.45) v2(24.52,68.95) v2(26.39,13.58) v2(26.5,14.76) v2(26.79,16.78) v2(26.98,16.22) v2(27.26,19.34) v2(27.63,60.52) v2(27.63,59.76) v2(27.73,54.63) v2(27.76,20.68) v2(27.96,50.51) v2(28.27,20.32) v2(28.42,60.49) v2(28.47,59.76) v2(28.73,48.79) v2(28.96,65.95) v2(28.9,20.46) v2(29.01,52.74) v2(29.19,44.6) v2(29.26,45.98) v2(29.28,40.68) v2(29.66,41.26) v2(30.91,0.45) v2(31.57,41.87) v2(32.16,55.06) v2(34.9,62.88) v2(35.51,35.78) v2(35.56,34.43) v2(35.88,36.98) v2(36.41,38.29) v2(36.57,37) v2(37.78,38.34) v2(39.09,38.23) v2(39.15,36.7) v2(39.29,0.45) v2(40.04,59.84) v2(40.3,38.32) v2(40.87,19.73) v2(40.9,1.93) v2(41.01,36.49) v2(41.67,38.16) v2(42.06,1.91) v2(42.7,60.28) v2(42.83,38.18) v2(43.37,1.88) v2(43.53,19.45) v2(44,36.46) v2(44.1,38.26) v2(44.42,19.67) v2(45.3,38.25) v2(46.91,0.45) v2(49.17,57.37) v2(49.46,40.06) v2(50.05,40.06) v2(50.82,58.61) v2(51.76,56.15) v2(53.02,7.64) v2(53.24,58.23) v2(54.22,52.62) v2(54.53,0.45) v2(55.32,58.26) v2(55.8,53.79) v2(55.8,52.62) v2(55.8,51.46) v2(55.8,50.29) v2(55.8,49.14) v2(55.8,47.98) v2(55.8,46.81) v2(57.37,53.79) v2(57.37,52.62) v2(57.37,51.46) v2(57.37,50.29) v2(57.37,49.14) v2(57.37,47.98) v2(57.37,45.64) v2(59.15,7.81) v2(59.15,7.18) v2(59.74,7.81) v2(59.74,7.18) v2(60.02,58.56) v2(60.32,7.81) v2(60.32,7.18) v2(60.5,59.43) v2(60.69,58.56) v2(60.7,2.15) v2(60.91,7.81) v2(60.91,7.18) v2(61.49,7.81) v2(61.49,7.18) v2(61.68,58.58) v2(61.65,51.16) v2(61.87,43.92) v2(61.85,4.41) v2(61.87,0.5) v2(62.08,7.81) v2(62.08,7.18) v2(62.15,47.72) v2(62.37,54.82) v2(62.56,52.72) v2(62.62,58.55) v2(62.67,7.18) v2(63.27,46.3) v2(63.26,7.18) v2(63.45,50.72) v2(63.84,7.18) v2(63.95,43.93) v2(64.29,55.52) v2(64.53,47.11) v2(64.72,48.74) v2(64.84,0.5) v2(64.97,4.33) v2(65.1,28.08) v2(65.1,27.45) v2(65.15,43.91) v2(65.54,52.24) v2(66.01,2.2) v2(66.23,55.47) v2(66.72,47.72) v2(66.93,44.36) v2(67.18,48.1) v2(68.78,45.23) v2(69.77,0.45) v2(70.36,44.29) v2(71.01,59.49) v2(72.2,52.26) v2(72.2,50.69) v2(72.2,49.11) v2(72.72,58.69) v2(73.1,10.94) v2(73.37,52.26) v2(73.37,50.69) v2(73.37,49.11) v2(73.38,43.22) v2(73.73,10.94) v2(74.5,10.94) v2(74.53,52.26) v2(74.53,50.69) v2(74.53,49.11) v2(74.54,44.03) v2(74.85,58.97) v2(74.88,10.05) v2(74.86,9.39) v2(75.26,10.94) v2(75.44,58.71) v2(75.49,10.06) v2(75.47,9.4) v2(75.7,52.26) v2(75.7,50.69) v2(75.7,49.11) v2(76.02,10.94) v2(76.07,10.07) v2(76.06,9.41) v2(76.67,10.07) v2(76.65,9.41) v2(76.78,10.94) v2(76.85,52.26) v2(76.85,50.69) v2(76.85,49.11) v2(77.07,59.27) v2(77.09,43.88) v2(77.32,9.57) v2(77.39,0.45) v2(77.44,10.94) v2(78.01,52.26) v2(78.01,50.69) v2(78.01,49.11) v2(79.18,52.26) v2(79.18,50.69) v2(79.18,49.11) v2(79.93,61.14) v2(80.03,44.16) v2(80.35,52.26) v2(80.35,50.69) v2(80.35,49.11) v2(85.01,0.45) v2(86.08,47.36) v2(86.1,46.75) v2(86.66,48.53) v2(86.66,47.94) v2(86.66,47.36) v2(86.69,46.75) v2(86.82,16.58) v2(87.3,48.53) v2(87.3,47.94) v2(87.3,47.36) v2(87.32,46.75) v2(90.44,66.37) v2(92.63,0.45) v2(93.57,60.3) v2(95.19,49.61) v2(95.2,49.01) v2(95.2,46.37) v2(95.2,51.21) v2(95.2,50.62) v2(95.21,48.14) v2(95.21,47.54) v2(95.2,46.96) v2(95.84,51.23) v2(95.83,50.62) v2(95.83,49.61) v2(95.83,49.01) v2(95.84,48.14) v2(95.85,47.54) v2(95.83,46.96) v2(95.83,46.37) v2(97.83,2.07) v2(98.38,73.2) v2(98.64,6.97) v2(98.64,6.09) v2(98.64,5.2) v2(98.64,4.31) v2(98.64,3.42) v2(99.27,6.97) v2(99.27,6.09) v2(99.27,5.2) v2(99.27,4.31) v2(99.27,3.42) v2(99.41,17.29) v2(99.91,6.97) v2(99.91,6.09) v2(99.91,5.2) v2(99.91,4.31) v2(99.91,3.42) v2(100.06,19.43) v2(100.25,0.45) v2(100.54,6.97) v2(100.54,6.09) v2(100.54,5.2) v2(100.54,4.31) v2(100.54,3.42) v2(102.46,23.22) v2(104.18,81.82) v2(104.98,19.22) v2(104.98,18.63) v2(105.5,18.93) v2(105.62,36.81) v2(105.62,36.17) v2(106.2,30.34) v2(106.2,29.14) v2(106.5,90.31) v2(106.52,157.24) v2(106.53,147.4) v2(106.54,132.65) v2(106.52,113.58) v2(107.2,37.99) v2(107.2,37.38) v2(107.19,36.78) v2(107.2,36.17) v2(107.17,29.74) v2(107.52,35.61) v2(107.8,37.98) v2(107.8,37.37) v2(107.81,36.77) v2(107.81,36.18) v2(107.87,0.45) v2(107.91,150.34) v2(108.1,94.27) v2(108.14,30.34) v2(108.28,126.75) v2(108.25,102.69) v2(108.25,102.11) v2(108.25,101.53) v2(108.25,100.94) v2(108.25,100.36) v2(108.23,91.18) v2(108.84,102.69) v2(108.84,102.11) v2(108.84,101.53) v2(108.84,100.94) v2(108.84,100.36) v2(109.42,102.11) v2(109.42,101.53) v2(109.42,100.94) v2(109.42,100.36) v2(109.83,95.06) v2(110.59,90.74) v2(110.63,173.27) v2(110.66,163.34) v2(111.07,156.18) v2(111.66,94.3) v2(111.82,131.14) v2(111.82,130.56) v2(111.88,92.17) v2(112.19,40.81) v2(112.24,177.64) v2(112.26,167.38) v2(112.21,41.42) v2(112.48,153.88) v2(112.41,131.13) v2(112.41,130.55) v2(112.55,13.2) v2(113.29,104.03) v2(113.36,105.81) v2(113.8,13.2) v2(114.49,153.98) v2(114.88,90.95) v2(114.91,94.33) v2(114.92,92) v2(115.23,148.33) v2(115.44,18.35) v2(115.49,0.45) v2(115.68,150.78) v2(115.71,111.13) v2(115.72,103.67) v2(115.72,17.77) v2(116.13,18.2) v2(116.3,151.4) v2(116.3,150.15) v2(116.93,150.78) v2(117.25,148.45) v2(117.27,103.67) v2(117.37,49.99) v2(117.55,100.41) v2(118.48,161.41) v2(118.51,110.58) v2(119.08,85.81) v2(119.1,85.21) v2(119.4,165.44) v2(119.33,110.38) v2(120.33,16.13) v2(120.65,95.72) v2(121.1,109.84) v2(121.26,95.77) v2(121.84,102.36) v2(122.42,102.63) v2(122.59,100.3) v2(123.11,0.45) v2(123.21,120.33) v2(123.66,121.05) v2(123.69,119.97) v2(124.17,16.13) v2(124.35,114.21) v2(125.19,113.57) v2(125.97,84.05) v2(126.73,136.89) v2(126.97,177.57) v2(126.98,172.97) v2(127.1,168.02) v2(127.16,11.25) v2(127.15,10.1) v2(127.38,10.66) v2(127.58,9.67) v2(127.74,11.25) v2(127.79,10.23) v2(128.09,10.75) v2(128.19,135.9) v2(128.19,9.67) v2(128.19,9.08) v2(128.42,10.21) v2(128.56,177.65) v2(128.75,116.89) v2(128.72,10.72) v2(128.78,9.67) v2(128.78,9.08) v2(129.03,157.8) v2(129.07,10.2) v2(129.29,168.76) v2(129.38,84.23) v2(129.36,9.67) v2(129.36,9.08) v2(129.49,159.15) v2(129.49,158.38) v2(129.54,117.22) v2(129.78,157.88) v2(129.94,9.67) v2(129.94,9.08) v2(130.25,134.51) v2(130.55,171.59) v2(130.57,103.77) v2(130.53,9.67) v2(130.53,9.08) v2(130.63,111.9) v2(130.73,0.45) v2(130.83,173.78) v2(130.93,102.2) v2(131.11,9.67) v2(131.11,9.08) v2(132.23,134.74) v2(132.61,169.69) v2(132.93,9.68) v2(132.93,9.04) v2(133.22,174.54) v2(133.46,102.17) v2(133.51,9.68) v2(133.51,9.04) v2(133.87,60.73) v2(134.01,134.71) v2(134.47,101.68) v2(135.04,173.48) v2(135.02,170.6) v2(135.17,175.11) v2(135.33,109.87) v2(135.5,60.48) v2(135.51,59.85) v2(135.52,59.24) v2(135.81,112.48) v2(136.2,117.75) v2(136.26,117.05) v2(136.3,116.39) v2(136.27,115.72) v2(136.34,135.04) v2(136.45,65.85) v2(136.55,118.23) v2(136.71,169.33) v2(136.87,117.73) v2(136.94,117.03) v2(136.97,116.38) v2(136.98,115.76) v2(137.16,65.85) v2(137.26,118.2) v2(137.23,51.32) v2(137.37,101.88) v2(137.62,117.73) v2(137.69,117.03) v2(137.72,116.38) v2(137.72,115.73) v2(137.82,65.85) v2(138.11,174.96) v2(138.35,0.45) v2(138.49,117.15) v2(138.85,100.05) v2(138.82,98.69) v2(139.39,96.28) v2(139.55,17.29) v2(139.55,15.76) v2(140.06,100.05) v2(140.23,94.63) v2(140.42,117) v2(140.76,22.93) v2(140.88,126.42) v2(140.87,94.58) v2(141.07,17.29) v2(141.17,100.03) v2(141.22,95.06) v2(141.58,94.58) v2(141.81,22.11) v2(142.34,87.87) v2(142.31,13.25) v2(142.45,22.13) v2(143,13.25) v2(143.07,108.82) v2(143.1,106.99) v2(143.14,107.85) v2(143.2,60.56) v2(143.24,22.98) v2(143.42,49.61) v2(143.56,87.7) v2(144.23,87.87) v2(144.53,23.03) v2(145.71,23.02) v2(145.82,42.19) v2(145.97,0.45) v2(146.38,19.83) v2(146.38,18.81) v2(146.62,73.03) v2(147.27,44.85) v2(148.03,103.52) v2(148.2,30.29) v2(148.68,147.41) v2(148.77,28.88) v2(148.82,39.99) v2(149.02,46.88) v2(149.1,44.82) v2(149.12,38.09) v2(149.22,42.31) v2(149.77,29.8) v2(149.87,98.41) v2(149.89,97.81) v2(149.91,99.15) v2(150.01,50.03) v2(150.11,110.11) v2(150.24,22.43) v2(150.52,40.02) v2(150.61,132.78) v2(150.7,38.83) v2(150.72,28.84) v2(150.92,41.62) v2(151.03,147.39) v2(151.13,21.17) v2(151.56,99.25) v2(151.56,98.67) v2(151.56,98.03) v2(151.57,30.09) v2(151.86,39.99) v2(151.84,38.45) v2(151.91,139.83) v2(151.91,138.56) v2(152.06,112.1) v2(152.14,120.42) v2(152.14,117.88) v2(152.29,132.83) v2(152.35,147.92) v2(152.85,100.71) v2(152.87,98.32) v2(152.82,70.44) v2(152.83,69.82) v2(152.83,69.21) v2(152.85,68.58) v2(153.18,141.1) v2(153.18,139.83) v2(153.18,138.56) v2(153.19,2.25) v2(153.24,112.21) v2(153.31,174.88) v2(153.32,168.39) v2(153.59,0.45) v2(153.63,54.93) v2(153.79,2.25) v2(154,53.5) v2(154.24,132.3) v2(154.33,119.15) v2(154.33,117.88) v2(154.45,139.83) v2(154.45,138.56) v2(154.48,51.41) v2(154.43,2.25) v2(154.51,52.59) v2(154.68,105.15) v2(154.91,148.05) v2(155.01,132.32) v2(155.11,2.25) v2(155.62,34.92) v2(156.09,105.43) v2(156.09,38.72) v2(156.12,26.32) v2(156.31,148.02) v2(156.51,119.15) v2(156.51,117.88) v2(156.54,28.07) v2(156.62,101.08) v2(156.69,38.71) v2(156.73,30.66) v2(156.84,176.54) v2(157.05,35.19) v2(157.06,33.77) v2(157.05,26.95) v2(157.12,93.15) v2(157.21,101.21) v2(157.68,105.83) v2(158.05,90.73) v2(158.05,90.15) v2(158.05,89.56) v2(158.11,27.78) v2(158.27,75.2) v2(158.27,73.07) v2(158.25,57.15) v2(158.25,55.13) v2(158.24,29.68) v2(158.39,148.27) v2(158.7,119.15) v2(158.7,117.88) v2(158.7,104.21) v2(158.63,90.73) v2(158.63,90.15) v2(158.63,89.56) v2(158.92,80.07) v2(159.33,74.13) v2(159.75,80.13) v2(159.97,103.97) v2(160.4,75.2) v2(160.4,73.07) v2(160.6,80.11) v2(160.6,127.4) v2(160.86,102.53) v2(161.21,0.45) v2(161.31,36.16) v2(161.56,38.5) v2(161.6,40.76) v2(162.65,88.8) v2(163.6,176.43) v2(163.9,118.04) v2(164.1,119.29) v2(164.16,120.95) v2(164.12,72.83) v2(164.66,134.27) v2(165.55,134.27) v2(165.68,135.8) v2(165.8,134.91) v2(165.94,118) v2(165.95,104.77) v2(166.1,119.27) v2(166.18,13.17) v2(166.25,120.87) v2(166.36,139.04) v2(166.44,138.34) v2(166.44,137.45) v2(167.19,13.17) v2(167.88,137.96) v2(168.48,156.48) v2(168.48,155.85) v2(168.48,155.09) v2(168.48,154.45) v2(168.83,0.45) v2(168.96,89.91) v2(170.05,36.31) v2(170.13,173.34) v2(170.13,165.75) v2(170.32,90.5) v2(170.46,112.49) v2(170.46,111.65) v2(170.51,110.96) v2(170.56,110.17) v2(170.65,30.9) v2(170.73,32.56) v2(171.08,159.27) v2(171.15,64.14) v2(171.42,176.19) v2(171.63,90.52) v2(171.64,30.9) v2(172.28,170.79) v2(172.28,163.17) v2(172.28,155.55) v2(172.28,147.93) v2(172.28,140.31) v2(172.28,132.69) v2(172.28,125.07) v2(172.28,117.45) v2(172.28,109.83) v2(172.54,53.23) v2(175.34,48.12) v2(175.61,51.47) v2(175.86,75.57) v2(175.82,44.14) v2(175.94,72.98) v2(175.95,17.41) v2(176.16,69.14) v2(176.39,73.64) v2(176.38,32.6) v2(176.47,77.74) v2(176.44,38.33) v2(176.45,0.45) v2(176.67,55.42) v2(176.67,36.33) v2(176.8,63.73) v2(176.76,25.76) v2(176.82,61.86) v2(176.88,60.96) v2(176.8,42.11) v2(176.84,41.14) v2(176.89,22.56) v2(176.89,20.53) v2(176.96,104.33) v2(176.96,70.76) v2(176.9,66.59) v2(176.94,40.04) v2(176.99,18.52) v2(177.06,59.41) v2(177.08,30.88) v2(177.18,73.01) v2(177.13,34.21) v2(177.25,76.27) v2(177.23,71.66) v2(177.23,65.21) v2(177.28,56.89) v2(177.2,27.55) v2(177.52,53.89) v2(177.64,51.43) v2(177.62,29.21) v2(177.7,24.19) v2(177.86,76.48) v2(177.82,50.2) v2(177.83,48.17) v2(177.98,81.35) v2(177.95,68.48) v2(177.96,36.33) v2(178.01,70.24) v2(178.02,55.45) v2(178.15,87.29) v2(178.1,66.61) v2(178.19,60.95) v2(178.16,25.74) v2(178.15,20.52) v2(178.22,74.49) v2(178.21,18.61) v2(178.4,30.86) v2(178.49,79.71) v2(178.41,59.4) v2(178.42,40.01) v2(178.42,34.14) v2(178.56,65.25) v2(178.52,38.3) v2(178.58,32.68) v2(178.73,90.72) v2(178.74,87.31) v2(178.84,53.94) v2(178.92,63.82) v2(178.98,29.2) v2(178.97,24.17) v2(179.08,48.13) v2(179.14,46.14) v2(179.39,55.43) v2(179.32,36.35) v2(179.44,56.85) v2(179.4,27.5) v2(179.58,44.4) v2(179.65,40) v2(179.77,51.46) v2(179.73,50.27) v2(179.82,15.95) v2(179.93,42.07) v2(180.02,20.44) v2(183.23,71.74) v2(183.21,37.35) v2(183.28,30.02) v2(183.37,75.8) v2(183.31,70.47) v2(183.39,42.2) v2(183.31,40.15) v2(183.36,38.59) v2(183.49,97.83) v2(183.49,77.16) v2(183.57,79.29) v2(183.76,73.81) v2(183.82,71.74) v2(183.87,37.38) v2(183.87,30.06) v2(183.92,68.01) v2(184,79.91) v2(184.05,75.79) v2(184.07,0.45) v2(184.77,24.22) v2(185.52,28.25) v2(185.95,91.22) v2(186.6,91.22) v2(187.29,91.22) v2(187.43,52.25) v2(188.94,50.27) v2(189.44,68.73) v2(189.47,16.17) v2(189.59,52) v2(189.67,48.19) v2(190.04,55.25) v2(190.11,39.95) v2(190.16,32.59) v2(190.14,27.42) v2(190.24,62.6) v2(190.46,42.94) v2(190.41,36.39) v2(190.46,34.74) v2(190.46,25.37) v2(190.59,95.65) v2(190.57,79.87) v2(190.52,46.14) v2(190.54,20.49) v2(190.57,17.31) v2(190.69,64.12) v2(190.67,59.55) v2(190.63,21.94) v2(190.72,70.37) v2(190.78,50.26) v2(190.87,78.63) v2(190.86,60.51) v2(190.85,48.15) v2(190.9,91.22) v2(190.95,72.95) v2(190.96,54.09) v2(190.91,31.09) v2(191.1,76.09) v2(191.02,23.69) v2(191.03,19.19) v2(191.15,74.11) v2(191.17,44.16) v2(191.28,77.31) v2(191.31,55.26) v2(191.31,38.24) v2(191.46,66.64) v2(191.48,62.58) v2(191.44,51.98) v2(191.42,29.14) v2(191.5,68.32) v2(191.51,65.57) v2(191.51,60.5) v2(191.63,71.67) v2(191.69,46.16) v2(191.66,36.36) v2(191.69,0.45) v2(191.71,42.94) v2(191.76,41.19) v2(191.71,25.36) v2(191.76,17.31) v2(191.82,34.73) v2(191.81,20.52) v2(191.95,50.28) v2(192.01,70.37) v2(192.16,31.09) v2(192.24,78.63) v2(192.28,72.94) v2(192.22,40) v2(192.25,27.5) v2(192.29,23.64) v2(192.32,76.09) v2(192.32,56.77) v2(192.38,44.19) v2(192.36,32.59) v2(192.35,19.22) v2(192.5,77.33) v2(192.55,55.28) v2(192.69,68.29) v2(192.69,66.68) v2(192.64,29.11) v2(192.71,65.57) v2(192.8,64.1) v2(192.74,21.97) v2(192.8,79.87) v2(192.8,71.67) v2(192.95,46.17) v2(192.95,36.39) v2(193.03,48.31) v2(193.08,25.36) v2(193,20.52) v2(193.15,74.1) v2(193.19,53.3) v2(193.49,38.19) v2(193.78,50.28) v2(193.81,17.15) v2(193.98,82.01) v2(193.99,16.17) v2(196.89,68.23) v2(196.92,75.3) v2(196.9,71.42) v2(197.5,71.42) v2(197.55,78.73) v2(197.51,75.3) v2(197.6,65.6) v2(197.92,43.48) v2(198.2,65.59) v2(198.21,95.65) v2(198.33,48.75) v2(198.81,65.55) v2(199.38,56.62) v2(199.37,51.22) v2(199.31,0.45) v2(199.55,89.33) v2(199.58,77.36) v2(200.16,89.33) v2(200.5,43.46) v2(200.51,71.55) v2(201.37,13.1) v2(202.26,13.1) v2(202.44,76.65) v2(203.07,76.65) v2(203.15,13.1) v2(203.74,76.63) v2(204.04,13.1) v2(204.92,13.1) v2(205.56,89.27) v2(205.69,13.1) v2(205.83,95.65) v2(206.17,89.27) v2(206.45,13.1) v2(206.78,89.27) v2(206.93,0.45) v2(213.45,95.65) v2(214.55,0.45) v2(219.36,80.77) v2(221.07,95.65) v2(222.04,41.09) v2(222.17,0.45) v2(222.79,50.4) v2(223.2,44.78) v2(223.38,41.03) v2(223.52,90.86) v2(223.69,34.77) v2(224.91,89.88) v2(224.91,33.96) v2(225.1,44.79) v2(225.25,41.01) v2(225.56,36.61) v2(225.74,61.67) v2(225.76,54.13) v2(226.1,49.84) v2(226.01,42.27) v2(226.15,35.22) v2(226.21,89.88) v2(226.27,61.11) v2(226.24,57.64) v2(226.48,41.03) v2(226.44,37.5) v2(226.59,28.36) v2(226.95,44.77) v2(227.37,56.17) v2(227.35,53.15) v2(227.39,31.88) v2(227.44,49.83) v2(227.41,33.58) v2(227.56,59.77) v2(227.59,47.39) v2(227.6,26.28) v2(227.75,36.82) v2(227.8,42.23) v2(227.94,29.7) v2(228.69,95.65) v2(228.64,54.8) v2(228.8,34.86) v2(228.77,33.27) v2(228.87,52.32) v2(228.87,44.78) v2(228.88,40.37) v2(228.97,27.56) v2(229.05,58.23) v2(229.21,61.23) v2(229.26,31.03) v2(229.48,47.4) v2(229.45,37.22) v2(229.79,0.45) v2(230.33,28.94) v2(231.11,25.37) v2(232.05,25.21) v2(232.44,24.17) v2(233.22,86.48) v2(233.28,25.09) v2(235.8,71.32) v2(236.24,25.37) v2(236.31,95.65) v2(236.78,81.5) v2(236.95,82.39) v2(237.06,71.29) v2(237.31,25.41) v2(237.33,23.53) v2(237.41,0.45) v2(238.38,82.56) v2(240.87,82.59) v2(241.44,55.17) v2(241.63,81.47) v2(241.82,59.32) v2(241.81,50.5) v2(241.88,46.62) v2(241.91,38.36) v2(242.26,55.13) v2(242.55,80.37) v2(242.55,46.62) v2(242.69,50.48) v2(242.8,38.39) v2(242.95,81.17) v2(243.17,46.62) v2(243.28,55.13) v2(243.34,59.32) v2(243.41,39.68) v2(243.41,39.03) v2(243.51,50.48) v2(243.53,17.16) v2(243.69,38.41) v2(243.76,79.44) v2(243.89,46.62) v2(243.93,95.65) v2(243.96,81.14) v2(244.17,55.13) v2(244.37,38.34) v2(244.45,50.46) v2(244.72,46.61) v2(244.8,59.32) v2(245.08,38.32) v2(245.03,0.45) v2(245.31,55.13) v2(245.36,50.48) v2(245.49,46.61) v2(245.69,79.31) v2(245.87,81.08) v2(245.82,38.34) v2(246.09,50.46) v2(246.2,59.32) v2(246.14,46.6) v2(246.45,55.13) v2(246.56,38.34) v2(246.89,81.24) v2(246.9,50.47) v2(247.09,59.32) v2(247.03,46.62) v2(247.29,38.37) v2(247.47,55.13) v2(247.58,43.34) v2(247.58,41.71) v2(247.62,79.31) v2(247.61,40.38) v2(247.67,2.63) v2(247.77,50.49) v2(247.74,47) v2(247.95,81.22) v2(247.98,59.32) v2(248.03,1.13) v2(248.36,38.38) v2(248.49,55.13) v2(248.44,40.31) v2(248.53,50.49) v2(248.51,46.97) v2(248.51,4.36) v2(248.87,59.32) v2(249.07,81.32) v2(249.15,38.36) v2(249.29,50.5) v2(249.21,46.99) v2(249.45,40.31) v2(249.5,55.13) v2(250.06,46.97) v2(250.19,81.37) v2(250.1,50.5) v2(250.29,79.57) v2(250.58,55.13) v2(250.64,4.71) v2(250.77,46.99) v2(250.82,42.61) v2(250.82,41.65) v2(251.46,70.35) v2(251.49,41.13) v2(251.55,95.65) v2(251.51,1.03) v2(251.71,38.15) v2(252.17,3.16) v2(252.3,79.69) v2(252.68,81.55) v2(252.6,69.79) v2(252.96,0.46) v2(253.74,71.98) v2(256,72.89) v2(256.96,69.48) v2(257.86,70.73) v2(259.17,95.65) v2(259.17,68.68) v2(259.35,70.14) v2(260.27,0.45) v2(260.86,63.36) v2(261.44,93.94) v2(262.1,93.97) v2(262.42,65.37) v2(262.88,63.85) v2(262.9,70.31) v2(263.6,70.31) v2(264.87,93.72) v2(265.58,93.73) v2(266.79,95.65) v2(267.32,55.93) v2(267.31,52.03) v2(267.89,0.45) v2(267.91,31.56) v2(268.04,43.05) v2(268.14,55.93) v2(268.13,52.03) v2(268.17,47.56) v2(268.63,60.39) v2(268.76,52.03) v2(268.73,43.03) v2(268.71,30.78) v2(268.81,55.95) v2(268.86,47.54) v2(268.91,17.49) v2(268.96,16.88) v2(269.39,43.06) v2(269.35,30.22) v2(269.45,55.94) v2(269.43,52.08) v2(269.49,17.52) v2(269.52,47.57) v2(269.57,16.83) v2(269.78,60.39) v2(269.94,29.57) v2(270.1,55.95) v2(270.1,52.04) v2(270.02,43.05) v2(270.15,47.56) v2(270.6,28.93) v2(271.02,60.39) v2(271.24,28.26) v2(271.88,27.58) v2(272.27,60.39) v2(272.91,71.43) v2(273.25,69.42) v2(273.49,71.43) v2(273.52,60.39) v2(273.82,71.99) v2(274.13,71.43) v2(274.41,95.65) v2(275.51,0.45) v2(278.84,60.8) v2(278.84,60.21) v2(278.84,59.63) v2(278.84,54.37) v2(278.97,45.35) v2(278.97,44.72) v2(278.97,43.96) v2(279.09,55.01) v2(279.47,60.8) v2(279.47,60.21) v2(279.47,59.63) v2(279.6,45.35) v2(279.6,44.72) v2(279.6,43.96) v2(279.73,54.37) v2(279.85,55.01) v2(280.12,70.23) v2(280.12,69.52) v2(280.11,60.8) v2(280.11,60.21) v2(280.11,59.63) v2(280.24,45.35) v2(280.24,44.72) v2(280.24,43.96) v2(280.49,50.81) v2(280.49,50.18) v2(280.49,49.54) v2(280.75,70.23) v2(280.75,69.52) v2(280.72,60.82) v2(280.72,60.24) v2(280.72,59.65) v2(280.77,31.46) v2(280.77,30.83) v2(280.77,30.19) v2(280.77,29.56) v2(280.87,41.54) v2(280.87,40.91) v2(280.87,40.27) v2(281.12,50.81) v2(281.12,50.18) v2(281.12,49.54) v2(281.3,60.82) v2(281.3,60.24) v2(281.3,59.65) v2(281.46,70.28) v2(281.46,69.57) v2(281.4,31.46) v2(281.4,30.83) v2(281.4,30.19) v2(281.4,29.56) v2(281.51,41.54) v2(281.51,40.91) v2(281.51,40.27) v2(281.63,20.84) v2(281.63,20.21) v2(281.63,19.57) v2(281.76,50.81) v2(281.76,50.18) v2(281.76,49.54) v2(281.89,60.85) v2(281.89,60.26) v2(281.89,59.68) v2(281.95,51.39) v2(282.03,95.65) v2(282.1,70.28) v2(282.1,69.57) v2(282.04,31.46) v2(282.04,30.83) v2(282.04,30.19) v2(282.04,29.56) v2(282.14,41.54) v2(282.14,40.91) v2(282.14,40.27) v2(282.27,20.84) v2(282.27,20.21) v2(282.27,19.57) v2(282.39,50.81) v2(282.39,50.18) v2(282.39,49.54) v2(282.47,60.87) v2(282.47,60.29) v2(282.47,59.7) v2(282.57,51.39) v2(282.67,31.46) v2(282.67,30.83) v2(282.67,30.19) v2(282.67,29.56) v2(282.74,70.24) v2(282.75,69.56) v2(282.78,41.54) v2(282.78,40.91) v2(282.78,40.27) v2(282.9,20.84) v2(282.9,20.21) v2(282.9,19.57) v2(283.06,60.87) v2(283.06,60.29) v2(283.06,59.7) v2(283.03,50.81) v2(283.03,50.18) v2(283.03,49.54) v2(283.16,51.39) v2(283.13,0.45) v2(283.38,69.58) v2(283.31,30.83) v2(283.31,30.19) v2(283.31,29.56) v2(283.45,70.59) v2(283.41,41.54) v2(283.41,40.91) v2(283.41,40.27) v2(283.54,20.84) v2(283.54,20.21) v2(283.54,19.57) v2(283.64,60.87) v2(283.64,60.29) v2(283.64,59.7) v2(283.66,50.81) v2(283.66,50.18) v2(283.66,49.54) v2(283.79,51.5) v2(284.05,41.54) v2(284.05,40.91) v2(284.05,40.27) v2(284.07,30.83) v2(284.07,30.19) v2(284.07,29.56) v2(284.12,70.73) v2(284.12,70.08) v2(284.15,68.81) v2(284.15,67.52) v2(284.15,66.22) v2(284.17,20.84) v2(284.17,20.21) v2(284.17,19.57) v2(284.3,60.97) v2(284.3,51.2) v2(284.3,50.56) v2(284.3,49.93) v2(284.3,49.29) v2(284.33,60.31) v2(284.33,59.73) v2(284.5,65.37) v2(284.68,41.54) v2(284.68,40.91) v2(284.68,40.27) v2(284.74,70.73) v2(284.87,70.06) v2(284.86,69.36) v2(284.88,49.32) v2(284.83,30.83) v2(284.83,30.19) v2(284.83,29.56) v2(284.96,60.31) v2(284.96,59.73) v2(284.93,51.2) v2(284.93,50.56) v2(284.93,49.93) v2(284.93,20.84) v2(284.93,20.21) v2(284.93,19.57) v2(285.32,41.54) v2(285.32,40.91) v2(285.32,40.27) v2(285.49,60.76) v2(285.44,31.13) v2(285.44,30.49) v2(285.44,29.86) v2(285.44,29.22) v2(285.44,28.59) v2(285.55,60.17) v2(285.57,51.2) v2(285.57,50.56) v2(285.57,49.93) v2(285.6,49.32) v2(285.7,20.77) v2(285.7,20.13) v2(285.7,19.5) v2(285.7,18.86) v2(285.71,68.81) v2(285.71,67.52) v2(285.71,66.22) v2(285.98,58.81) v2(285.98,57.51) v2(285.98,56.21) v2(285.95,41.54) v2(285.95,40.91) v2(285.95,40.27) v2(285.95,39.64) v2(286.08,71.64) v2(286.08,48.06) v2(286.08,46.77) v2(286.08,45.47) v2(286.08,38.33) v2(286.08,37.04) v2(286.08,35.74) v2(286.06,27.29) v2(286.06,25.99) v2(286.06,24.69) v2(286.08,17.58) v2(286.08,16.29) v2(286.08,14.99) v2(286.13,60.79) v2(286.15,60.19) v2(286.2,51.2) v2(286.2,50.56) v2(286.2,49.93) v2(286.28,49.32) v2(286.33,55.36) v2(286.33,31.13) v2(286.33,30.49) v2(286.33,29.86) v2(286.33,29.22) v2(286.33,28.59) v2(286.33,20.77) v2(286.33,20.13) v2(286.33,19.5) v2(286.33,18.86) v2(286.43,44.62) v2(286.43,34.89) v2(286.4,23.84) v2(286.43,14.14) v2(286.59,41.54) v2(286.59,40.91) v2(286.59,40.27) v2(286.59,39.64) v2(286.69,59.36) v2(286.79,48.61) v2(286.79,38.88) v2(286.76,27.84) v2(286.79,18.13) v2(286.84,71.64) v2(286.86,65.84) v2(286.84,51.2) v2(286.84,50.56) v2(286.84,49.93) v2(286.87,49.32) v2(286.97,20.77) v2(286.97,20.13) v2(286.97,19.5) v2(286.97,18.86) v2(287.11,92.16) v2(287.22,41.54) v2(287.22,40.91) v2(287.22,40.27) v2(287.22,39.64) v2(287.47,53.74) v2(287.54,58.81) v2(287.54,57.51) v2(287.54,56.21) v2(287.64,48.06) v2(287.64,46.77) v2(287.64,45.47) v2(287.64,38.33) v2(287.64,37.04) v2(287.64,35.74) v2(287.62,27.29) v2(287.62,25.99) v2(287.62,24.69) v2(287.6,20.77) v2(287.6,20.13) v2(287.6,19.5) v2(287.6,18.86) v2(287.64,17.58) v2(287.64,16.29) v2(287.64,14.99) v2(287.73,71.64) v2(287.73,50.78) v2(287.89,30.98) v2(287.89,30.34) v2(287.89,29.71) v2(287.89,29.07) v2(287.89,28.44) v2(288.24,41.29) v2(288.36,71.64) v2(288.49,50.78) v2(288.69,55.84) v2(288.79,45.09) v2(288.79,35.36) v2(288.76,24.31) v2(288.79,14.61) v2(289,41.29) v2(289.25,20.42) v2(289.38,50.78) v2(289.65,95.65) v2(289.75,93.31) v2(289.76,41.29) v2(289.9,20.39) v2(290.14,50.78) v2(290.4,41.29) v2(290.52,20.42) v2(290.75,0.45) v2(291.16,20.42) v2(291.88,65.93) v2(291.84,65.19) v2(291.84,64.51) v2(291.81,20.38) v2(292.06,93.3) v2(292.45,20.38) v2(293.17,85.69) v2(293.19,21.88) v2(293.7,89.75) v2(293.95,92.06) v2(294.28,45.05) v2(294.23,44.24) v2(294.26,43.4) v2(294.9,84.92) v2(296.24,88.48) v2(296.84,85.35) v2(297.2,81.21) v2(297.2,78.67) v2(297.27,95.65) v2(297.76,73.8) v2(298.07,92.04) v2(298.07,89.8) v2(298.37,0.45) v2(298.51,81.21) v2(298.83,84.95) v2(298.88,73.98) v2(299.82,81.21) v2(299.82,78.67) v2(300.25,72.99) v2(300.56,26.91) v2(300.78,18.81) v2(300.78,18.05) v2(300.78,17.28) v2(300.78,16.52) v2(301.04,74.01) v2(301.13,81.21) v2(301.13,78.67) v2(301.34,26.91) v2(301.44,72.28) v2(301.7,69.48) v2(302.05,72.3) v2(302.11,26.89) v2(302.31,86.93) v2(303.07,94.96) v2(303.15,42.55) v2(304.99,83.43) v2(305.27,76.98) v2(305.72,81.6) v2(305.88,85.55) v2(305.99,0.45) v2(306,13.43) v2(306.61,80.04) v2(306.7,81.47) v2(306.74,13.48) v2(306.85,14.96) v2(307.08,74.82) v2(307.27,26.43) v2(307.27,25.85) v2(307.34,76.55) v2(307.86,26.43) v2(307.86,25.85) v2(308.71,84.7) v2(310.02,20.17) v2(310.42,35.24) v2(311.26,20.72) v2(311.57,19.21) v2(311.96,21.81) v2(311.98,20.67) v2(312.09,22.9) v2(312.87,59.27) v2(312.87,57.6) v2(313.09,28.15) v2(313.08,3.37) v2(313.1,5.43) v2(313.29,24.25) v2(313.26,21.81) v2(313.46,57.6) v2(313.51,59.27) v2(313.61,0.45) v2(313.77,3.4) v2(313.87,29.94) v2(313.86,5.46) v2(313.93,52.12) v2(313.93,50.99) v2(313.92,26.74) v2(314.09,49.15) v2(314.06,45.94) v2(314.04,45.29) v2(314.14,59.27) v2(314.12,47.98) v2(314.27,54.62) v2(314.42,3.4) v2(314.53,58.71) v2(314.53,58.13) v2(314.56,24.28) v2(314.78,59.27) v2(314.82,5.41) v2(314.99,28.46) v2(315.08,76.86) v2(315.1,30.41) v2(315.01,27.04) v2(315.04,3.39) v2(315.16,58.71) v2(315.16,58.13) v2(315.12,31.43) v2(315.12,25.41) v2(315.39,59.27) v2(315.63,5.45) v2(315.7,3.43) v2(315.72,72.58) v2(315.75,58.74) v2(315.75,58.16) v2(316.32,3.4) v2(316.48,5.39) v2(316.66,71.9) v2(316.68,70.75) v2(316.91,3.48) v2(317.35,58.31) v2(317.42,70.75) v2(317.5,5.4) v2(317.83,58.72) v2(318.47,5.42) v2(320.11,6.87) v2(320.7,17.4) v2(321.1,13.67) v2(321.23,0.45) v2(322.2,18.09) v2(322.43,64.91) v2(322.63,19.17) v2(322.72,6.36) v2(323.29,17.95) v2(323.8,62.63) v2(324.1,66.87) v2(324.58,17.36) v2(324.66,68.82) v2(325.54,41.33) v2(325.7,17.31) v2(326.16,66.64) v2(326.18,62.63) v2(327.05,64.53) v2(327.49,41.44) v2(328.85,0.45) v2(329.99,22.56) v2(330.16,13.88) v2(330.27,38.88) v2(330.27,37.35) v2(330.24,23.73) v2(330.24,23.1) v2(330.72,58.75) v2(330.85,12.38) v2(330.91,37.35) v2(331.04,38.88) v2(331.3,58.75) v2(331.59,31.46) v2(331.59,30.87) v2(331.89,58.75) v2(331.82,51.34) v2(331.94,53.15) v2(331.94,52.55) v2(331.99,51.97) v2(332.18,31.46) v2(332.18,30.87) v2(333.09,19.83) v2(334.42,13.44) v2(334.9,1.26) v2(335.54,1.26) v2(335.76,62.88) v2(336.24,1.26) v2(336.32,0.47) v2(338.86,11.01) v2(339.55,10.96) v2(340.26,11) v2(344.09,0.45) v2(344.68,60.03) v2(346.36,40.72) v2(346.46,41.38) v2(347.09,41.41) v2(347.07,40.72) v2(347.03,39.95) v2(347.68,40.7) v2(347.63,39.98) v2(347.8,41.42) v2(348.4,39.98) v2(348.44,40.7) v2(348.56,41.42) v2(349.08,40.7) v2(349.03,39.98) v2(349.2,41.42) v2(350.97,58.95) v2(351.69,3.14) v2(351.71,4.43) v2(351.71,3.82) v2(351.71,0.45) v2(355,42.17) v2(358.41,0.56) v2(360.18,58.95) v2(364.06,47.06) v2(364.07,25.28) v2(365.25,23.46) v2(366,25.25) v2(366.81,22.87) v2(367.48,38.11) v2(367.59,19.78) v2(367.71,45.16) v2(367.87,38.62) v2(368.06,59.53) v2(368.2,26.06) v2(368.34,45.15) v2(368.5,22.82) v2(368.6,19.75) v2(368.92,45.15) v2(369.23,38.11) v2(369.53,20.42) v2(369.81,38.58) v2(369.91,23.05) v2(370.53,21.59) v2(370.77,25.97) v2(371.12,29.78) v2(371.63,24.08) v2(374.9,50.8) v2(374.96,54.57) v2(374.93,52.81) v2(375.14,61.37) v2(377.76,29.69) v2(377.9,41.88) v2(377.96,45.08) v2(378.13,43.51) v2(378.45,29.71) v2(378.72,37.24) v2(379.71,35.76) v2(379.76,23.01) v2(379.76,21.05) v2(379.85,55.76) v2(379.85,54.64) v2(379.85,53.52) v2(380.97,55.76) v2(380.97,54.64) v2(380.97,53.52) v2(381.62,36.22) v2(381.73,23.01) v2(381.73,21.05) v2(382.09,55.76) v2(382.09,54.64) v2(382.09,53.52) v2(382.24,36.85) v2(382.24,35.6) v2(382.86,36.22) v2(382.96,56.9) v2(383.21,65.15) v2(383.41,45.09) v2(383.41,43.97) v2(383.41,42.85) v2(383.64,60.72) v2(383.64,59.48) v2(383.7,24.98) v2(383.7,23.01) v2(383.7,21.05) v2(384.26,60.1) v2(384.53,45.09) v2(384.53,43.97) v2(384.53,42.85) v2(384.62,57.57) v2(385.26,11.34) v2(385.64,45.09) v2(385.64,43.97) v2(385.64,42.85) v2(386.06,2.34) v2(388.93,69.25) v2(389.86,3.24) v2(390.78,1.23) v2(390.85,4.71) v2(391.87,55.89) v2(392.5,55.89) v2(392.55,20.64) v2(392.63,30.75) v2(392.63,30.11) v2(392.81,20.11) v2(393.14,73.32) v2(393.47,29.21) v2(393.57,1.16) v2(393.9,29.68) v2(393.93,4.76) v2(394.29,29.12) v2(394.49,3.39) v2(394.83,17.13) v2(395.3,16.78) v2(396.17,53.7) v2(396.13,45.96) v2(396.41,4.47) v2(397.36,13.95) v2(397.94,13.95) v2(398.52,13.95) v2(400.22,8.74) v2(400.8,41.9) v2(400.83,39.68) v2(400.9,37.52) v2(400.9,33.71) v2(400.86,31.55) v2(400.91,76.58) v2(400.92,45.33) v2(400.99,35.58) v2(401.22,67.02) v2(401.25,64.8) v2(401.28,56.67) v2(401.32,62.64) v2(401.32,58.83) v2(401.47,75.28) v2(401.41,60.7) v2(401.52,72.86) v2(403.19,41.77) v2(403.22,39.55) v2(403.28,37.39) v2(403.28,33.58) v2(403.25,31.42) v2(403.38,35.45) v2(403.6,76.37) v2(403.61,66.89) v2(403.64,64.67) v2(403.67,56.54) v2(403.7,62.51) v2(403.8,60.57) v2(403.7,58.7) v2(404.42,71.69) v2(404.43,53.81) v2(404.95,62.73) v2(404.95,57.89) v2(404.96,40.97) v2(404.96,34.57) v2(405.76,75.48) v2(405.97,73.24) v2(407.26,9.4) v2(407.81,67.57) v2(407.87,28.64) v2(407.9,15.56) v4(9.62,15.09) v4(26.81,20.51) v4(59,8.57) v4(60.08,8.45) v4(65.91,43.54) v4(68.78,43.88) v4(70.42,52.38) v4(73.42,11.47) v4(99.4,2.54) v4(120.08,85.21) v4(130.02,158.7) v4(131.38,11.2) v4(138.28,117.99) v4(139.47,94.13) v4(142.34,86.77) v4(150.95,98.57) v4(153.95,3.51) v4(165.64,117.39) v4(166.32,136.57) v4(171.08,91.77) v4(199.63,91) v4(269.42,30.85) v4(279.98,61.98) v4(283.07,72.81) v4(284.62,72.56) v4(284.93,61.88) v4(286.88,21.49) v4(301.22,69.99) v4(306.41,26.29) v4(315.96,4.32) v4(331.07,38.1) v4(331.54,57.93) v4(332.76,30.22) v4(345.58,40.9) v4(389.41,55.32)
