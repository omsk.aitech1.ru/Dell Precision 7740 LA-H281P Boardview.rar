# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_N14: length 119.4
  TOP w0.102: v2(142.92,46.48) 143.03,46.37 UH1.E5
  IN4 w0.102: v2(142.92,46.48) 142.92,45.89 142.83,45.81 142.83,45.6 143.27,45.16 143.27,43.26 141.79,41.78 141.29,41.78 141.08,41.57 139.08,41.57 138.67,41.99 138.67,42.97 138.16,43.47 137.92,43.47 137.51,43.88 137.51,44.95 137.26,45.2 135.84,45.2 135.58,44.95 133.3,44.95 132.31,45.94 131.96,45.94 131.71,46.19 130.22,46.19 129.48,46.94 127.48,46.94 125.33,49.09 125.33,49.95 123.34,51.95 122.42,51.95 121.47,52.89 121.47,57.39 120.03,58.83 118.05,58.83 116.76,60.11 112.48,60.11 111.39,61.2 111.39,62 108.91,64.48 108.91,69.64 108.38,70.17 108.38,74.04 111.99,77.64 111.99,79.08 116.93,84.02 116.93,84.44 123.52,91.02 123.52,96.95 122.82,97.64 122.82,98.55 123.78,99.5 123.78,103.33 122.78,104.33 121.89,104.33 121.18,105.04 113.75,105.04 v2(113.55,105.24)
  BOTTOM w0.102: RI49.1 111.74,100.84 L1.1 111.58,100.17 111.44,100.03 111.33,100.03 111.27,99.97 111.27,99.8 111.42,99.65 112.26,99.65 112.66,100.04 112.66,100.55 112.7,100.59 112.7,104.64 112.98,104.92 113.22,104.92 v2(113.55,105.24)
USB20_N14_R: length 3.5
  BOTTOM w0.102: RI49.2 111.74,101.75 L1.2 111.58,102.43 111.4,102.61 111.4,102.94 111.6,103.14 111.6,103.79 111.75,103.95 JNGFF1.5
USB20_NA: length 36.9
  IN2 w0.094: v2(21.03,29.31) 21.03,29.61 20.84,29.8 20.65,29.8 20.38,29.53 20.38,28.87 21.28,27.97 24.51,27.97 25.41,27.07 26.73,27.07 27.25,27.6 27.25,31.23 25.63,32.86 25.63,34.2 25.99,34.57 28.15,34.57 29.19,33.53 32.17,33.53 34.54,35.91 34.54,41.67 34.3,41.91 34.3,43.46 34.14,43.62 33.95,43.62 33.84,43.73 v2(33.84,43.94)
  BOTTOM w0.102: v2(33.84,43.94) UT1.D20 ; v2(21.03,29.31) 20.91,29.2 RT562.2
USB20_NB: length 23.2
  IN2 w0.094: v2(33.83,44.58) 33.68,44.72 33.68,44.89 33.78,44.98 34.31,44.98 34.4,45.06 34.4,45.2 34.27,45.32 33.52,45.32 33.17,44.97 33.17,41.22 30.25,38.3 29.18,38.3 28.17,37.29 27.78,36.9 27.78,35.38 27.39,35 25.94,35 25.89,35.05 24.46,35.05 24.03,34.61 23.14,34.61 22.97,34.45 22.97,33.84 23.21,33.6 23.5,33.6 23.59,33.69 23.59,33.84 v2(23.39,34.04)
  BOTTOM w0.102: v2(33.83,44.58) UT1.D19 ; RT558.1 23.45,33.97 v2(23.39,34.04)
USB20_P1: length 307.4
  TOP w0.076: 141.7,49.9 141.69,49.89 141.69,49.86 141.38,49.56 141.38,48.18 141.32,48.12 141.15,48.12 141.08,48.05 141.08,47.86 141.19,47.75 141.25,47.75 UH1.J2
  TOP w0.102: UI1.3 383.89,58.26 383.76,58.13 383.76,57.71 v2(384.03,57.43) ; 141.7,49.9 141.8,50.01 141.8,51.04 141.99,51.23 142.24,51.23 v2(142.47,51.45)
  IN2 w0.094: v2(142.47,51.45) 142.28,51.27 142.08,51.27 141.8,50.99 141.8,49.49 142.98,48.31 144.66,48.31 145.23,47.73 150.48,47.73 157.89,40.32 157.89,32.19 159.27,30.81 159.27,21.23 163.67,16.83 163.67,14.74 171.59,6.81 243.58,6.81 246.23,9.46 254.93,9.46 256.51,7.88 292.82,7.88 295.81,10.87 307.37,10.87 316.22,19.72 316.22,19.99 321.2,24.97 336.75,24.97 345.93,34.14 351.77,34.14 356.69,39.06 366.54,39.06 369.59,42.11 369.59,50.44 375.35,56.2 383.21,56.2 383.76,56.75 383.76,57.16 v2(384.03,57.43)
USB20_P1_R: length 21
  TOP w0.102: JUSB1.3 396.42,62.05 396.53,61.94 396.85,61.94 397.59,62.68 397.59,66.1 396.61,67.08 v3(392.03,67.08) 390.71,67.08 390.61,66.98 390.61,66.3 390.58,66.26 390.58,64.57 390.1,64.1 389.56,64.1 389.43,63.96 DI2.3 388.56,63.94 388.23,63.94 387.91,63.62 387.72,63.62 387.56,63.47 LI3.1
USB20_P2: length 283.8
  TOP w0.102: UH1.N15 v2(140.05,42.05) ; UI2.3 380.37,35.97 380.22,36.13 380.04,36.13 379.79,36.38 379.47,36.38 v2(379.21,36.12)
  IN2 w0.094: v2(140.05,42.05) 139.74,42.05 139.61,42.18 139.61,42.34 139.77,42.5 139.87,42.6 141.86,42.6 142.52,41.94 143.27,41.94 146.44,38.77 146.91,38.77 147.48,38.2 147.48,37.84 152.85,32.46 152.85,25.45 153.23,25.07 153.23,23.32 155.01,21.54 155.01,19.13 170.45,3.7 245.09,3.7 247.74,6.34 253.31,6.34 256.46,3.19 269.14,3.19 269.83,2.5 302.33,2.5 307.45,7.62 310.32,7.62 322.72,20.02 326.81,20.02 328.01,18.81 333.08,18.81 335.06,20.79 337.36,20.79 347.51,30.94 353.41,30.94 355.86,33.39 371.18,33.39 372.82,35.03 374.49,35.03 376.14,36.68 378.28,36.68 378.51,36.45 379.1,36.45 379.21,36.34 v2(379.21,36.12)
USB20_P2_R: length 21.9
  TOP w0.102: JUSB2.3 396.42,37.26 396.75,36.93 397.52,36.93 397.76,37.17 397.76,41.12 396.86,42.02 393.65,42.02 v3(391.99,40.36) 390.97,39.34 390.97,39.29 390.51,38.83 390.51,37.35 389.8,36.64 389.3,36.64 389.2,36.53 DI3.3 388.33,36.64 387.59,36.64 387.43,36.48 LI4.1
USB20_P3: length 134.9
  TOP w0.076: UH1.K3 140.97,47.22 141.03,47.17 141.08,47.17 141.18,47.26 141.18,47.52 140.91,47.78 140.91,48.11 140.93,48.13 140.93,48.15
  TOP w0.102: UI3.3 116.55,148.85 116.41,148.7 116.41,148.6 v2(116.67,148.34) ; 140.93,48.15 140.93,48.39 141.12,48.58 141.12,49.85 141.47,50.2 141.47,50.68 141.28,50.87 140.99,50.87 v2(140.82,51.05)
  IN4 w0.102: v2(140.82,51.05) 140.82,50.78 140.73,50.69 140.51,50.69 140.39,50.82 140.39,51.3 141.63,52.54 143,52.54 143.32,52.86 143.32,54.23 143.86,54.77 145.17,54.77 149.11,58.71 150.22,58.71 151.79,60.28 151.79,61.79 151.06,62.51 151.06,63.17 151.61,63.72 151.61,70.04 151.86,70.3 151.86,73.38 151.08,74.17 151.08,80.09 149.95,81.22 149.95,82.89 149.32,83.52 149.32,84.1 147,86.42 144.73,86.42 143.94,87.21 140.75,87.21 139.8,88.16 136.65,88.16 128.99,95.82 128.99,97.22 128.38,97.83 128.38,99.42 126.78,101.02 126.78,105.05 126.96,105.22 126.96,107.96 126.16,108.76 126.16,111.83 127.15,112.81 127.15,114.12 122.53,118.73 122.53,120.92 122.18,121.27 122.18,128.21 114.75,135.64 114.75,139.14 117.29,141.68 117.29,146.51 116.29,147.52 116.29,147.96 v2(116.67,148.34)
USB20_P3_R: length 14.2
  TOP w0.102: v2(118.83,160.93) 118.57,160.67 118.57,159.55 119.83,158.29 119.83,157.79 119.93,157.69 DI5.3 119.83,156.82 119.83,155.99 119.98,155.84 LI7.1
  BOTTOM w0.102: v2(118.83,160.93) 118.64,160.73 118.64,160.56 118.76,160.44 119.52,160.44 120.53,161.45 120.53,163.33 119.94,163.92 JUSB3.3
USB20_P4: length 162.5
  TOP w0.102: v2(140.23,45.35) 140.63,44.96 UH1.L9
  IN2 w0.094: v2(19.95,25.68) 20.34,25.68 20.44,25.78 20.44,26.2 20.81,26.57 23.77,26.57 24.22,26.12 27.62,26.12 28.42,26.92 28.42,29.75 28.14,30.03 28.14,31.47 28.71,32.04 42.01,32.04 42.96,31.09 47.23,31.09 51.6,26.72 52.02,26.72 54.34,24.39 58.96,24.39 60.72,22.64 60.72,21.92 63.07,19.57 65.46,19.57 66.85,20.95 67.64,20.95 68.29,21.6 71.61,21.6 72.76,22.75 75.93,22.75 79.76,26.58 82.5,26.58 84.35,28.43 84.95,28.43 87.58,31.06 88.13,31.06 90.28,33.21 91.96,33.21 92.1,33.35 93.24,33.35 96.41,36.52 96.41,41.06 100.22,44.87 100.22,50.15 101.55,51.48 105.54,51.48 106.4,52.34 110.72,52.34 111.59,53.22 114.13,53.22 115.32,54.4 116.87,54.4 117.45,53.82 120.58,53.82 122.43,51.98 126.42,51.98 126.64,51.75 128.1,51.75 128.5,51.35 128.5,48.52 128.88,48.14 132.37,48.14 132.94,47.57 138.19,47.57 138.53,47.92 139.53,47.92 140.29,47.15 140.29,46.47 139.62,45.79 139.62,45.44 139.81,45.25 140.13,45.25 v2(140.23,45.35)
  BOTTOM w0.102: RT559.2 20.31,26.51 20.31,26.04 v2(19.95,25.68)
USB20_P5: length 149.5
  TOP w0.102: UH1.L2 140.21,48.05 140.02,48.24 140.02,48.78 v2(140.33,49.09)
  IN2 w0.094: v2(26.63,33.25) 26.92,33.54 28.05,33.54 29.03,32.56 36.22,32.56 36.97,33.31 41.25,33.31 43.05,35.11 46.64,35.11 47.44,34.3 48.4,34.3 50.88,31.82 52.63,31.82 53.8,30.66 54.5,30.66 61.69,23.47 61.69,22.14 62.22,21.6 62.6,21.6 64.06,20.14 65.08,20.14 68.39,23.46 69.29,23.46 70.64,24.81 71.94,24.81 72.38,24.37 76.61,24.37 79.24,27 82.24,27 84.13,28.89 84.53,28.89 87.53,31.89 88.4,31.89 90.26,33.75 90.7,33.75 93.28,36.33 95.43,36.33 95.84,36.74 95.84,41.06 99.82,45.04 99.82,50.31 101.39,51.88 105.34,51.88 106.46,53 110.34,53 111.17,53.82 113.65,53.82 114.93,55.1 121.09,55.1 121.25,55.26 126.37,55.26 129.9,51.73 130.32,51.73 130.99,51.06 130.99,50.24 133.19,48.04 137.71,48.04 138.57,48.9 139.39,48.9 139.79,49.31 140.11,49.31 v2(140.33,49.09)
  BOTTOM w0.102: RT555.1 26.1,33.49 26.38,33.49 v2(26.63,33.25)
USB20_P6: length 1.6
  TOP w0.109: v2(141.79,45.73) 141.5,46.03 UH1.K6
  BOTTOM w0.109: v2(141.79,45.73) 141.74,45.73 T314.1
USB20_P8: length 77.6
  TOP w0.076: v2(143.87,50.67) 143.83,50.63 143.83,50.55 143.76,50.47 143.41,50.47 142.69,49.76 142.69,49.54 142.15,49 142.15,48.36 142.33,48.18 142.33,47.35 142.18,47.2 142.18,46.95 142.4,46.72 UH1.G5
  IN1 w0.102: v2(146.61,108.59) 146.89,108.31 146.89,107.43 150.95,103.36 150.95,96.4 150.23,95.67 150.23,76.55 148.48,74.79 148.48,73.28 148.86,72.89 148.86,72.64 148.42,72.19 148.42,71.79 148.71,71.5 149.11,71.5 149.86,72.24 150.11,72.24 150.29,72.06 150.29,71.81 149.55,71.07 149.55,70.66 149.84,70.37 150.24,70.37 150.69,70.81 150.94,70.81 151.35,70.41 151.35,68.36 151.78,67.93 151.78,64.73 152.17,64.34 152.17,59.69 144.38,51.9 144.38,50.53 144.17,50.32 144.02,50.32 143.87,50.47 v2(143.87,50.67)
  BOTTOM w0.102: JNGFF2.7 146.74,107.72 146.88,107.87 146.88,108.32 v2(146.61,108.59)
USB20_P10: length 260.9
  TOP w0.076: 142.21,49.38 142.2,49.36 142.17,49.36 141.85,49.05 141.85,48.28 141.9,48.23 141.98,48.23 142.06,48.16 142.06,47.98 UH1.H2
  TOP w0.102: 142.21,49.38 142.46,49.63 142.46,49.78 143.05,50.37 143.05,51.26 143.37,51.58 143.54,51.58 143.62,51.5 v2(143.62,51.27) ; JUSH1.18 334.68,55.05 334.59,55.14 334.59,55.26 334.49,55.36 334.38,55.36 333.56,54.54 332.16,54.54 330.79,53.17 330.79,46.02 v3(327.4,42.63) 326.55,41.78 326.55,41.57 326.75,41.37 v2(326.89,41.37)
  IN2 w0.094: v2(326.89,41.37) 326.58,41.06 326.58,40.77 326.15,40.34 323.03,40.34 321.71,39.01 321.71,28.22 313.91,20.42 313.91,18.31 307.06,11.47 295.56,11.47 292.68,8.58 256.88,8.58 255.4,10.06 245.53,10.06 242.97,7.5 171.84,7.5 166.59,12.75 166.59,13.66 164.32,15.93 164.32,17.05 159.87,21.51 159.87,31.18 158.98,32.06 158.98,40.17 150.56,48.59 149.1,48.59 146.48,51.21 145.3,51.21 144.93,51.58 143.69,51.58 143.62,51.51 v2(143.62,51.27)
USB20_P11: length 98.6
  TOP w0.102: v2(130.64,112.52) 130.24,112.52 130.16,112.59 130.16,113.1 130.37,113.31 LV2.4 ; v2(139.61,44.42) 139.23,44.42 139.18,44.47 UH1.P9
  IN4 w0.102: v2(130.64,112.52) 130.29,112.52 129.63,113.17 128.97,113.17 127.27,111.47 127.27,108.88 128.36,107.78 128.36,104.76 127.26,103.65 127.26,101.12 128.83,99.55 128.83,98.17 133.64,93.36 133.64,91.99 135.75,89.88 137.79,89.88 138.94,88.74 145.35,88.74 150.58,83.51 150.58,81.55 151.5,80.64 151.5,78.75 152.34,77.92 152.34,73.14 153.4,72.07 153.4,67.35 152.97,66.92 152.97,64.76 152.21,64 152.21,60.07 150.21,58.06 149.16,58.06 145.54,54.44 145.49,54.39 145.49,53.43 144.39,52.33 144.39,49.05 143.91,48.57 142.94,48.57 140.88,46.51 140.88,44.6 140.14,43.86 139.98,43.86 139.89,43.95 139.89,44.33 139.8,44.42 v2(139.61,44.42)
USB20_P11_R: length 15.8
  TOP w0.102: JEDP1.16 120.7,118.12 120.55,117.96 120.55,116.35 120.9,115.99 122.13,115.99 122.55,116.42 v3(122.92,116.42) 123.29,116.42 123.96,115.75 126.46,115.75 127.57,114.64 127.85,114.64 127.95,114.74 DV41.3 128.65,114.96 128.77,114.96 129.62,115.82 130.03,115.82 130.22,115.63 130.22,115.42 130.37,115.27 LV2.3
USB20_P14: length 119.3
  TOP w0.102: UH1.F6 v2(143.46,45.82)
  IN4 w0.102: v2(143.46,45.82) 143.1,45.82 143.1,45.81 143.02,45.73 143.02,45.67 143.46,45.24 143.46,43.18 141.87,41.59 141.37,41.59 141.16,41.39 139.01,41.39 138.48,41.91 138.48,42.89 138.08,43.29 137.84,43.29 137.33,43.8 137.33,44.87 137.18,45.01 135.91,45.01 135.66,44.76 133.22,44.76 132.23,45.75 131.88,45.75 131.63,46 130.15,46 129.4,46.75 127.41,46.75 125.14,49.01 125.14,49.87 123.26,51.76 122.34,51.76 121.28,52.81 121.28,57.31 119.95,58.64 117.97,58.64 116.69,59.92 112.4,59.92 111.2,61.12 111.2,61.92 108.72,64.4 108.72,69.56 108.19,70.09 108.19,74.12 111.8,77.72 111.8,79.16 116.74,84.1 116.74,84.52 123.33,91.1 123.33,96.87 122.64,97.56 122.64,98.63 123.59,99.58 123.59,103.25 122.7,104.14 121.82,104.14 121.1,104.85 113.75,104.85 v2(113.55,104.66)
  BOTTOM w0.102: v2(113.55,104.66) 113.48,104.73 113.06,104.73 112.89,104.56 v3(112.89,100.26) 112.89,100 112.34,99.46 111.34,99.46 111.08,99.72 L1.4 110.91,100.84 RI50.1
USB20_P14_R: length 3.4
  BOTTOM w0.102: RI50.2 110.91,101.75 L1.3 111.08,102.43 111.21,102.56 111.21,103.02 111.41,103.22 111.41,103.82 111.26,103.97 JNGFF1.3
USB20_PA: length 36.9
  IN2 w0.094: v2(34.49,43.94) 34.49,43.93 34.49,41.99 34.74,41.75 34.74,35.83 32.25,33.34 29.11,33.34 28.07,34.37 26.07,34.37 25.82,34.12 25.82,32.94 27.45,31.32 27.45,27.52 26.81,26.88 25.32,26.88 24.43,27.77 21.2,27.77 20.18,28.79 20.18,29.65 v2(20.04,29.79)
  BOTTOM w0.102: v2(34.49,43.94) UT1.E20 ; RT561.2 19.9,29.65 v2(20.04,29.79)
USB20_PB: length 23.2
  IN2 w0.094: v2(23.39,33.01) 23.39,33.29 23.27,33.41 23.13,33.41 22.78,33.76 22.78,34.53 23.06,34.81 23.94,34.81 24.38,35.24 25.97,35.24 26.02,35.19 27.31,35.19 27.58,35.46 27.58,36.98 27.97,37.37 29.1,38.5 30.17,38.5 32.98,41.3 32.98,45.06 33.44,45.52 34.35,45.52 34.59,45.28 34.59,44.98 34.48,44.87 v2(34.48,44.58)
  BOTTOM w0.102: v2(23.39,33.01) 23.54,33.16 RT557.1 ; v2(34.48,44.58) UT1.E19
USB_ILIM1: length 3.6
  TOP w0.254: UT9.11 39.22,27.42 v2(39.04,27.59)
  BOTTOM w0.254: RT587.1 37.84,25.92 RT588.1 37.84,26.72 38.71,27.59 v2(39.04,27.59)
USB_ILIM2: length 4.3
  TOP w0.305: UT11.11 44.52,28 v2(44.31,28.21)
  BOTTOM w0.109: v1(44.94,28.81) 44.57,29.18 RT586.1
  BOTTOM w0.305: RT585.1 44.41,27.6 44.41,28.05 44.31,28.15 v2(44.31,28.21) 44.31,28.45 43.99,28.77 RT586.1
USB_OC0#: length 22.9
  TOP w0.109: v2(130.86,18.3) 130.66,18.1 RH713.1 130.06,17.16 130.81,16.41 RH720.1 ; v2(131.67,31) 132.04,31 UH1.AH36
  BOTTOM w0.109: v2(130.86,18.3) 130.89,18.27 133.09,18.27 133.43,18.61 133.43,18.92 133.76,19.25 133.76,21.26 134.02,21.51 134.02,22.89 133.45,23.46 133.45,25.38 133.98,25.91 133.98,27.94 133.67,28.25 132.9,28.25 132.05,29.1 v1(132.05,29.72) 132.05,30.6 131.67,30.98 v2(131.67,31)
USB_OC1#: length 357.6
  TOP w0.109: UH1.AL40 130.69,29.55 v2(130.46,29.32) ; UI1.13 381.2,60.85 v2(381.2,60.85) v1(380.68,60.85) ; v2(133.06,21.75) 133.06,21.3 132.66,20.9 RH710.1 133.35,20.04 133.35,18.57 134.5,17.41 RH719.1
  IN2 w0.081: v2(347.93,13.15) 347.47,13.6 347.47,14.44 348.38,15.36 348.38,18.7 348.04,19.04 348.04,21.41 347.5,21.96 347.5,29.07 348.92,30.5 354.08,30.5 355.17,31.59 364.78,31.59 365.62,30.75 368.63,30.75 369.47,31.59 369.86,31.59 371.27,33 376.33,33 378.4,35.07 379.68,35.07 380.38,35.77 380.38,37.22 381.15,37.99 381.15,38.74 381.73,39.32 381.73,42.33 380.71,43.35 380.71,44.87 382.72,46.88 382.72,51.36 384.5,53.13 384.5,56.06 385.13,56.69 385.13,58.11 384.93,58.32 383.73,58.32 v2(381.2,60.85)
  IN3 w0.081: v2(347.93,13.15) 347.93,12.6 345.76,10.43 341.75,10.43 340.37,11.81 338.46,11.81 337.49,10.84 324.61,10.84 322.92,12.52 322.46,12.52 317.67,7.73 310.63,7.73 308.73,5.83 305.94,5.83 305.75,6.02 301.13,6.02 299.37,4.25 278.41,4.25 275.43,7.24 269.44,7.24 266.4,10.27 257.38,10.27 255.85,11.8 245.22,11.8 244.98,11.56 241.43,11.56 240.84,10.98 239.95,10.98 235.72,6.76 169.06,6.76 162.86,12.96 160.42,12.96 158.58,14.8 149.78,14.8 149.49,14.5 145.93,14.5 144.01,16.42 136.93,16.42 136.65,16.7 135.34,16.7 135.12,16.48 130.39,16.48 130.1,16.76 130.1,19.49 129.36,20.24 125.04,20.24 124.54,19.74 124.05,19.74 123.95,19.84 123.95,21.5 124.25,21.81 124.25,22.66 127.5,25.9 128.43,25.9 130.46,27.93 v2(130.46,29.32) 131.26,29.32 131.9,28.68 131.9,26.76 133.45,25.2 133.45,22.78 133.06,22.39 v2(133.06,21.75)
USB_OC2#: length 308.4
  TOP w0.109: v2(131.01,27.54) 131.21,27.33 UH1.AJ44 ; RH711.1 131.77,18.1 v2(132.25,17.63) 133.96,17.63 134.12,17.46 134.12,16.97 133.74,16.59 RH721.1
  TOP w0.254: UI2.13 382.99,38.14 383.36,38.51 v2(383.36,38.62)
  IN2 w0.081: v2(347.93,13.77) 347.93,14.4 348.82,15.29 348.82,21.27 347.9,22.19 347.9,28.51 349.66,30.27 354.51,30.27 355.42,31.18 364.86,31.18 365.52,30.52 368.72,30.52 369.38,31.18 371.25,31.18 372.34,30.08 375.03,30.08 376.1,31.16 376.1,32.19 378.66,34.74 379.8,34.74 381,35.94 381,37.28 381.37,37.64 382.38,37.64 v2(383.36,38.62)
  IN3 w0.081: v2(131.01,27.54) 130.77,27.54 130.24,27 130.24,26.67 129.18,25.61 129.18,24.02 131.19,22.01 131.19,19.69 131.61,19.26 131.61,18.26 v2(132.25,17.63) 132.69,18.07 133.62,18.07 135.68,20.12 136.22,20.12 136.78,20.68 140.22,20.68 140.85,20.05 142.93,20.05 143.13,19.85 145.03,19.85 145.45,19.43 146.82,19.43 148.41,17.85 150.91,17.85 151.81,16.94 152.81,16.94 152.98,17.11 157.24,17.11 160.7,13.64 163.15,13.64 169.35,7.44 231.27,7.44 234.96,11.14 237.96,11.14 238.26,11.44 240.65,11.44 241.24,12.02 244.58,12.02 244.83,12.26 256.07,12.26 257.61,10.73 266.6,10.73 269.64,7.7 275.83,7.7 276.83,6.7 302.44,6.7 302.66,6.48 305.94,6.48 306.13,6.29 307.98,6.29 309.66,7.96 317.58,7.96 322.37,12.75 323.02,12.75 324.7,11.07 337.28,11.07 338.25,12.04 340.66,12.04 341.27,11.43 345.76,11.43 347.23,12.9 347.23,13.07 v2(347.93,13.77)
  BOTTOM w0.109: v2(383.36,38.62) 383.36,38.43 v1(383.07,38.14)
USB_OC3#: length 165.7
  TOP w0.109: v2(113.74,151.78) 113.99,151.53 UI3.13 ; v2(135.05,20.65) 134.9,20.5 RH712.1 134.9,16.96 135.27,16.59 RH718.1 ; UH1.AL41 130.2,28.82 v2(130.03,28.99)
  IN1 w0.102: v2(124.18,141.49) 124.72,140.95 124.72,140.1 124.43,139.8 124.43,120.09 123.47,119.13 123.47,117.86 122.15,116.54 122.15,112.64 122.78,112 122.78,106.85 120.89,104.95 119.9,104.95 119.17,104.23 119.17,102.07 119.51,101.74 119.51,100.29 125.52,94.27 125.52,83.06 125.17,82.7 125.17,79.16 124.15,78.15 124.15,75.76 124.61,75.3 124.61,73.57 125.92,72.26 125.92,71.36 126.97,70.31 126.97,67.91 127.63,67.25 127.63,65.76 127.77,65.62 127.77,64.21 128.05,63.93 128.59,63.93 128.96,63.56 129.84,63.56 130.1,63.3 130.1,62.15 131.88,60.37 132.22,60.37 133.07,59.51 133.07,54.68 132.76,54.38 132.76,52.77 132.1,52.11 132.1,49.65 130.49,48.04 130.49,45.16 130.6,45.05 130.6,44.26 130.91,43.96 130.91,40.22 131.1,40.03 131.1,37.7 131.01,37.61 131.01,29.99 130.76,29.73 130.19,29.73 130.03,29.58 v2(130.03,28.99)
  IN2 w0.081: v2(113.74,151.78) 113.87,151.65 113.87,150.84 113.26,150.23 113.26,145.98 114.37,144.86 120.81,144.86 v2(124.18,141.49) ; v2(130.03,28.99) 129.49,28.99 128.48,27.98 128.48,27.62 132,24.11 132,23.41 132.71,22.7 135,22.7 135.51,22.2 135.51,21.12 v2(135.05,20.65)
  BOTTOM w0.109: v2(124.18,141.49) v1(124.75,141.49)
USB_OC4#: length 127.2
  TOP w0.109: UH1.AV47 127.45,24.56 127.58,24.43 v2(127.67,24.43) ; v2(93.95,22.28) 93.95,27.86 93.66,28.16 90.23,28.16 90,28.39 v2(88.97,28.39) ; UT9.8 41,25.46 41.42,25.03 41.6,25.03 41.81,24.83 41.81,24.13 v2(41.62,23.94)
  IN2 w0.081: v2(93.93,15.8) 93.93,15.44 94.18,15.19 99.5,15.19 99.7,15 105.53,15 105.7,14.82 107.06,14.82 107.32,14.56 107.32,13.74 108.17,12.89 110.97,12.89 112.91,14.84 113.69,14.84 113.92,15.06 113.92,15.45 114.65,16.18 116.57,16.18 117.7,17.31 117.7,18.25 120.7,21.25 121.99,21.25 123.8,23.07 124.69,23.07 125.49,22.26 126.59,22.26 126.87,22.54 126.87,23.63 v2(127.67,24.43) ; v2(88.97,28.39) 88.49,28.39 87.13,27.03 84.2,27.03 82.84,25.67 80.19,25.67 75.22,20.7 69.26,20.7 67.87,19.31 66.75,19.31 65.56,18.13 62.95,18.13 61.62,19.46 60.03,19.46 59.64,19.84 59.64,20.73 58.64,21.73 48.97,21.73 48.69,21.45 45.19,21.45 v2(45.01,21.64)
  IN3 w0.081: v2(45.01,21.64) 45,21.63 43.41,21.63 43.15,21.88 43.15,23.97 42.97,24.14 41.74,24.14 41.63,24.03 41.63,23.95 v2(41.62,23.94)
  IN4 w0.102: v2(93.95,22.28) 94.08,22.15 94.08,15.95 v2(93.93,15.8)
  BOTTOM w0.109: v2(41.62,23.94) 41.49,24.07 40.66,24.07 CT383.2 ; RH714.1 130.95,21.06 130.88,21.13 130.88,22.51 130.1,23.29 v1(129.69,23.29) 128.55,24.43 v2(127.67,24.43)
USB_OC5#: length 127.8
  TOP w0.109: UH1.AR35 128.21,31.26 v2(128.09,31.26) ; UT11.8 46.29,25.46 46.64,25.1 v2(46.64,24.64)
  IN2 w0.081: v2(48.93,13.51) 50.23,12.2 53.16,12.2 53.66,11.7 55.19,11.7 55.57,11.32 58.98,11.32 60.17,12.51 76.47,12.51 82.45,18.49 83.24,18.49 83.56,18.17 89.24,18.17 89.98,18.9 89.98,20.38 92.34,22.75 96.01,22.75 99.89,26.62 100.12,26.62 100.48,26.98 100.48,27.09 100.87,27.49 101.95,27.49 101.97,27.47 104.56,27.47 v2(104.83,27.21)
  BOTTOM w0.109: v2(104.83,27.21) 106.09,28.47 108.64,28.47 109.05,28.89 112.64,28.89 114.47,27.06 116.43,27.06 116.92,27.55 117.34,27.55 118.31,26.57 118.31,26.28 118.61,25.97 120.39,25.97 120.74,25.62 122.12,25.62 122.24,25.75 v1(122.24,26.13) 122.24,26.5 122.98,27.24 123.38,27.24 123.85,26.77 124.11,26.77 124.48,27.14 124.48,28.24 125.09,28.85 125.51,28.85 125.83,29.17 125.83,29.76 126.13,30.07 126.13,30.44 126.38,30.68 127.03,30.68 127.61,31.26 v2(128.09,31.26) 128.55,30.8 129.39,30.8 129.74,30.44 129.74,30.09 129.59,29.94 129.59,28.53 129.73,28.39 129.96,28.39 130.53,27.83 130.53,27.32 130.82,27.04 131.55,27.04 131.65,26.94 133.08,26.94 133.32,26.7 133.32,26.39 133.1,26.17 132.76,26.17 131.52,24.93 131.52,24.08 131.71,23.89 131.71,23.35 131.2,22.84 131.2,21.19 131.26,21.13 131.26,21.08 131.68,20.67 RH715.1 ; CT384.2 46.92,24.92 v2(46.64,24.64) 46.64,24.04 46.84,23.85 46.84,22.98 46.2,22.34 46.2,21.53 49.02,18.71 49.02,17.97 48.87,17.82 48.87,17.52 48.08,16.73 48.08,16.35 49.09,15.34 49.09,13.66 v2(48.93,13.51)
USB_OC6#: length 14.8
  TOP w0.109: v2(129.31,31.21) 129.15,31.05 UH1.AR37
  BOTTOM w0.109: v2(129.31,31.21) 129.51,31.21 130.2,30.52 130.71,30.52 131.15,30.08 131.15,29.49 v1(132.33,28.31) 132.59,28.05 133.43,28.05 133.77,27.72 133.77,25.97 133.08,25.28 133.08,22.29 132.09,21.3 132.09,21.02 132.45,20.67 RH716.1
USB_OC7#: length 15
  TOP w0.109: UH1.AV43 v2(126.92,28.13)
  IN1 w0.102: v2(126.92,28.13) 126.92,26.59 127.9,25.61 133.89,25.61 134.34,25.16 134.34,22.37 v2(133.64,21.67)
  BOTTOM w0.109: v2(133.64,21.67) 133.23,21.26 RH717.1
USB_POWERSHARE_EN#: length 456.1
  TOP w0.109: v2(124.94,144.77) 124.94,145.02 119.57,150.39 118.47,150.39 118.33,150.53 UI3.6 ; UI1.6 v2(386.03,59.85) ; UE1.J3 v2(134.04,72.45) ; v2(131.28,73.84) 131.11,73.67 RE701.1 ; UI2.6 v2(381.99,33.8)
  IN1 w0.102: v2(134.04,72.45) 133.71,72.78 133.71,73.59 132.84,74.46 132.84,74.64 131.87,75.61 131.87,77.2 131.04,78.04 131.04,81.94 132.46,83.37 132.46,95.06 130.93,96.59 130.93,98.94 130.25,99.62 129.16,99.62 125.65,103.13 125.65,107.04 123.74,108.94 123.74,113.03 125.56,114.85 125.56,119.34 126.05,119.82 126.05,134.57 127.86,136.39 127.86,142.1 125.19,144.77 v2(124.94,144.77)
  IN2 w0.081: v2(381.99,33.8) 382.5,34.3 384.82,34.3 388.95,38.43 388.95,52.47 386.53,54.88 386.53,59.68 386.37,59.85 v2(386.03,59.85) 385.8,60.07 385.46,60.07 383.74,61.79 378.46,61.79 376.5,59.83 372.59,59.83 370.68,57.93 346.64,57.93 345.51,59.05 341.06,59.05 339.45,60.67 337.72,60.67 336.72,61.67 330.46,61.67 330.17,61.38 320.19,61.38 310.82,70.75 v2(309.7,70.75) ; v2(134.04,72.45) 131.74,72.45 131.28,72.91 v2(131.28,73.84) ; v2(169.84,105.87) 169.84,106.64 169.75,106.74 169.75,132.48 168.98,133.24 167.84,133.24 167.33,133.75 164.54,133.75 162.51,135.78 157.58,135.78 157.17,136.18 157.17,136.8 156.42,137.56 155.98,137.56 155.93,137.61 149.76,137.61 149.3,138.06 148.6,138.06 146.06,140.6 128.72,140.6 124.94,144.39 v2(124.94,144.77)
  VCC w0.086: v2(169.84,105.87) 171.35,104.37 175.85,104.37 185.08,95.14 270.83,95.14 271.08,94.89 271.17,94.89 271.85,94.2 v2(272.08,94.2)
  BOTTOM w0.109: v2(309.7,70.75) v1(309.7,72.39) 309.7,72.91 308.81,73.8 308.81,78.75 308.18,79.39 302.21,79.39 301.8,79.8 301.8,81.57 300.17,83.2 297.18,83.2 296.62,83.76 294.13,83.76 289.91,87.98 284.81,87.98 283.02,86.19 279.73,86.19 279.02,85.49 277.44,85.49 276.3,86.63 275.46,86.63 274.34,87.75 274.34,89.25 273.91,89.68 273.91,93.28 272.82,94.38 272.26,94.38 v2(272.08,94.2)
USB_POWERSHARE_VBUS_EN: length 626
  TOP w0.109: v2(124.36,144.76) 119.01,150.1 118.42,150.1 118.35,150.03 UI3.5 ; v2(381.33,33.8) 381.49,33.96 UI2.5 ; RE702.1 RE700.1 131.24,72.89 v2(131.71,73.36) 131.92,73.15 131.92,72.54 132.03,72.43 133.22,72.43 UE1.J2 ; v2(386.03,59.2) 385.87,59.35 UI1.5
  IN1 w0.102: v2(102.14,59.74) 101.27,59.74 90.83,49.3 90.83,39.6 88.09,36.87 87.35,36.87 87.2,36.71 87.2,36.35 87.58,35.97 87.58,33.77 86.45,32.64 86.45,31.23 85.42,30.21 79.47,30.21 77.72,28.46 75.92,28.46 75.51,28.87 74.62,28.87 73.48,27.73 67.49,27.73 67.21,28.01 66.72,28.01 65.52,26.8 65,26.8 64.6,27.21 62.84,27.21 62.41,26.78 58.43,26.78 57.76,26.11 57.76,25.45 56.8,24.5 55.37,24.5 54.76,23.89 50.25,23.89 49.86,24.28 49.86,24.86 48.33,26.38 45.45,26.38 41.94,22.86 40.76,22.86 40.38,23.24 35.82,23.24 35.38,23.69 35.38,23.94 35.23,24.09 34.11,24.09 33.68,23.66 26.55,23.66 26.07,23.18 24.78,23.18 23.96,23.99 22.27,23.99 21.38,24.89 17.63,24.89 17.54,24.98 16.22,24.98 10.84,30.35 10.84,36.18 13.18,38.52 v2(13.55,38.52) ; v2(124.36,144.76) 124.36,144.55 126.62,142.29 126.62,137.52 125.82,136.72 125.82,119.92 125.34,119.43 125.34,116.57 123.51,114.75 123.51,108.85 125.42,106.94 125.42,103.03 130.71,97.75 130.71,96.49 132.24,94.96 132.24,83.5 130.81,82.07 130.81,77.94 131.65,77.1 131.65,75.63 131.52,75.51 131.52,74.45 131.72,74.25 131.72,73.37 v2(131.71,73.36)
  IN2 w0.081: v2(381.33,33.8) 382.09,34.56 384.75,34.56 388.57,38.37 388.57,52.34 386.15,54.75 386.15,59.07 v2(386.03,59.2) 385.75,59.48 385.6,59.48 383.59,61.48 378.53,61.48 376.63,59.58 372.69,59.58 370.79,57.67 346.49,57.67 345.39,58.77 340.98,58.77 339.34,60.42 337.49,60.42 336.49,61.41 330.56,61.41 330.28,61.13 320.09,61.13 311.22,69.99 v2(309.19,69.99) ; v2(124.36,144.76) 124.36,142.69 129.72,137.33 138.25,137.33 138.67,137.75 141.3,137.75 141.72,137.33 156.31,137.33 156.77,136.87 156.77,136.15 157.39,135.52 162.38,135.52 165.17,132.73 168.96,132.73 169.46,132.22 169.46,106.36 v2(169.27,106.17)
  VCC w0.086: v2(169.27,106.17) 169.27,105.67 170.77,104.16 175.73,104.16 184.96,94.93 270.74,94.93 271.9,93.77 272.48,93.77 v2(272.63,93.93)
  IN3 w0.081: v2(117.16,74.37) 116.99,74.21 115.06,74.21 113.53,72.68 113.53,71.53 103.24,61.23 103.24,60.43 102.54,59.74 v2(102.14,59.74)
  IN4 w0.102: v2(117.16,74.37) 117.4,74.37 118.8,72.97 125.3,72.97 126.26,73.93 127.72,73.93 128.4,73.24 131.19,73.24 131.28,73.33 131.68,73.33 v2(131.71,73.36)
  BOTTOM w0.109: v2(272.63,93.93) 272.63,93.57 273.53,92.67 273.53,89.12 273.91,88.74 273.91,87.75 275.33,86.32 276.04,86.32 277.26,85.1 278.98,85.1 279.83,85.95 285.55,85.95 286.64,87.04 290.32,87.04 294.06,83.29 294.75,83.29 295.27,82.77 300.23,82.77 301.55,81.45 301.55,79.54 301.95,79.14 307.92,79.14 308.56,78.5 308.56,73.55 309.19,72.91 v1(309.19,71.02) v2(309.19,69.99) ; QT5.2 13.55,38.56 13.55,38.52 v2(13.55,38.52)
USB_POWERSHARE_VBUS_EN#: length 51
  IN1 w0.102: v2(41.95,23.45) 41.59,23.09 40.85,23.09 40.05,23.89 39.14,23.89 37.3,25.73 35.51,25.73 34.76,24.98 v2(33.2,24.98) 32.36,24.14 26.24,24.14 25.25,25.14 23.37,25.14 23.27,25.23 23.27,25.24 22.39,26.13 21.53,26.13 21.36,26.29 19.82,26.29 19.23,25.7 16.63,25.7 16.33,25.99 16.33,26.45 16.69,26.8 16.69,27.21 16.3,27.6 14.01,27.6 11.07,30.54 11.07,35.04 11.96,35.93 v2(11.96,36.31)
  BOTTOM w0.109: v2(33.2,24.98) 33.57,24.61 UT10.1 ; QT5.1 12.76,37.84 RT564.2 11.96,37.04 v2(11.96,36.31) v1(13.02,36.31) ; UT12.1 42.49,23.99 v2(41.95,23.45) 41.59,23.09 41.16,23.09 40.9,22.84 RT610.2
USB_PWR_SHR_VBUS_RHT_EN2: length 1.7
  BOTTOM w0.109: RI75.2 381.72,57.98 UI4.5
USB_PWR_SHR_VBUS_RHT_EN3: length 5.1
  BOTTOM w0.109: v1(387.46,49.85) 386.88,49.85 386.55,49.52 386.55,48.06 386.13,47.64 RI91.2 385.28,46.83 UI5.5
USH_DET#: length 299.6
  TOP w0.109: v2(336.75,45.29) 336.75,46.18 336.38,46.55 JUSH1.1 ; v2(156.33,67.78) 156.33,68.3 v1(156.39,68.35) ; RE526.2 144.66,78.49 144.04,78.49 v2(144.02,78.47) 143.45,77.9 142.69,77.9 UE1.C13
  IN2 w0.081: v2(144.02,78.47) 144.3,78.47 145.62,77.15 145.62,71.08 146.01,70.69 148.37,70.69 149.08,71.39 151.32,71.39 152.18,72.25 153.39,72.25 154.73,70.91 154.73,69.93 155.32,69.34 156.05,69.34 156.33,69.05 v2(156.33,67.78)
  VCC w0.086: v2(156.33,67.78) 156.16,67.6 156.16,66.36 154.68,64.89 152.42,64.89 152.2,65.11 150.09,65.11 149.32,64.35 149.32,62.74 147.24,60.66 147.24,59.77 146.49,59.02 146.49,52.03 149.94,48.59 150.7,48.59 158.34,40.95 158.34,33.87 159,33.21 159,23.89 155.97,20.86 155.97,17.93 164.72,9.18 216.51,9.18 217.19,8.49 221.45,8.49 222.09,9.14 232.57,9.14 236.69,13.25 241.4,13.25 241.71,12.95 248.8,12.95 249.34,12.41 264.96,12.41 267.67,9.7 292.6,9.7 297.79,14.88 301,14.88 302.23,16.12 302.23,23.64 312.21,33.62 319.09,33.62 320.9,35.42 324.37,35.42 333.09,44.15 335.61,44.15 v2(336.75,45.29)
USH_EXPANDER_SMBCLK: length 318.2
  TOP w0.109: v2(333.8,53.76) 334.49,53.76 334.78,54.05 JUSH1.16 336.11,54.05 336.39,54.33 337.4,54.33 337.79,53.94 RZ8.2 CZ62.1 ; v2(149.07,70.33) 151.25,70.33 151.78,70.86 154.85,70.86 155.17,70.55 156.16,70.55 156.87,71.26 v2(158.68,71.26) ; UE1.B3 v2(134.07,78.82)
  VCC w0.086: v2(333.8,53.76) 333.8,51.9 327.15,45.25 327.15,44.36 322.74,39.96 322.74,38.76 321.66,37.68 320.92,37.68 319.3,36.06 316.76,36.06 316.02,35.32 313.22,35.32 301.6,23.71 301.6,16.39 300.73,15.52 297.73,15.52 292.4,10.19 267.87,10.19 265.16,12.91 249.54,12.91 249.01,13.44 241.91,13.44 241.6,13.75 236.48,13.75 232.37,9.63 221.81,9.63 221.17,8.99 217.62,8.99 216.94,9.67 164.93,9.67 156.46,18.14 156.46,20.65 159.5,23.68 159.5,33.41 158.83,34.07 158.83,41.15 150.91,49.08 150.13,49.08 146.99,52.22 146.99,55.69 148.09,56.8 148.09,60.09 148.36,60.37 148.36,61.43 149.61,62.68 149.61,64.29 150.19,64.86 152.09,64.86 152.4,64.56 154.91,64.56 156.52,66.16 156.52,67.14 157,67.62 157,69.89 158.37,71.26 v2(158.68,71.26)
  IN3 w0.081: v2(149.07,70.33) 149.07,72.89 148.07,73.89 148.07,77.55 146.71,78.91 143.65,78.91 143.39,79.17 142.34,79.17 142.03,79.48 140.96,79.48 140.51,79.03 138.13,79.03 137.53,78.43 136.81,78.43 136,79.24 134.38,79.24 134.07,78.93 v2(134.07,78.82)
  BOTTOM w0.109: UE12.12 158.88,71.45 158.7,71.26 v2(158.68,71.26)
USH_EXPANDER_SMBDAT: length 317.3
  TOP w0.109: v2(157.53,69.33) 157.02,69.33 156.66,69.69 154.94,69.69 153.31,68.06 152.75,68.06 152.09,68.72 v2(152.09,68.98) ; JUSH1.15 334.72,53.55 334.45,53.28 333.6,53.28 v2(333.17,53.71) ; UE1.E5 v2(135.67,76.42)
  IN2 w0.081: v2(152.09,68.98) 151.2,68.98 150.54,69.64 148.38,69.64 147.89,69.14 146.21,69.14 144.88,70.47 144.88,75.91 144.24,76.55 143.76,76.55 143.66,76.44 143.33,76.44 142.82,76.95 142.49,76.95 141.63,77.81 141.63,79.06 141.42,79.26 141.04,79.26 140.67,78.88 138.43,78.88 137.8,78.25 137.8,76.82 136.17,76.82 135.77,76.42 v2(135.67,76.42)
  VCC w0.086: v2(157.53,69.33) 157.53,68.82 157.99,68.37 157.99,67.5 157.87,67.39 157.25,67.39 156.87,67.01 156.87,65.8 155.29,64.23 152.38,64.23 151.99,64.62 150.29,64.62 149.86,64.18 149.86,62.58 148.64,61.36 148.64,60.16 148.33,59.86 148.33,56.69 147.23,55.59 147.23,52.27 150.18,49.33 151.01,49.33 159.08,41.26 159.08,34.18 159.74,33.51 159.74,23.58 156.71,20.55 156.71,18.24 165.03,9.92 217.04,9.92 217.73,9.23 221.07,9.23 221.71,9.88 232.27,9.88 236.38,13.99 241.71,13.99 242.01,13.69 249.11,13.69 249.64,13.15 265.26,13.15 267.98,10.44 292.29,10.44 293.66,11.81 293.66,12.63 296.8,15.77 298.36,15.77 300.34,17.74 300.34,22.79 313.34,35.79 315.44,35.79 315.97,36.32 319.21,36.32 320.83,37.94 321.41,37.94 322.43,38.95 322.43,39.99 326.79,44.36 326.79,45.27 333.17,51.64 v2(333.17,53.71)
  BOTTOM w0.109: v2(157.53,69.33) 157.85,69.65 157.85,71.03 158.43,71.62 UE12.13 ; v2(333.17,53.71) 333.7,53.18 334.24,53.18 334.54,53.48 CZ63.1 335.28,52.63 RZ9.2
USH_PWR_STATE#: length 286.6
  TOP w0.109: v2(133.28,73.25) 133.64,73.61 UE1.H2 ; JUSH1.5 336.22,48.55 336.96,47.81 337.31,47.81 RZ10.2 337.45,47.02 v2(337.44,47)
  IN1 w0.102: v2(147.16,57.81) 147.16,58.69 144.3,61.56 139.77,61.56 138.38,62.96 138.38,64 137.24,65.14 136.24,65.14 135.81,65.57 135.81,66.03 135.12,66.72 134.41,66.72 133.21,67.92 133.21,68.77 133.91,69.47 133.91,70.34 133.65,70.59 133.65,72.02 133.28,72.4 v2(133.28,73.25)
  VCC w0.086: v2(147.16,57.81) 147.62,57.35 147.62,56.68 146.74,55.8 146.74,52.13 150.03,48.83 150.8,48.83 158.59,41.05 158.59,33.97 159.25,33.31 159.25,23.79 156.22,20.75 156.22,18.03 164.83,9.42 216.61,9.42 217.29,8.74 221.35,8.74 221.99,9.38 232.47,9.38 236.59,13.5 241.5,13.5 241.81,13.19 248.91,13.19 249.44,12.66 265.06,12.66 267.77,9.95 292.5,9.95 297.81,15.25 300.81,15.25 301.89,16.33 301.89,23.64 312.11,33.86 318.32,33.86 320.49,36.02 324.46,36.02 335.44,47 v2(337.44,47)
  BOTTOM w0.109: v1(134.48,73.67) 133.7,73.67 v2(133.28,73.25)
USH_RST#_R: length 7.2
  TOP w0.109: JUSH1.6 336.17,49.05 337.03,48.18 337.93,48.18 RZ114.2 338.63,47.48 339.47,47.48 CZ61.1 339.88,48.14 340.75,49.01 v1(341.21,49.01)
VCI_IN1#: length 4.5
  TOP w0.109: v1(135.58,82.69) 135.52,82.63 135.52,82.1 135.45,82.02 RE507.1 135.45,80.26 135.6,80.11 135.6,78.91 136.04,78.47 UE1.B5
VCI_IN2#: length 5.2
  TOP w0.109: UE1.D4 v2(134.87,77.22)
  BOTTOM w0.109: RE508.1 136.44,80.76 136.35,80.76 135.41,79.82 v1(135.41,79.71) 135.41,78.71 135.22,78.51 135.22,77.88 135.15,77.82 134.87,77.53 v2(134.87,77.22)
VCI_IN3#: length 7.1
  TOP w0.109: UE1.E4 v2(134.87,76.42)
  BOTTOM w0.109: v1(134.41,76.04) 134.48,76.04 v2(134.87,76.42) 135.24,76.8 135.24,77.42 135.42,77.6 135.96,77.6 136.09,77.73 136.09,79.03 136.45,79.39 136.45,80.04 136.45,80.04 136.45,80.07 136.79,80.41 137.18,80.41 RE750.1
VCT_LAN_R1: length 3.6
  TOP w0.203: UL1.6 157.29,139.63 v2(157.39,139.53)
  BOTTOM w0.254: RL50.2 158.83,138.58 RL3.1 158.67,139.51 v1(157.91,139.51) 157.41,139.51 v2(157.39,139.53)
VGA_IDENTIFY: length 170.2
  TOP w0.109: RE84.1 144.21,65.61 v2(143.96,65.85) ; v2(275.65,87.08) 276.09,87.52 JDGFF4.F1 ; UE1.L9 v2(139.61,70.88) ; JDGFF2.F1 246.49,86.76 v2(246.3,86.57) 245.92,86.19 243.5,86.19 243.02,85.71 237.19,85.71 236.26,84.77 232.94,84.77 232.23,84.06 225.75,84.06 225.35,84.46 v2(225.14,84.46)
  VCC w0.086: v2(155.27,72.41) 155.27,72.41 155.27,72.79 155.83,73.34 155.83,73.68 158.83,76.69 158.83,77.19 161.74,80.1 161.74,85.93 165.93,90.12 165.93,92.48 167.51,94.06 168.94,94.06 169.44,93.56 177.2,93.56 177.64,93.11 181.18,93.11 183.94,90.36 185.07,90.36 185.34,90.09 195.13,90.09 195.77,90.73 217.28,90.73 223.92,84.09 224.78,84.09 v2(225.14,84.46)
  IN3 w0.081: v2(246.3,86.57) 246.49,86.76 247.62,86.76 249.14,85.24 251.1,85.24 252,86.14 252.43,86.14 253.41,85.16 267.82,85.16 268.41,85.75 270.46,85.75 271.07,86.35 271.07,87.14 271.85,87.92 273.4,87.92 274.24,87.08 v2(275.65,87.08)
  BOTTOM w0.109: v2(139.61,70.88) 140,70.49 140,69.85 140.36,69.5 140.68,69.5 140.82,69.36 140.82,68.65 141.96,67.5 142.64,67.5 143.96,66.18 v2(143.96,65.85) 145.15,65.85 146.35,67.05 148.32,67.05 v1(148.65,67.38) 149.22,67.38 149.68,67.83 149.68,69.67 152.16,72.15 155.01,72.15 v2(155.27,72.41)
VID0_VCCIO_VR: length 5.7
  TOP w0.109: 312.4,61.5 312.4,61.61 311.94,62.07 v1(311.94,63.44)
  TOP w0.254: PU300.4 309.93,60.63 310.22,60.92 311.08,60.92 311.47,61.31 PR314.1 312.4,61.5 PR313.2
VID1_VCCIO_VR: length 4.6
  TOP w0.254: PU300.3 310.43,60.37 310.6,60.54 v1(312.51,60.54) 313.07,61.11 313.07,61.51 PR311.1 313.98,61.51 PR312.2
VOUT_IO: length 16.2
  TOP w0.254: v2(307.2,65.18) PR306.1 307.19,64.53 PR303.2 ; v2(310.47,55.32) 310.31,55.32 309.93,55.7 PU300.12
  BOTTOM w0.254: v2(310.47,55.32) 310.92,55.77 310.92,56.95 310.3,57.57 v1(310.3,58.22) 310.3,64.39 309.51,65.18 v2(307.2,65.18)
VR_SVID_ALERT#: length 81.6
  TOP w0.109: PR1115.2 309.56,39.42 v2(309.87,39.12) PR1199.2
  IN1 w0.102: v2(309.87,39.12) 309.17,38.42 309.17,32.99 308.18,31.99 292.29,31.99 292.01,32.27 287.02,32.27 286.06,33.24 278.7,33.24 278.06,33.89 264.35,33.89 262.02,31.56 v2(262.02,29.71)
  BOTTOM w0.109: RC153.1 266.01,13.05 266.09,12.97 RC152.2 266.34,12.33 267.18,12.33 267.38,12.53 267.38,15.2 v1(267.28,15.29) 267.28,18.48 267.66,18.86 267.66,22.62 262.02,28.26 v2(262.02,29.71)
VR_SVID_CLK: length 91.4
  TOP w0.109: PR1117.2 309.4,40.07 v2(309.88,40.07) PR1104.2 ; UC1.BH32 254.39,31.96 v2(254.39,31.93)
  IN1 w0.102: v2(309.88,40.07) 308.69,38.88 308.69,33.19 307.98,32.48 292.49,32.48 292.21,32.76 289.53,32.76 288.57,33.72 278.9,33.72 278.26,34.37 261.11,34.37 259.27,32.53 258.29,32.53 258.04,32.28 256.83,32.28 256.58,32.02 254.49,32.02 v2(254.39,31.93)
  BOTTOM w0.109: CC325.1 264.06,17.16 262.96,17.16 260.49,19.63 260.49,22 260.77,22.28 260.77,24.72 260.49,25 260.49,29.56 258.77,31.29 257.36,31.29 256.73,31.93 v1(255.26,31.93) v2(254.39,31.93)
VR_SVID_DATA: length 101.6
  TOP w0.109: UC1.BH29 251.6,32.88 v2(251.31,32.88) ; PR1105.1 v2(309.88,38.17) 308.94,38.17 PR1113.2
  IN1 w0.102: v2(251.31,32.88) 251.56,32.88 252.96,31.48 256.8,31.48 257.01,31.28 258.94,31.28 261.12,29.1 262.43,29.1 262.71,29.38 262.71,31.28 264.83,33.4 277.85,33.4 278.5,32.76 285.86,32.76 286.82,31.79 291.81,31.79 292.09,31.51 308.38,31.51 309.65,32.79 309.65,37.94 v2(309.88,38.17)
  BOTTOM w0.109: v2(251.31,32.88) 251.69,32.88 252.42,32.15 v1(252.42,31.27) 252.42,30.75 253,30.17 253.29,30.17 253.56,29.9 253.98,29.9 254.45,30.37 255.63,30.37 255.94,30.68 256.81,30.68 257.56,29.93 258.53,29.93 259.89,28.57 259.89,25.05 259.51,24.68 259.51,19.47 264,14.97 264.48,14.97 265.14,14.32 RC157.2
VRALERT#: length 5.1
  TOP w0.102: RH203.1 119.93,31.38 120.67,32.13 121.22,32.13 122.37,33.28 123.1,33.28 123.4,33.58 123.67,33.58 123.91,33.34 UH1.BE32
VSET_5105: length 8.5
  TOP w0.109: v2(141.22,82.36) 141.22,82.79 141.25,82.83 RE77.1 ; RE77.1 142.08,83.4 CE38.1 ; RE77.1 v1(140.31,83.4) ; UE1.C9 v2(139.61,78.02)
  IN1 w0.102: v2(139.61,78.02) 139.46,78.18 139.46,80.09 141.15,81.78 141.15,82.29 v2(141.22,82.36)
VSN_1PH: length 8.8
  TOP w0.152: v1(312.24,48.96) 311.85,48.57 PC1140.2
  TOP w0.203: PU1100.51 306.7,44.55 307.59,45.44 307.59,46.12 308.4,46.93 308.4,47.73 308.69,48.02 309.84,48.02 PR1107.2 PC1140.2
VSN_2PH: length 4.2
  TOP w0.203: PR1127.1 PC1112.1 306.07,37.29 v1(305.65,37.7) 304.82,38.53 304.82,38.8 304.75,38.88 PU1100.37
VSN_4PH: length 9.6
  TOP w0.203: PU1100.2 305.15,46.08 305.48,46.42 306.49,46.42 307.39,47.32 307.39,48.99 v2(307.78,49.38)
  BOTTOM w0.152: v1(306.59,52.38) PR1123.2
  BOTTOM w0.203: PR1123.2 PC1110.2 307.44,50.51 307.78,50.17 v2(307.78,49.38)
VSP_1PH: length 5.8
  TOP w0.203: PU1100.52 306.59,44.95 307.21,45.56 v1(307.21,45.6) 307.21,46.21 308.07,47.07 308.07,48.03 PC1105.2 PR1109.2
VSP_2PH: length 6.9
  TOP w0.203: PU1100.38 305.15,39.06 305.28,38.93 305.28,38.66 306.25,37.7 306.84,37.7 307.46,37.07 307.46,36.43 v1(307.87,36.02) 307.87,35.17 PR1126.1 307.69,34.99 PC1111.1
VSP_4PH: length 7.4
  TOP w0.203: v2(307.85,48.71) 307.74,48.6 307.74,47.21 306.63,46.09 305.7,46.09 305.55,45.94 PU1100.1
  BOTTOM w0.152: v2(307.85,48.71) v1(307.85,47.94)
  BOTTOM w0.203: v2(307.85,48.71) 307.82,48.68 306.84,48.68 PR1121.2 PC1109.2
WIGIG_32KHZ: length 5.4
  BOTTOM w0.109: JNGFF1.42 123,113.68 123.07,113.74 123.07,115.34 122.77,115.64 RZ56.1 121.07,115.64 v1(120.85,115.85)
WLAN_COEX1: length 52.3
  IN2 w0.081: v2(161.6,123.25) 161.3,122.95 159,122.95 157.91,121.85 151.17,121.85 145.88,127.15 136.21,127.15 127.06,118 126.44,118 122.88,114.44 v2(122.62,114.44)
  BOTTOM w0.109: v2(161.6,123.25) v1(162.38,122.47) RZ130.2 ; JNGFF1.40 122.5,114.32 v2(122.62,114.44)
WLAN_COEX2: length 52.3
  IN2 w0.081: v2(160.78,123.44) 159.13,123.44 157.84,122.15 151.2,122.15 145.97,127.38 136.14,127.38 126.99,118.23 126.09,118.23 122.94,115.08 v2(122.63,115.08)
  BOTTOM w0.109: v2(160.78,123.44) 161.49,122.73 v1(161.49,121.5) RZ129.2 ; JNGFF1.38 122,114.71 122.38,115.08 v2(122.63,115.08)
WLAN_COEX3: length 56.8
  IN2 w0.081: v2(121.8,111.01) 121.8,112.73 126.63,117.55 127.68,117.55 131.03,120.9 131.57,120.9 133.92,123.25 137.44,123.25 140.03,125.85 141.86,125.85 145.9,121.81 145.9,121.58 146.15,121.33 147.37,121.33 149.02,119.67 150.29,119.67 151.84,121.22 158.34,121.22 159.56,122.44 v2(160.22,122.44)
  BOTTOM w0.109: v2(160.22,122.44) v1(159.59,122.44) 159.23,122.08 RZ128.2 ; v2(121.8,111.01) 121.5,111.31 JNGFF1.36
WLAN_PWR_EN: length 8.5
  TOP w0.109: DZ9.1 149.15,98.3 147.81,96.97 RZ71.2 ; DZ9.1 149.15,99.39 v1(149.55,99.8) ; DZ9.1 148.56,98.79 148.13,99.23 148.13,100.19 RZ70.2 147.6,100.73 R127.1 147.6,101.92 147.63,101.95 UZ44.3
WLAN_WIGIG60GHZ_DIS#: length 89.7
  TOP w0.109: UE1.L13 v2(142.81,70.88) 143.38,70.31 144.5,70.31 RE8.1
  IN1 w0.102: v2(142.81,70.88) 142.81,71.96 143.18,72.32 143.18,73.6 142.8,73.98 142.8,75.63 143.25,76.09 143.25,76.52 143.12,76.66 143.12,76.97 143.36,77.21 143.36,78.68 143.13,78.9 143.13,80.37 143.65,80.89 144.15,80.89 144.83,80.89 145.67,81.73 145.67,82.53 145.21,82.98 145.21,86.82 146.69,88.29 146.69,100.28 147.14,100.73 147.14,103.29 146.78,103.65 146.78,104.83 144.23,107.38 144.23,110.9 143.12,112.01 143.12,116.14 144.1,117.12 144.23,117.12 146.1,118.99 146.1,123.42 v2(145.87,123.65)
  BOTTOM w0.109: v2(145.87,123.65) 145.35,124.17 139.41,124.17 137.81,122.57 137.81,119.52 137.49,119.2 136.81,119.2 135.52,117.92 135.52,116.85 135.35,116.68 130.99,116.68 129.75,117.92 126.29,117.92 v1(126.22,117.99) 125.82,117.99 DZ1.1
WLAN_WIGIG60GHZ_DIS#_R: length 3.2
  BOTTOM w0.109: DZ1.2 124.93,115.27 v1(124.93,114.34) 124.93,114.06 124.5,113.64 JNGFF1.48
WRST#: length 3.4
  BOTTOM w0.109: UE12.19 156.64,74.58 156.36,74.87 CE343.1 155.73,74.82 RE564.2 155.73,73.19 v1(155.64,73.1)
WWAN_COEX1: length 6
  BOTTOM w0.109: JNGFF2.56 160.99,115.44 162.29,116.74 RZ373.1 162.56,117.76 162.56,117.97 v1(163.06,118.46) 163.06,118.77 RZ130.1
WWAN_COEX2: length 5.4
  BOTTOM w0.109: RZ129.1 161.49,118.84 RZ372.1 161.37,118.71 161.37,117.88 161.01,117.52 v1(161.01,116.8) 161.01,115.81 160.49,115.29 JNGFF2.54
WWAN_COEX3: length 3.9
  BOTTOM w0.109: JNGFF2.52 159.99,116.67 RZ374.1 159.71,116.69 159.44,116.42 RZ128.1 v1(158.28,116.42)
WWAN_FULL_PWR_EN: length 125.4
  TOP w0.109: UH1.BF19 123.59,39.45 122.53,39.45 122.23,39.74 121.63,39.74 121.63,39.75 121.09,39.75 120.75,39.4 120.75,38.53 120.31,38.1 118.36,38.1 118.21,38.24 v2(118.21,38.93)
  IN1 w0.102: v2(147.6,58.22) 147.6,59.82 147.2,60.21 147.2,60.8 148.73,62.32 148.73,63.91 149.68,64.86 149.68,68.68 147.58,70.78 147.04,70.78 146.78,71.03 146.78,71.96 147.79,72.96 147.79,74.74 148.13,75.08 148.13,80.43 148.99,81.29 148.99,95.2 150.55,96.76 150.55,101.29 150.19,101.65 149.35,101.65 149.12,101.88 149.12,103.75 145.02,107.85 145.02,110.72 145.96,111.66 145.96,113.95 146.78,114.77 146.78,116.26 146.39,116.65 v2(146.39,117.35)
  IN3 w0.081: v2(118.21,38.93) 118.21,39.45 117.77,39.89 117.77,44.27 119.24,45.75 119.24,48.09 123.19,52.03 123.3,52.03 124.41,53.14 124.69,53.14 126.43,54.88 127.1,54.88 128.58,53.39 132.37,53.39 133.18,52.58 133.18,52.41 133.62,51.98 133.91,51.98 136.1,54.16 138.8,54.16 139.24,54.6 142.04,54.6 143.19,55.76 144.24,55.76 146.75,58.27 147.55,58.27 v2(147.6,58.22)
  BOTTOM w0.109: JNGFF2.6 146.49,115.81 146.39,115.91 146.39,116.49 v1(145.94,116.94) 145.98,116.94 v2(146.39,117.35) 146.31,117.43 145.25,117.43 RZ43.1 144.71,117.96 CZ198.1
WWAN_RADIO_DIS#: length 54.3
  TOP w0.109: UE1.F12 141.82,75.25 142.18,75.62 142.73,75.62 142.8,75.69 143.34,75.69 143.68,75.34 v2(144.01,75.34) 144.01,75.41 RE10.1
  IN1 w0.102: v2(145.69,117.85) 145.53,117.68 145.53,116.7 146.23,116 146.23,115.02 145.42,114.21 145.42,111.86 144.49,110.93 144.49,107.52 147.6,104.41 147.6,99.97 146.91,99.29 146.91,86.46 145.69,85.24 145.69,83.18 146.15,82.72 146.15,81.51 145.03,80.39 143.96,80.39 143.65,80.09 143.65,79.19 143.98,78.86 144.22,78.86 144.68,78.4 144.68,76.01 v2(144.01,75.34)
  BOTTOM w0.109: v2(145.69,117.85) 146.2,117.85 v1(146.52,118.16) 147.42,118.16 DZ5.1
WWAN_RADIO_DIS#_R: length 1.9
  BOTTOM w0.109: JNGFF2.8 146.99,115.58 DZ5.2
WWAN_WAKE#: length 43.5
  TOP w0.109: RE38.1 143.91,70.07 142.82,70.07 v2(142.81,70.08) UE1.M13
  IN1 w0.102: v2(142.81,70.08) 143.1,70.08 143.77,70.76 143.77,73.23 145.03,74.49 145.03,79.31 148.01,82.29 148.01,98.46 149.9,100.35 v2(149.9,100.37)
  BOTTOM w0.109: JNGFF2.15 150.74,105.79 151.05,105.48 151.05,101.2 v1(150.42,100.57) 150.25,100.39 149.92,100.39 v2(149.9,100.37)
XCLK_RBIAS: length 8.7
  TOP w0.109: UH1.T3 138.51,47.75 138.51,48.84 139.01,49.34 139.01,50.31 v1(139.43,50.72) 139.43,51.46 v2(140.05,52.08)
  BOTTOM w0.109: v2(140.05,52.08) 139.88,52.26 RH171.2 139.42,54.52 RH435.2
XDP_DBRESET#: length 174.1
  TOP w0.109: UC3.1 122.44,57.5 122.88,57.06 RH66.2 123.33,57.06 123.7,57.43 123.7,58.13 125.41,59.84 v2(125.67,59.84)
  IN2 w0.081: v2(125.67,59.84) 125.67,58.72 126.36,58.03 132.31,58.03 132.59,58.31 132.59,59.38 132.33,59.64 132.33,60.47 133.66,61.79 137.45,61.79 138.55,60.7 142.4,60.7 143.52,59.58 148.82,59.58 150.42,57.98 150.69,57.98 152.78,55.89 154.66,55.89 160.74,49.81 160.74,47.74 162.94,45.54 162.94,35.51 166.11,32.34 166.11,24.41 167.43,23.1 167.43,17.49 172.16,12.77 173.97,12.77 176.11,10.63 213.47,10.63 215.08,12.24 230.18,12.24 230.67,11.75 233.51,11.75 237.78,16.01 241.58,16.01 242.35,16.78 v2(242.35,17.08)
  BOTTOM w0.109: v2(242.35,17.08) 242.35,17.25 242.18,17.42 JXDP1.48 v1(242.18,20.28) 242.55,20.65 243.15,20.65 243.3,20.8 CC32.1 243.77,21.94 243.77,23.4 243.62,23.55 RC137.1
XDP_OBS0: length 7
  TOP w0.089: 250.19,26.87 250.1,26.96 250.1,27.68 UC1.BR27
  TOP w0.109: RC239.1 250.39,22.01 v1(249.94,22.46) 249.83,22.58 249.83,26 250.2,26.37 250.2,26.86 250.19,26.87
XDP_OBS0_R: length 20.2
  TOP w0.109: RC239.2 250.39,20.34 v2(250.78,19.95) 251.08,19.66 251.08,18.81 v1(251.28,18.61)
  IN1 w0.102: v2(250.78,19.95) 251.09,19.64 251.09,19.11 250.92,18.94 250.58,18.94 250.47,18.84 250.47,17.72 250.37,17.62 250.17,17.62 250.07,17.72 250.07,18.84 249.97,18.94 249.76,18.94 249.66,18.84 249.66,17.72 249.56,17.62 249.36,17.62 249.26,17.72 249.26,18.84 249.15,18.94 248.95,18.94 248.85,18.84 248.85,17.72 248.75,17.62 248.54,17.62 248.44,17.72 248.44,19.06 248.35,19.15 247.64,19.15 247.44,18.96 247.44,17.46 247.63,17.28 249.66,17.28 v2(250.18,16.75)
  BOTTOM w0.109: JXDP1.21 250.28,16.65 v2(250.18,16.75)
XDP_OBS1: length 10.2
  TOP w0.109: UC1.BT27 250.62,27.1 250.62,26.53 250.01,25.92 250.01,23.7 250.77,22.94 250.77,22.38 RC240.1 251.35,21.82 251.99,21.17 251.99,19.09 v1(252.56,18.52)
XDP_OBS1_R: length 19.7
  TOP w0.109: RC240.2 251.55,20.68 v1(251.55,19.9) v2(251.55,19.19)
  IN1 w0.102: v2(251.55,19.19) 251.61,19.19 251.91,18.89 251.91,18.74 250.88,17.71 250.88,17.57 251.02,17.42 251.17,17.42 252.2,18.46 252.34,18.46 252.96,17.85 252.96,16.19 251.46,14.7 251.04,14.7 250.93,14.8 250.93,15.99 250.83,16.09 250.63,16.09 250.53,15.99 250.53,14.8 250.43,14.7 250.24,14.7 250.12,14.81 250.12,15.99 250.02,16.09 249.82,16.09 249.71,15.99 249.71,14.8 249.61,14.7 249.39,14.7 v2(249.09,14.39)
  BOTTOM w0.109: v2(249.09,14.39) 249.68,14.99 JXDP1.23
XDP_PRSNT_PIN1: length 3.5
  BOTTOM w0.109: RC121.1 258.32,14.8 RC122.1 257.86,14.8 v2(257.69,14.64) 257.39,14.64 256.93,15.09 256.42,15.09 256.28,15.23 JXDP1.1
XTAL24_IN_R: length 4.5
  TOP w0.109: RH153.1 139.59,54.77 RH436.2 139.59,55.56 139.68,55.65 CH13.1 138.89,56.85 138.89,57.63 YH2.3
XTAL24_IN_R1: length 14.5
  TOP w0.102: v2(138.04,44.01) 137.57,44.01 UH1.U10
  TOP w0.109: RH436.1 141.07,54.43 v2(141.07,54.16)
  IN1 w0.102: v2(138.04,44.01) 138.28,44.01 138.66,44.39 138.66,44.96 138.43,45.19 138.43,46.85 139.39,47.82 139.39,52.39 141.07,54.06 v2(141.07,54.16)
  BOTTOM w0.109: v2(141.07,54.16) v1(141.07,53.55)
XTAL24_OUT: length 3.5
  TOP w0.109: RH152.2 138.79,53.99 RH153.2 138.79,55.46 CH14.1 138.76,56.28 138.27,56.77 YH2.1
XTAL24_OUT_R1: length 13.6
  TOP w0.102: UH1.U9 v2(138.25,44.64)
  TOP w0.109: RH152.1 140.26,53.98 140.42,54.14 v2(140.49,54.14)
  IN1 w0.102: v2(138.25,44.64) 138,44.39 137.59,44.39 137.44,44.54 137.44,44.85 138.24,45.65 138.24,47.27 139.11,48.14 139.11,52.54 140.49,53.91 v2(140.49,54.14)
XTAL_25_IN: length 5.1
  BOTTOM w0.076: UT1.D22 33.49,42.67 33.49,42.21 33.47,42.2
  BOTTOM w0.109: RT394.1 30.62,39.83 31.23,40.44 31.85,40.44 33.47,42.06 33.47,42.2
XTAL_25_OUT: length 3.6
  BOTTOM w0.109: UT1.D23 33.73,41.98 32.57,40.82 32.57,40.57 32.41,40.4 RT40.1
XTAL_25_OUT_R: length 4.2
  BOTTOM w0.109: RT40.2 31.5,39.43 CT20.1 31.2,38.29 31.2,36.62 32.08,35.74 YT1.3
XTALI: length 6.3
  TOP w0.109: Y1.1 160.35,142.73 160.11,142.49 159.48,142.49 CL14.1 158.6,142.42 157.76,142.42 157.62,142.29 157.62,141.63 157.46,141.47 156.98,141.47 156.74,141.23 UL1.10
XTALO: length 2.3
  TOP w0.109: UL1.9 156.68,140.83 157.05,141.21 158.01,141.21 RL34.2
XTALO_R: length 4.8
  TOP w0.109: Y1.3 162.05,141.93 161.73,142.26 159.63,142.26 159.56,142.18 159.3,142.18 CL13.1 159.01,141.96 RL34.1
Z2805: length 3.2
  TOP w0.109: RL18.1 v1(158.14,171.21)
  TOP w0.381: RL18.1 157.49,170.21 v2(157.48,170.19)
  BOTTOM w0.381: v2(157.48,170.19) TL1.22
Z2806: length 3.1
  TOP w0.109: v1(158.26,163.6) RL17.1
  TOP w0.381: RL17.1 157.61,162.59 v2(157.59,162.61)
  BOTTOM w0.381: v2(157.59,162.61) 157.62,162.57 TL1.16
Z2807: length 3.2
  TOP w0.109: v1(158.14,167.92) RL16.1
  TOP w0.381: RL16.1 v2(157.48,168.94)
  BOTTOM w0.381: v2(157.48,168.94) 157.49,168.92 TL1.21
Z2808: length 3.1
  TOP w0.109: v1(158.26,160.36) RL15.1
  TOP w0.381: RL15.1 v2(157.53,161.32)
  BOTTOM w0.381: TL1.15 158.14,161.3 158.12,161.32 v2(157.53,161.32)
Z4012: length 4.4
  BOTTOM w0.109: v1(299.91,31.84) PR64.1
  BOTTOM w0.203: PR61.2 301.62,30.63 PD8.2
  BOTTOM w0.254: PR61.2 300.86,30.68 PR64.1 301.24,31.84 301.43,31.65 PQ26.2
Z4304: length 5.5
  TOP w0.109: PR65.1 68.2,14.72 v2(68.76,14.16)
  BOTTOM w0.109: v2(68.76,14.16) 68.4,13.81 PBATT1.4 68.4,10.63 v4(68.13,10.37)
Z4305: length 6.4
  TOP w0.109: PR66.1 68.01,13.93 68.19,13.75 69.49,13.75 v2(69.9,14.16)
  BOTTOM w0.109: v4(69.9,10.33) PBATT1.5 v2(69.9,14.16)
Z4306: length 10.4
  TOP w0.109: v2(71.4,14.14) 70.73,14.81 68.72,14.81 68.03,15.5 PR67.1
  BOTTOM w0.109: v2(71.4,14.14) PBATT1.6 71.4,11.56 70.6,10.76 70.6,9.02 v4(70.18,8.6)
N17828613: length 31.1
  IN1 w0.381: v2(51.38,28.08) 51.64,27.83 56.3,27.83 58.56,30.09 60.31,30.09 61.21,30.99 62.42,30.99 64.85,33.42 64.85,37.3 65.63,38.08 72.16,38.08 v2(72.93,37.3)
  BOTTOM w0.254: PQ17.4 v1(72.8,36.48) 72.8,37.18 v2(72.93,37.3)
N17880182: length 30.3
  IN1 w0.381: v2(83.73,30.97) 83.39,30.97 82.74,31.61 80.18,31.61 77.51,28.95 75.97,28.95 75.66,29.25 74.37,29.25 73.38,28.26 67.58,28.26 67.08,28.76 64.75,28.76 63.56,27.57 62.23,27.57 61.87,27.21 60.6,27.21 60.52,27.29 58.85,27.29 v2(58.8,27.35)
  BOTTOM w0.109: v1(59.45,27.13) 59.23,27.35 v2(58.8,27.35)
  BOTTOM w0.508: PQ18.4 v2(83.73,30.97)
N17880186: length 3.6
  TOP w0.109: v1(59.64,32) PR26.2
  TOP w0.508: PQ20.2 60.93,29.75 60.37,30.31 PR32.1 PR26.2
N17880313: length 2.9
  TOP w0.109: PQ5.3 v1(62.67,30.63) 62.29,31.02 PR32.2
N17883210: length 1.8
  TOP w0.305: PQ6.3 55.2,27.72 55.62,28.14 PR34.2
N17883346: length 5.3
  TOP w0.109: PR71.2 65.61,30.05 v1(66.05,30.49)
  TOP w0.381: PQ5.5 63.32,27.27 63.48,27.12 63.92,27.12 63.97,27.16 PQ5.6 63.97,28.23 64.84,29.1 65.17,29.1 PR71.2
