# Allegro board LAH281PR10-0410_Gerber.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
TPC12
  round 0.305 smd: 1(0,0)
TPS51212DSCR_SON10_3X3
  oval 0.279x0.838 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,2.95) 7(1.5,2.95) 8(1,2.95) 9(0.5,2.95) 10(0,2.95)
  custom 0.412x0.412 smd: 11(1,1.475)
TS5A3159ADCKR_SC70-6
  oval 0.381x1.372 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0.65,1.74) 6(0,1.74)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
UNIMI_FBGCAX011_68P-T-S
  round 1.194 hole 1.194 unplated: (-1.06,0.64) (11.88,0.64)
  round 2.692 hole 2.692 unplated: (5.41,-2.82)
  round 0.991 hole 0.991 unplated: (5.41,-6.27)
  oval 0.711x0.406 smd: A1(0,0) A2(0,-0.6) A3(0,-1.2) A4(0,-1.8) A5(0,-2.4) A6(0,-3) A7(0,-3.6) A8(0,-4.2) A9(0,-4.8) A10(0,-5.4) B1(0.92,0) B2(0.92,-0.6) B3(0.92,-1.2) B4(0.92,-1.8) B5(0.92,-2.4) B6(0.92,-3) B7(0.92,-3.6) B8(0.92,-4.2) B9(0.92,-4.8) B10(0.92,-5.4) C1(3.3,0) C2(3.3,-0.6) C3(3.3,-1.2) C4(3.3,-1.8) C5(3.3,-2.4) C6(3.3,-3) C7(3.3,-3.6) C8(3.3,-4.2) C9(3.3,-4.8) C10(3.3,-5.4) D1(4.22,0) D2(4.22,-0.6) D9(4.22,-4.8) D10(4.22,-5.4) E1(6.6,0) E2(6.6,-0.6) E9(6.6,-4.8) E10(6.6,-5.4) F1(7.52,0) F2(7.52,-0.6) F3(7.52,-1.2) F4(7.52,-1.8) F5(7.52,-2.4) F6(7.52,-3) F7(7.52,-3.6) F8(7.52,-4.2) F9(7.52,-4.8) F10(7.52,-5.4) G1(9.9,0) G2(9.9,-0.6) G3(9.9,-1.2) G4(9.9,-1.8) G5(9.9,-2.4) G6(9.9,-3) G7(9.9,-3.6) G8(9.9,-4.2) G9(9.9,-4.8) G10(9.9,-5.4) H1(10.82,0) H2(10.82,-0.6) H3(10.82,-1.2) H4(10.82,-1.8) H5(10.82,-2.4) H6(10.82,-3) H7(10.82,-3.6) H8(10.82,-4.2) H9(10.82,-4.8) H10(10.82,-5.4)
W25Q80DVSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
W25Q256JVEIQ_WSON8_8X6
  oval 0.66x0.991 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,8) 6(2.54,8) 7(1.27,8) 8(0,8)
  rect 4.293x3.404 smd: 9(1.905,4)
W25X40CLSSIG_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
WGI219LM-SLKJ2-A0_QFN48_6X6
  oval 0.762x0.254 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(5.9,-4.4) 26(5.9,-4) 27(5.9,-3.6) 28(5.9,-3.2) 29(5.9,-2.8) 30(5.9,-2.4) 31(5.9,-2) 32(5.9,-1.6) 33(5.9,-1.2) 34(5.9,-0.8) 35(5.9,-0.4) 36(5.9,0)
  oval 0.254x0.762 smd: 13(0.75,-5.15) 14(1.15,-5.15) 15(1.55,-5.15) 16(1.95,-5.15) 17(2.35,-5.15) 18(2.75,-5.15) 19(3.15,-5.15) 20(3.55,-5.15) 21(3.95,-5.15) 22(4.35,-5.15) 23(4.75,-5.15) 24(5.15,-5.15) 37(5.15,0.75) 38(4.75,0.75) 39(4.35,0.75) 40(3.95,0.75) 41(3.55,0.75) 42(3.15,0.75) 43(2.75,0.75) 44(2.35,0.75) 45(1.95,0.75) 46(1.55,0.75) 47(1.15,0.75) 48(0.75,0.75)
  rect 2.997x2.997 smd: 49(2.95,-2.2)
Y_8Y24000034_4P
  rect 0.889x0.787 smd: 1(0,0) 2(1.4,0) 3(1.4,1.1) 4(0,1.1)
Y_9H03200042_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_FL2500123Z_4P
  rect 1.499x1.194 smd: 1(0,0) 2(2.12,0) 3(2.12,1.6) 4(0,1.6)
Y_X1A000141000200_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_X3G025000DI1H-H_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
YDM_DH792_1P-T
  custom 1.675x1.675 smd: 1(0,0)

## Nets
0.6V_DDR_VTT_ON: PR210.1 RD17.2 UD1.4(Y)
1.2V_SUS_PWRGD: PR205.2 PU200.10(PGOOD)
3.3V_CAM_EN#: RH736.2 RZ545.1 UH1.BE18(GPP_D2/SPI1_MISO/SBK2_BK2)
3.3V_RUN_GFX_ON: QZ20.2(G) RZ547.1 RZ548.1 UE1.K9(GPIO032/GPTP-OUT0) UZ41.5(ON2)
3.3V_WWAN_EN: R129.1 UE1.C6(GPIO165/32KHZ_IN/CTOUT0) UZ44.5(ON2)
3V_FB: PC112.1 PU100.13(FF)
+0.6V_DDR_VTT: CD27.1 CD30.1 CD31.1 CD57.1 CD58.1 CD59.1 CD91.1 CD92.1 CD93.1 CD122.1 CD123.1 CD124.1 JDIMM1.258(VTT) JDIMM2.258(VTT) JDIMM3.258(VTT) JDIMM4.258(VTT) PJP204.1
+0.6V_P: PC205.1 PJP204.2 PU200.2(VTTSNS) PU200.20(VTT)
+0.9V_LAN: CL3.1 CL4.1 CL8.1 CL9.1 CL10.1 CL11.1 CL12.1 LL1.2 UL1.8(VDD0P9_8) UL1.11(VDD0P9_11) UL1.16(VDD0P9_16) UL1.22(VDD0P9_22) UL1.37(VDD0P9_37) UL1.40(VDD0P9_40) UL1.43(VDD0P9_43) UL1.46(VDD0P9_46) UL1.47(VDD0P9_47)
+0.9V_TBT_LC: CT333.1 UT1.J8(VCC0P9_LC)
+0.9V_TBT_LVR_OUT: CT329.1 CT330.1 CT331.1 CT332.1 UT1.H6(VCC0P9_LVR_SENSE) UT1.H8(VCC0P9_LVR)
+0.9V_TBT_PCIE: CT337.1 CT338.1 CT339.1 CT340.1 CT341.1 UT1.J18(VCC0P9_PCIE) UT1.L18(VCC0P9_ANA_PCIE_2_1) UT1.L19(VCC0P9_ANA_PCIE_1_1) UT1.M16(VCC0P9_ANA_PCIE_2_2) UT1.M18(VCC0P9_ANA_PCIE_2_3) UT1.M19(VCC0P9_ANA_PCIE_1_2)
+0.9V_TBT_SVR: CT305.1 CT306.1 CT307.1 CT308.1 CT309.1 CT310.1 CT311.1 CT316.2 CT317.2 CT318.2 CT319.2 CT320.2 CT321.2 CT322.2 CT334.1 CT335.1 CT336.1 LT10.2 UT1.E8(VCC0P9_SVR_BRD_SENSE) UT1.H9(VCC0P9_SVR_PAB_ANA1) UT1.H11(VCC0P9_SVR_PAB_ANA2) UT1.H12(VCC0P9_SVR_PAB_ANA3) UT1.H13(VCC0P9_SVR_PAB_ANA4) UT1.H15(VCC0P9_SVR_PAB_ANA5) UT1.H16(VCC0P9_SVR_PAB_ANA6) UT1.J13(VCC0P9_SVR1) UT1.L11(VCC0P9_SVR2) UT1.L13(VCC0P9_SVR3) UT1.M8(VCC0P9_SVR4) UT1.M11(VCC0P9_SVR5) UT1.M13(VCC0P9_SVR6) UT1.N6(VCC0P9_SVR_DPAUX_ANA) UT1.N8(VCC0P9_SVR7) UT1.N11(VCC0P9_SVR8) UT1.N13(VCC0P9_SVR9) UT1.R8(VCC0P9_SVR10) UT1.R11(VCC0P9_SVR11) UT1.R13(VCC0P9_SVR12) UT1.R16(VCC0P9_SVR13) UT1.T8(VCC0P9_SVR14) UT1.T9(VCC0P9_SVR_USB_ANA1) UT1.T11(VCC0P9_SVR_USB_ANA2) UT1.T12(VCC0P9_SVR_PC_ANA1) UT1.T13(VCC0P9_SVR_PC_ANA2) UT1.T15(VCC0P9_SVR_PC_ANA3) UT1.T16(VCC0P9_SVR15)
+1.0V_ALW_PCH: CH29.1 LH421.1 LH423.1 PJP3.2 RH171.1 RH240.1 RH241.1 RH254.2 RH255.1 RH256.1 RH257.1 RH258.1 RH259.1 RH260.1 RH286.1 RH287.1 RH288.1 RH290.1
+1.0V_AMPHYPLL: CH267.1 CH324.1 CH555.1 CH560.1 LH423.2 UH1.C49(VCCAMPHYPLL_1P051) UH1.D49(VCCAMPHYPLL_1P052) UH1.E49(VCCAMPHYPLL_1P053)
+1.0V_AZPLL: CH32.1 CH46.1 RH241.2 UH1.D1(VCCPRIM_1P0521) UH1.E1(VCCPRIM_1P0522)
+1.0V_BCLKPLL2: CC330.1 LC2.1 RH259.2
+1.0V_BCLKPLL2_R: CC311.1 CH31.1 LC2.2 UH1.B1(VCCAPLL_1P051) UH1.B2(VCCAPLL_1P052) UH1.B3(VCCAPLL_1P053)
+1.0V_CLPLLEBB: CC328.1 CH66.1 RH290.2 UH1.W31(VCCPRIM_MPHY_1P05)
+1.0V_DSW: CH35.1 RH255.2 UH1.BG45(VCCDSW_1P051) UH1.BG46(VCCDSW_1P052)
+1.0V_DUSB: CH38.1 RH286.2 UH1.W22(VCCDUSB_1P051) UH1.W23(VCCDUSB_1P052)
+1.0V_MPHY: CH34.1 CH47.1 PJP3.1 UH1.U26(VCCPRIM_1P0523) UH1.U29(VCCPRIM_1P0524) UH1.V25(VCCPRIM_1P0525) UH1.V27(VCCPRIM_1P0526) UH1.V28(VCCPRIM_1P0527) UH1.V30(VCCPRIM_1P0528) UH1.V31(VCCPRIM_1P0529)
+1.0V_OC: CH44.1 RH260.2 UH1.V19(VCCA_BCLK_1P05)
+1.0V_OCPLL1: CC332.1 LC3.1 RH240.2
+1.0V_OCPLL1_R: CC331.1 CH20.1 LC3.2 UH1.C1(VCCAPLL_1P054) UH1.C2(VCCAPLL_1P055)
+1.0V_PRIM_CNV_HVLO: RH257.2 UH1.AE17(VCCPRIM_1P0515)
+1.0V_PRIM_FUSE: RH256.2 UH1.AD31(VCCPRIM_1P0514)
+1.0V_PRIM_XDP: CC28.1 CC29.1 JXDP1.43 JXDP1.44 RC115.2 RC138.1 RC216.2
+1.0V_SRC: RH258.2 UH1.W19(VCCA_SRC_1P051) UH1.W20(VCCA_SRC_1P052)
+1.0V_VCCSFR: LC562.1 RC304.2
+1.0V_VCCSFR_R: CC192.2 CC333.1 CC335.2 LC562.2 UC1.H28(VCCPLL1) UC1.J28(VCCPLL2)
+1.0V_VCCST: CC191.2 CC193.2 CC194.2 CC569.1 PC1101.2 PJP1.1 PR1103.1 PR1104.1 PR1105.2 PR1199.1 RC71.1 RC79.1 RC80.1 RC152.1 RC157.1 RC166.1 RC218.1 RC304.1 RE59.1 RE90.2 RZ151.2 UC1.H30(VCCST) UV69.5(VCC)
+1.0V_VCCST_C: CZ101.1 PJP1.2 UZ21.6(VOUT)
+1.0V_VCCSTG: CC186.2 CC195.2 PJP2.1 RC83.1 RC135.2 RC326.2 RH312.2 RH314.2 RH315.2 RZ151.1 UC1.H29(VCCSTG2)
+1.0V_VCCSTG_C: CZ106.1 PJP2.2 UZ19.6(VOUT)
+1.0V_XTAL: CH45.2 LH421.2 UH1.P2(VCCA_XTAL_1P051) UH1.P3(VCCA_XTAL_1P052)
+1.0VS_VCCIO: CC187.1 CC188.1 CC189.1 CC272.1 PJP301.2 QE11.1(D) RC1.2 RC2.1 RC132.1 RC439.2 UC1.AG12(VCCIO1) UC1.G15(VCCIO2) UC1.G17(VCCIO3) UC1.G19(VCCIO4) UC1.G21(VCCIO5) UC1.H15(VCCIO6) UC1.H16(VCCIO7) UC1.H17(VCCIO8) UC1.H19(VCCIO9) UC1.H20(VCCIO10) UC1.H21(VCCIO11) UC1.H26(VCCIO12) UC1.H27(VCCIO13) UC1.J15(VCCIO14) UC1.J16(VCCIO15) UC1.J17(VCCIO16) UC1.J19(VCCIO17) UC1.J20(VCCIO18) UC1.J21(VCCIO19) UC1.J26(VCCIO20) UC1.J27(VCCIO21)
+1.0VS_VCCIOP: PC307.1 PC308.1 PC309.1 PC310.1 PJP301.1 PL300.2 PR303.1
+1.2V_MEM: CC81.1 CC82.1 CC83.1 CC84.1 CC161.1 CC163.1 CC164.1 CC165.1 CC166.1 CC167.1 CC168.1 CC170.1 CC171.1 CC172.1 CC185.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD16.1 CD17.1 CD18.1 CD19.1 CD20.1 CD21.1 CD22.1 CD23.1 CD24.1 CD34.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CD47.1 CD49.1 CD50.1 CD51.1 CD52.1 CD53.1 CD54.1 CD55.1 CD56.1 CD68.1 CD69.1 CD70.1 CD71.1 CD72.1 CD73.1 CD74.1 CD75.1 CD76.1 CD77.1 CD79.1 CD80.1 CD81.1 CD82.1 CD83.1 CD84.1 CD85.1 CD86.1 CD96.1 CD104.1 CD105.1 CD106.1 CD107.1 CD108.1 CD109.1 CD110.1 CD111.1 CD112.1 CD114.1 CD115.1 CD116.1 CD117.1 CD118.1 CD119.1 CD120.1 CD121.1 CZ102.2 JDIMM1.12(DM0_N/DBI0_N) JDIMM1.33(DM1_N/DBI_N) JDIMM1.54(DM2_N/DBI2_N) JDIMM1.75(DM3_N/DBI3_N) JDIMM1.96(DM8_N/DBI_N/NC) JDIMM1.111(VDD1) JDIMM1.112(VDD2) JDIMM1.117(VDD3) JDIMM1.118(VDD4) JDIMM1.123(VDD5) JDIMM1.124(VDD6) JDIMM1.129(VDD7) JDIMM1.130(VDD8) JDIMM1.135(VDD9) JDIMM1.136(VDD10) JDIMM1.141(VDD11) JDIMM1.142(VDD12) JDIMM1.147(VDD13) JDIMM1.148(VDD14) JDIMM1.153(VDD15) JDIMM1.154(VDD16) JDIMM1.159(VDD17) JDIMM1.160(VDD18) JDIMM1.163(VDD19) JDIMM1.178(DM4_N/DBI4_N) JDIMM1.199(DM5_N/DBI5_N) JDIMM1.220(DM6_N/DBI6_N) JDIMM1.241(DM7_N/DBI7_N) JDIMM2.12(DM0_N/DBI0_N) JDIMM2.33(DM1_N/DBI_N) JDIMM2.54(DM2_N/DBI2_N) JDIMM2.75(DM3_N/DBI3_N) JDIMM2.96(DM8_N/DBI_N/NC) JDIMM2.111(VDD1) JDIMM2.112(VDD2) JDIMM2.117(VDD3) JDIMM2.118(VDD4) JDIMM2.123(VDD5) JDIMM2.124(VDD6) JDIMM2.129(VDD7) JDIMM2.130(VDD8) JDIMM2.135(VDD9) JDIMM2.136(VDD10) JDIMM2.141(VDD11) JDIMM2.142(VDD12) JDIMM2.147(VDD13) JDIMM2.148(VDD14) JDIMM2.153(VDD15) JDIMM2.154(VDD16) JDIMM2.159(VDD17) JDIMM2.160(VDD18) JDIMM2.163(VDD19) JDIMM2.178(DM4_N/DBI4_N) JDIMM2.199(DM5_N/DBI5_N) JDIMM2.220(DM6_N/DBI6_N) JDIMM2.241(DM7_N/DBI7_N) JDIMM3.12(DM0_N/DBI0_N) JDIMM3.33(DM1_N/DBI_N) JDIMM3.54(DM2_N/DBI2_N) JDIMM3.75(DM3_N/DBI3_N) JDIMM3.96(DM8_N/DBI_N/NC) JDIMM3.111(VDD1) JDIMM3.112(VDD2) JDIMM3.117(VDD3) JDIMM3.118(VDD4) JDIMM3.123(VDD5) JDIMM3.124(VDD6) JDIMM3.129(VDD7) JDIMM3.130(VDD8) JDIMM3.135(VDD9) JDIMM3.136(VDD10) JDIMM3.141(VDD11) JDIMM3.142(VDD12) JDIMM3.147(VDD13) JDIMM3.148(VDD14) JDIMM3.153(VDD15) JDIMM3.154(VDD16) JDIMM3.159(VDD17) JDIMM3.160(VDD18) JDIMM3.163(VDD19) JDIMM3.178(DM4_N/DBI4_N) JDIMM3.199(DM5_N/DBI5_N) JDIMM3.220(DM6_N/DBI6_N) JDIMM3.241(DM7_N/DBI7_N) JDIMM4.12(DM0_N/DBI0_N) JDIMM4.33(DM1_N/DBI_N) JDIMM4.54(DM2_N/DBI2_N) JDIMM4.75(DM3_N/DBI3_N) JDIMM4.96(DM8_N/DBI_N/NC) JDIMM4.111(VDD1) JDIMM4.112(VDD2) JDIMM4.117(VDD3) JDIMM4.118(VDD4) JDIMM4.123(VDD5) JDIMM4.124(VDD6) JDIMM4.129(VDD7) JDIMM4.130(VDD8) JDIMM4.135(VDD9) JDIMM4.136(VDD10) JDIMM4.141(VDD11) JDIMM4.142(VDD12) JDIMM4.147(VDD13) JDIMM4.148(VDD14) JDIMM4.153(VDD15) JDIMM4.154(VDD16) JDIMM4.159(VDD17) JDIMM4.160(VDD18) JDIMM4.163(VDD19) JDIMM4.178(DM4_N/DBI4_N) JDIMM4.199(DM5_N/DBI5_N) JDIMM4.220(DM6_N/DBI6_N) JDIMM4.241(DM7_N/DBI7_N) PJP202.1 PJP203.1 RD4.1 RD8.1 RD30.1 RD34.1 RZ119.1 UC1.AA6(VDDQ1) UC1.AE12(VDDQ2) UC1.AF5(VDDQ3) UC1.AF6(VDDQ4) UC1.AG5(VDDQ5) UC1.AG9(VDDQ6) UC1.AJ12(VDDQ7) UC1.AL11(VDDQ8) UC1.AP6(VDDQ9) UC1.AP7(VDDQ10) UC1.AR6(VDDQ12) UC1.AR12(VDDQ11) UC1.AT12(VDDQ13) UC1.AW6(VDDQ14) UC1.AY6(VDDQ15) UC1.J5(VDDQ16) UC1.J6(VDDQ17) UC1.K6(VDDQ19) UC1.K12(VDDQ18) UC1.L6(VDDQ21) UC1.L12(VDDQ20) UC1.R6(VDDQ22) UC1.T6(VDDQ23) UC1.W6(VDDQ24) UC1.Y12(VDDQ25) UD1.5(VCC) UZ26.1(VIN1) UZ26.2(VIN2) UZ26.7(VIN THERMAL) UZ43.1(VIN1) UZ43.2(VIN2)
+1.2V_MEN_P: PC207.1(P) PC211.2 PC212.1 PJP202.2 PJP203.2 PL201.1 PR206.2 PU200.5(VDDQ) PU200.19(VLDOIN)
+1.2V_RUN: LV5.2 LV6.2 LV7.2 LV8.2 LV10.2 LV11.2 LV12.2 LV13.2 PJP66.1
+1.2V_RUN_PWR: CZ514.1 PJP66.2 UZ43.7(VOUT1) UZ43.8(VOUT2)
+1.05V_PRIM: CH36.1 CR255.1 CZ100.1 CZ105.1 PJP801.2 RC216.1 RH254.1 UH1.AA22(VCCPRIM_1P051) UH1.AA23(VCCPRIM_1P052) UH1.AB20(VCCPRIM_1P053) UH1.AB22(VCCPRIM_1P054) UH1.AB23(VCCPRIM_1P055) UH1.AB27(VCCPRIM_1P056) UH1.AB28(VCCPRIM_1P057) UH1.AB30(VCCPRIM_1P058) UH1.AD20(VCCPRIM_1P059) UH1.AD23(VCCPRIM_1P0510) UH1.AD27(VCCPRIM_1P0511) UH1.AD28(VCCPRIM_1P0512) UH1.AD30(VCCPRIM_1P0513) UH1.AF23(VCCPRIM_1P0516) UH1.AF27(VCCPRIM_1P0517) UH1.AF30(VCCPRIM_1P0518) UR4.1(VIN1) UR4.2(VIN2) UR4.7(VIN THERMAL) UZ19.1(VIN1) UZ19.2(VIN2) UZ19.7(VIN THERMAL) UZ21.1(VIN1) UZ21.2(VIN2) UZ21.7(VIN THERMAL)
+1.05V_PRIMP: PC806.1(P) PJP801.1 PL801.2 PR809.1
+1.05V_VDD: CR214.2 CR215.1 CR219.2 CR220.2 CR221.1 CR222.1 CR223.2 CR237.2 CR238.2 CR239.1 CR240.2 CR241.2 CR242.1 CR249.2 CR250.2 CR251.1 CR252.2 CR253.2 CR254.1 LR1.2 RR227.2 UR1.3(VDDRX) UR1.6(VDDCMU) UR1.9(VDDTX) UR1.16(SDV10) UR1.30(VDD_LN1) UR1.31(VDD_LN0)
+1.8V_ALW_PCHRES: RH247.2 RH250.2 RH294.2 RH295.1 RH296.1
+1.8V_ALW_VTR3: CE21.1 PJP20.2 RE549.1 UE1.N5(VTR3) UE11.5(VCC)
+1.8V_PHVLDO: RH239.1 UH1.AF19(VCCPRIM_1P81) UH1.AF20(VCCPRIM_1P82)
+1.8V_PRIM: CE22.1 CZ544.1 PJP20.1 PJP901.2 RH242.1 RH247.1 RH604.1 RH605.2 RH607.1 RH613.1 RH614.1 RZ543.2 UZ45.1(VIN1) UZ45.2(VIN2) UZ61.5(VCC)
+1.8V_PRIM_PCH: CH21.1 CH22.1 RH239.2 RH242.2 RZ376.1 RZ378.1 UH1.AG19(VCCPRIM_1P83) UH1.AG20(VCCPRIM_1P84) UH1.AN15(VCCPRIM_1P85) UH1.AR15(VCCPRIM_1P86) UH1.BB11(VCCPRIM_1P87)
+1.8V_PRIMP: PC904.1 PC905.1 PC906.1 PJP901.1 PL900.2 PR904.1
+1.8V_RUN: CA65.1 CA66.1 PJP42.1 RA201.1
+1.8V_RUN_AUDIO: CA57.1 CA58.1 CA69.1 RA201.2 UA1.20(CPVDD/AVDD2)
+1.8V_RUN_PWR: CZ120.1 PJP42.2 UZ45.7(VOUT1) UZ45.8(VOUT2)
+1.24V_DPHY: RH237.1 UH1.AJ22(VCCDPHY_1P241) UH1.AJ23(VCCDPHY_1P242)
+1.24V_DPHY_MAR: CH30.1 CH559.1 T75.1 UH1.BG5(VCCDPHY_1P243)
+1.24V_LDOSRAM: RH237.2 T287.1 UH1.AK22(VCCPRIM_1P241) UH1.AK23(VCCPRIM_1P242)
+2.5V_MEM: CD1.1 CD2.1 CD3.1 CD4.1 CD35.1 CD36.1 CD37.1 CD38.1 CD64.1 CD65.1 CD66.1 CD67.1 CD100.1 CD101.1 CD102.1 CD103.1 JDIMM1.257(VPP1) JDIMM1.259(VPP2) JDIMM2.257(VPP1) JDIMM2.259(VPP2) JDIMM3.257(VPP1) JDIMM3.259(VPP2) JDIMM4.257(VPP1) JDIMM4.259(VPP2) PJP401.2
+2.5V_MEMP: PC402.1 PC403.1 PC404.1 PJP401.1 PL400.2 PR404.1
+2.8V_FHV0: RH287.2 UH1.AF31(VCCPRIM_1P0519)
+2.8V_FHV1: RH288.2 UH1.AG31(VCCPRIM_1P0520)
+3.3V_1.8V_AZIO: CC329.1 LC1.1 RH292.2 RH295.2
+3.3V_1.8V_AZIO_R: CC310.1 CC327.1 LC1.2 UH1.BB14(VCCHDA)
+3.3V_1.8V_GPPA: RH95.2 RH291.2 RH294.1 RH327.2 RH340.2 UH1.AN32(VCCPGPPA)
+3.3V_1.8V_GPPD: RH293.2 RH296.2 UH1.AN24(VCCPGPPD)
+3.3V_1.8V_SPI: RH246.2 RH250.1 UH1.AN44(VCCSPI)
+3.3V_ALW: CE16.1 CE52.1 CE53.1 CE59.1 CE60.1 CE61.1 CE340.1 CE341.1 CT237.1 CT389.1 CZ57.1 CZ58.1 CZ82.1 CZ91.1 JAPS1.3 JAPS1.7 JKBTP1.6(6        6) PJP6.2 PJP22.1 PJP101.2 PJP391.2 PJP400.1 PJP900.1 PR10.2 PR22.2 PR23.1 PR40.2 PR41.1 PR59.2 PR60.1 PR62.1 PR107.1 PR110.1 PR205.1 PR400.1 PR720.1 PR721.1 PR725.2 PR730.2 PR800.2 PR900.1 PR2003.2 PR2005.2 PR2007.2 PR2008.2 PR2010.2 PR2016.2 PR2018.2 PR2021.2 PR2143.2 PR2151.2 QH7.3(S) QT3.1(D) RE8.2 RE10.2 RE11.2 RE12.2 RE21.2 RE25.1 RE35.2 RE37.2 RE38.2 RE43.2 RE63.2 RE68.2 RE69.1 RE71.1 RE72.1 RE73.1 RE74.1 RE75.1 RE79.1 RE83.2 RE84.2 RE91.2 RE300.1 RE302.2 RE303.2 RE343.1 RE362.2 RE365.2 RE505.2 RE526.1 RE532.1 RE561.2 RE563.2 RE564.1 RE565.1 RE566.1 RE700.2 RE701.2 RE730.2 RE731.2 RE732.2 RE733.2 RE734.2 RE735.2 RE739.1 RE740.1 RE741.1 RE742.1 RE748.2 RH431.2 RH432.1 RT510.2 RT511.2 RT512.2 RT514.2 RT515.2 RT516.2 RT518.2 RT528.1 RT529.1 RV909.1 RZ369.1 RZ375.1 RZ377.1 RZ381.1 RZ1482.1 UE3.5(VCC) UE4.5(VCC) UE5.5(VCC) UE12.14(VSTBY1) UE12.24(VSTBY2) UT32.5(V+) UT34.5(VCC) UV24.5(VIN) UZ6.5(VCC) UZ7.1(VIN1) UZ7.2(VIN2) UZ42.1(VIN1) UZ42.2(VIN2) UZ44.1(VIN1_1) UZ44.2(VIN1_2) UZ44.6(VIN2_1) UZ44.7(VIN2_2) UZ59.1(VIN1) UZ59.2(VIN2)
+3.3V_ALW2: PR104.2 RE57.2
+3.3V_ALW_DSW_R: QH7.1(D) RH439.2
+3.3V_ALW_PCH: JAPS1.1 JSPI1.16(16     16) PJP38.1 RC74.1 RC133.1 RC137.2 RH56.1 RH57.1 RH61.1 RH67.1 RH77.1 RH78.1 RH80.1 RH81.1 RH86.1 RH101.1 RH185.1 RH203.2 RH204.2 RH279.1 RH309.1 RH310.1 RH311.1 RH329.2 RH330.1 RH371.2 RH376.1 RH400.2 RH440.2 RH553.2 RH555.2 RH710.2 RH711.2 RH712.2 RH713.2 RH714.2 RH715.2 RH716.2 RH717.2 RH730.1 RH731.1 RH734.1 RH736.1 RI94.2 RI95.2 RT391.2 RT615.1 RZ69.1 RZ368.1 RZ379.1 RZ1385.1 UH7.5(VCC)
+3.3V_ALW_PCH_PWR: CZ520.1 PJP38.2 UZ42.7(VOUT1) UZ42.8(VOUT2)
+3.3V_ALW_PCHRES: RH246.1 RH279.2 RH291.1 RH292.1 RH293.1 RH298.1 RH299.1 RH300.1 RH302.1 RH303.1 RH304.1 RH305.1 RH306.1
+3.3V_ALW_R: CV810.1 CV811.1 CZ68.1 CZ73.1 CZ93.1 CZ200.1 CZ540.1 JPB1.3 JUSH1.11 JUSH1.12 JUSH1.13 PC313.1 PJP27.2 PJP28.2 PJP502.2 PR300.1 PR311.2 PR313.1 PR500.1 PR515.1 PU300.10(3V3) RC241.1 RV817.1 RV820.1 RV821.1 RZ8.1 RZ9.1 UV60.5(VCC) UV63.5(P) UV68.5(VCC) UZ9.1(VIN1_1) UZ9.2(VIN1_2) UZ9.6(VIN2_1) UZ9.7(VIN2_2) UZ10.5(VCC) UZ34.5(VCC) UZ35.5(VCC) UZ40.6(VIN2_1) UZ40.7(VIN2_2) UZ41.6(VIN2_1) UZ41.7(VIN2_2) UZ58.1(VIN1) UZ58.2(VIN2) UZ60.5(P)
+3.3V_ALW_RP: PC520.1 PC521.1 PC522.1 PC523.1 PC525.1 PC529.1 PJP502.1 PL501.2 PR513.2 PU501.14(OUT)
+3.3V_ALW_UE1: CE13.1 CE14.1 CE15.1 CE19.1 CE20.1 CE23.1 PJP22.2 RE314.2 UE1.B7(VTR_ANALOG) UE1.G8(VTR1) UE1.H1(VTR_REG) UE1.K2(VREF_ADC) UE1.M9(VTR2)
+3.3V_ALW_UZ12: CZ51.1 CZ52.1 PJP391.1 UZ12.1(VSB)
+3.3V_ALWP: PC101.1 PC102.1 PC103.1 PC104.1 PC105.1 PC106.1 PJP101.1 PL100.2 PR106.2 PU100.14(OUT)
+3.3V_CARD_SPI: CR236.2 RR235.2 RR236.2 RR237.2 RR238.2 UR3.8(VCC)
+3.3V_DGFF: CV809.1 CV902.1 CV903.1 CV956.1 JDGFF1.E9 JDGFF1.E10 JDGFF2.E9 JDGFF2.E10 PJP43.1 QV30.2(G) QV30.5(G) RV803.1 RV804.1 RV805.1 RV806.1 RV807.1 RV815.1 RV816.1 RV819.1 UV61.5(P) UV62.5(P)
+3.3V_DGFF_PWR: CZ518.1 CZ528.1 PJP43.2 UZ41.8(VOUT2_2) UZ41.9(VOUT2_1)
+3.3V_DSW: CH63.1 RH92.2 RH93.2 RH94.2 RH243.2 RH439.1 RH440.1 RH602.2 UH1.BE48(VCCDSW_3P31) UH1.BE49(VCCDSW_3P32)
+3.3V_EC_PLL: CE17.1 CE18.1 RE314.1 UE1.F1(VTR_PLL)
+3.3V_FUSE: RH300.2 UH1.AT44(VCCPRIM_3P31)
+3.3V_LAN: C191.1 CL15.1 CL18.1 CL19.1 CL28.1 CL199.1 CL280.1 JLOM1.A1(AMBER_LED+) JLOM1.B2(YELLOW_LED+) RL1.1 RL2.1 RL5.1 RL6.1 RL8.2 RL29.1 RL30.1 RL50.1 UL2.5(P) UZ7.7(VOUT1) UZ7.8(VOUT2)
+3.3V_LAN_OUT: CL7.1 RL8.1 UL1.4(VDD3P3_4) UL1.5(VDD3P3_IN) UL1.15(VDD3P3_15) UL1.19(VDD3P3_19) UL1.29(VDD3P3_29)
+3.3V_M_TPM: CZ59.1 CZ60.1 RZ366.2 RZ367.1 RZ368.2 RZ369.2
+3.3V_MMI_AUX: CR247.1 CR248.2 RR200.2 RR201.1 RR211.1 RR235.1 UR1.45(AUX3V3)
+3.3V_MV: CR217.1 CR218.1 CR229.2 CR230.1 CR234.1 CR235.1 PJP69.2 RR200.1 RR231.1 UR1.12(HV_LC) UR1.18(MV33) UR1.39(HV_SWREG_1) UR1.40(HV_SWREG_2)
+3.3V_PGPPBC: RH304.2 UH1.AN26(VCCPGPPBC1) UH1.AP26(VCCPGPPBC2)
+3.3V_PGPPEF: CH62.1 RH303.2 UH1.AE35(VCCPGPPEF1) UH1.AE36(VCCPGPPEF2)
+3.3V_PGPPG: RH305.2 UH1.AN21(VCCPGPPG_3P3)
+3.3V_PGPPHK: CH64.1 RH306.2 UH1.AC35(VCCPGPPHK1) UH1.AC36(VCCPGPPHK2)
+3.3V_PHVC: RH299.2 UH1.AW9(VCCPRIM_3P32)
+3.3V_PHVLDO: CH37.1 CH67.1 CH323.1 RH298.2 UH1.AY8(VCCPRIM_3P33) UH1.BB7(VCCPRIM_3P34)
+3.3V_PRTC: CH33.1 CH65.1 RH297.2 UH1.BC49(VCCRTC1) UH1.BD49(VCCRTC2)
+3.3V_PUSB2: RH302.2 UH1.V23(VCCPRIM_3P35)
+3.3V_RTC_LDO: PD8.3 PR105.2
+3.3V_RUN: CH10.1 CN1.1 CN2.1 CV60.1 CV61.1 CV62.1 CV63.1 CV64.1 CV813.1 CV814.1 CV815.1 CV816.1 CV817.1 CV844.1 CV854.1 CV855.1 CV856.1 CV857.1 CV858.1 CV878.1 CV879.1 CV880.1 CV881.1 CV882.1 CV939.1 CV940.1 CV941.1 CV942.1 CV955.1 CZ67.1 CZ72.1 CZ509.1 FZ1.1 JDGFF4.C9 JDGFF4.C10 JDGFF4.D1 JDGFF4.D2 JDGFF4.D9 JDGFF4.D10 JDGFF4.E1 JDGFF4.E2 JDGFF4.F9 JDGFF4.F10 JESPI.1 JESPI.2 JUSH1.8 LGA1.2(CS) LGA1.3(SDO/SA0) LGA1.9(VDD) LGA1.10(VDD_IO) LV4.2 LV9.2 PJP5.2 PJP18.1 PJP35.1 PJP39.1 PJP69.1 PR1114.1 QH4.2(G) QH4.5(G) RC370.2 RC444.2 RD14.1 RD15.1 RD16.2 RD17.1 RD22.1 RD23.1 RD24.1 RD40.1 RD46.1 RD48.1 RD78.2 RD85.2 RD86.2 RD88.2 RD92.2 RD93.2 RD94.2 RE67.2 RE557.2 RH76.1 RH90.1 RH123.2 RH124.2 RH126.2 RH127.2 RH128.2 RH130.2 RH131.2 RH132.2 RH133.2 RH134.2 RH199.2 RH214.1 RH221.2 RH222.2 RH223.2 RH224.2 RH225.2 RH267.2 RH319.1 RH324.1 RH331.1 RH333.2 RH339.1 RH350.2 RH355.1 RH360.1 RH361.1 RH373.2 RH374.2 RH378.1 RH380.1 RH402.1 RH628.2 RN2.1 RN200.2 RN203.2 RN208.2 RN211.2 RT643.2 RT644.1 RV55.1 RV57.1 RV59.1 RV61.1 RV63.1 RV65.1 RV125.1 RV126.1 RV127.1 RV739.1 RV740.1 RV822.2 RV823.2 RV824.2 RV825.2 RV826.2 RV827.2 RV828.2 RV840.1 RV848.2 RV849.2 RV850.2 RV851.2 RV852.2 RV853.2 RV855.2 RV862.2 RV864.2 RV865.2 RV866.2 RV867.2 RV869.2 RV877.2 RV878.2 RV879.2 RV885.2 RV886.2 RV887.2 RV888.2 RV891.2 RV893.2 RV900.1 RV901.1 RV904.1 RZ89.1 RZ362.1 RZ365.2 RZ504.1 RZ505.1 RZ507.1 RZ508.1 RZ542.2 UC3.5(VCC) UV8.5(VDD33_1) UV8.21(VDD33_2) UV8.30(VDD33_3) UV8.51(VDD33_4) UV8.57(VDD33_5) UV64.21(VDD33_1) UV64.26(VDD33_2) UV64.35(VDD33_3) UV64.49(VDD33_4) UV64.60(VDD33_5) UV65.5(VCC) UV66.1(VDD_DDC) UV67.1(VDD_DDC)
+3.3V_RUN_AUDIO: CA67.1 CA68.1 LA12.1 LA14.1 PJP18.2 RA219.1 RA224.1
+3.3V_RUN_AUDIO_DVDD: CA55.1 CA56.1 CA226.1 LA12.2 RA18.1 UA1.3(DVDD)
+3.3V_RUN_AUDIO_IO: CA10.1 CA61.1 LA14.2 UA1.18(DVDD-IO)
+3.3V_RUN_DIMM1: CD32.1 CD33.1 JDIMM1.255(VDDSPD) RD16.1
+3.3V_RUN_DIMM2: CD62.1 CD63.1 JDIMM2.255(VDDSPD) RD92.1
+3.3V_RUN_DIMM3: CD98.1 CD99.1 JDIMM3.255(VDDSPD) RD93.1
+3.3V_RUN_DIMM4: CD127.1 CD128.1 JDIMM4.255(VDDSPD) RD94.1
+3.3V_RUN_PWR: CZ524.1 PJP39.2 UZ40.8(VOUT2_2) UZ40.9(VOUT2_1)
+3.3V_RUN_R: JEDP1.10 RZ551.1
+3.3V_RUN_R_F: FZ1.2 QZ1.3(S) RZ551.2
+3.3V_SPI: CH9.1 CH270.1 JSPI1.15 RH30.1 RH185.2 RH335.1 RH600.1 RH601.1 RH615.1 UC5.8(VCC) UC6.8(VCC)
+3.3V_SSD3: CN174.1 CN175.1 CN176.1 CN177.1 CN178.1 CN179.1 CN276.1 CN277.1 CN279.1 CN280.1 CN281.1 CN282.1 JNGFF3.2(3P3VAUX1) JNGFF3.4(3P3VAUX2) JNGFF3.12(3P3VAUX3) JNGFF3.14(3P3VAUX4) JNGFF3.16(3P3VAUX5) JNGFF3.18(3P3VAUX6) JNGFF3.62(3P3VAUX7) JNGFF3.64(3P3VAUX8) JNGFF3.66(3P3VAUX9) PJP30.1 RN37.2
+3.3V_SSD3_PWR: C200.1 PJP30.2 UZ9.13(VOUT1_2) UZ9.14(VOUT1_1)
+3.3V_SSD4: CN188.1 CN189.1 CN190.1 CN191.1 CN192.1 CN193.1 CN283.1 CN285.1 CN286.1 CN287.1 CN288.1 CN289.1 JNGFF4.2(3P3VAUX_1) JNGFF4.4(3P3VAUX_2) JNGFF4.12(3P3VAUX_3) JNGFF4.14(3P3VAUX_4) JNGFF4.16(3P3VAUX_5) JNGFF4.18(3P3VAUX_6) JNGFF4.70(3P3VAUX_7) JNGFF4.72(3P3VAUX_8) JNGFF4.74(3P3VAUX_9) PJP62.1 RN202.2
+3.3V_SSD4_PWR: C206.1 PJP62.2 UZ58.7(VOUT1) UZ58.8(VOUT2)
+3.3V_SSD5: CN202.1 CN203.1 CN204.1 CN205.1 CN206.1 CN207.1 CN295.1 CN297.1 CN298.1 CN299.1 CN300.1 CN301.1 JNGFF5.2(3P3VAUX1) JNGFF5.4(3P3VAUX2) JNGFF5.12(3P3VAUX3) JNGFF5.14(3P3VAUX4) JNGFF5.16(3P3VAUX5) JNGFF5.18(3P3VAUX6) JNGFF5.62(3P3VAUX7) JNGFF5.64(3P3VAUX8) JNGFF5.66(3P3VAUX9) PJP64.1
+3.3V_SSD5_PWR: C203.1 PJP64.2 UZ9.8(VOUT2_2) UZ9.9(VOUT2_1)
+3.3V_SSD6: CN216.1 CN217.1 CN218.1 CN219.1 CN220.1 CN221.1 CN306.1 CN309.1 CN310.1 CN311.1 CN312.1 CN313.1 JNGFF6.2(3P3VAUX1) JNGFF6.4(3P3VAUX2) JNGFF6.12(3P3VAUX3) JNGFF6.14(3P3VAUX4) JNGFF6.16(3P3VAUX5) JNGFF6.18(3P3VAUX6) JNGFF6.62(3P3VAUX7) JNGFF6.64(3P3VAUX8) JNGFF6.66(3P3VAUX9) PJP63.1 RN210.2
+3.3V_SSD6_PWR: C199.1 PJP63.2 UZ59.7(VOUT1) UZ59.8(VOUT2)
+3.3V_TBT: LT2.2 PJP5.1
+3.3V_TBT_ANA: CT302.1 UT1.E16(VCC3P3_ANA)
+3.3V_TBT_ANA_PCIE: CT301.1 RT554.2 UT1.L16(VCC3P3_ANA_PCIE)
+3.3V_TBT_ANA_USB2: CT300.1 UT1.H18(VCC3P3_ANA_USB2)
+3.3V_TBT_FLASH_R: CT1.1 RT1.2 RT2.2 RT3.2 RT4.2 RT9.1 RT578.1 UT2.8(VCC)
+3.3V_TBT_LC: CT303.1 RT5.2 RT6.2 RT7.2 RT8.2 RT9.2 UT1.V6(VCC3P3_LC)
+3.3V_TBT_S0: CT67.1 CT68.1 CT69.1 CT323.1 CT324.1 CT325.1 CT326.1 CT327.1 CT328.1 LT2.1 UT1.E6(VCC3P3A) UT1.G1(VCC3P3_SVR1) UT1.G2(VCC3P3_SVR2) UT1.H2(VCC3P3_SVR3) UT1.L6(VCC3P3_S0)
+3.3V_TBT_SX: CT314.1 CT315.1 PJP6.1 RT11.2 RT16.2 RT17.2 RT20.2 RT372.2 RT502.2 RT503.2 RT591.2 RT592.2 RT593.2 RT613.2 UT1.F18(VCC3P3_SX1) UT1.R6(VCC3P3_SX2)
+3.3V_TP: CZ90.1 JKBTP1.12(12     12) PJP35.2 RZ18.1 RZ19.1 RZ20.1 RZ21.1 RZ116.1 RZ117.1
+3.3V_VDD_PIC: CT370.2 CT371.2 PC5.2 PC2007.1 PC2008.1 PC2015.1 PR20.1 PR39.1 PR57.1 PR70.1 PR71.1 PR72.1 PR2023.1 PR2024.2 PR2025.2 PR2027.1 PR2028.2 PR2029.2 PR2037.2 PR2038.2 PR2039.2 PR2041.1 PR2048.1 PR2050.1 PR2063.1 PR2064.1 PR2147.1 PR2149.1 PR2158.1 PR2159.1 PU1.5(P) PU2001.8(P) PU2003.8(P) PU2004.8(P) RT547.2 RT564.1 RT569.2 RT578.2 UT10.5(VCC) UT12.5(VCC)
+3.3V_VDD_PICP: QT2.1(D) RT542.2
+3.3V_WLAN: CZ157.1 CZ530.1 CZ531.1 CZ532.1 CZ533.1 CZ534.1 CZ535.1 CZ542.1 CZ543.1 JNGFF1.2 JNGFF1.4 JNGFF1.64 JNGFF1.66 PJP36.1
+3.3V_WLAN_PWR: C190.1 PJP36.2 UZ44.13(VOUT1_2) UZ44.14(VOUT1_1)
+3.3V_WWAN: CZ17.1 CZ18.1 CZ19.1 CZ20.1 CZ21.1 CZ164.1 JNGFF2.2 JNGFF2.4 JNGFF2.62 JNGFF2.64 JNGFF2.66 PJP37.1 RZ43.2
+3.3V_WWAN_PWR: C194.1 PJP37.2 UZ44.8(VOUT2_2) UZ44.9(VOUT2_1)
+3.3VB_1.8V: PC900.1 PC901.1 PJP900.2 PU900.3(VIN)
+3.3VB_2.5V: PC400.1 PC406.1 PJP400.2 PU400.3(VIN)
+5V_ALW: CT342.1 CT343.1 CT355.1 CT356.1 CT357.1 CT358.1 JCCG1.7 PC805.1 PJP103.2 PR19.1 PR203.1 PR204.2 PU800.7(V5IN) RI82.2 UI3.1(VIN) UI3.7(CTL2) UI3.8(CTL3) UR4.3(VBIAS) UT5.J2(V5V_P1) UT5.L9(V5V_P2) UT9.1(IN) UT11.1(IN) UZ7.4(VBIAS) UZ42.4(VBIAS) UZ43.4(VBIAS) UZ44.4(VBIAS) UZ59.4(VBIAS)
+5V_ALW2: PC127.1 PU101.15(LDO)
+5V_ALW_R: CZ64.1 CZ69.1 CZ527.1 JLED1.1 JPB1.2 JUSH1.9 JUSH1.10 PC1215.1 PC1225.1 PC1235.1 PC1245.1 PC1708.1 PC1808.1 PJP501.2 PR1151.1 PR1170.1 PR1200.1 PR1205.1 PR1208.1 PR1212.1 PR1700.1 PR1801.1 PU1200.2(SMOD#) PU1200.15(VCCD) PU1201.2(SMOD#) PU1201.15(VCCD) PU1202.2(SMOD#) PU1202.15(VCCD) PU1203.2(SMOD#) PU1203.15(VCCD) PU1700.2(SMOD#) PU1700.15(VCCD) PU1800.15(VCCD) RI13.2 RI67.2 UI1.1(VIN) UI1.7(CTL2) UI1.8(CTL3) UI2.1(VIN) UI2.7(CTL2) UI2.8(CTL3) UZ9.4(VBIAS) UZ19.3(VBIAS) UZ21.3(VBIAS) UZ23.1(VIN1) UZ23.2(VIN2) UZ23.4(VBIAS) UZ26.3(VBIAS) UZ40.1(VIN1_1) UZ40.2(VIN1_2) UZ40.4(VBIAS) UZ41.1(VIN1_1) UZ41.2(VIN1_2) UZ41.4(VBIAS) UZ45.4(VBIAS) UZ58.4(VBIAS)
+5V_ALW_RP: PC506.1 PC507.1 PC508.1 PC509.1 PC510.1 PC511.1 PJP501.1 PL500.2 PR506.2 PU500.14(OUT)
+5V_ALWP: PC120.1 PC121.1 PC122.1 PC123.1 PC124.1 PC125.1 PJP103.1 PL101.2 PR114.2 PU101.14(OUT)
+5V_DGFF: CV805.1 CV806.1 CV957.1 JDGFF1.D9 JDGFF1.D10 JDGFF2.D9 JDGFF2.D10 PJP65.1
+5V_DGFF_PWR: CZ513.1 CZ529.1 PJP65.2 UZ41.13(VOUT1_2) UZ41.14(VOUT1_1)
+5V_HDD: JNGFF4.40(NC12) JNGFF4.42(NC13) JNGFF4.44(NC14) JNGFF4.46(NC15) PJP32.2 RN1.1
+5V_HDD_UZ23: CZ129.1 PJP32.1 UZ23.7(VOUT1) UZ23.8(VOUT2)
+5V_RUN: CZ66.1 CZ71.1 CZ92.1 CZ505.1 CZ506.1 CZ507.1 CZ508.1 DZ20.1 DZ21.1 JDGFF4.E9 JDGFF4.E10 JFAN1.4 JFAN2.4 JKBTP1.5 JUSH1.7 PJP17.1 PJP40.1 RZ518.1
+5V_RUN_AUDIO: CA59.1 CA60.1 CA63.1 CA64.1 LA21.2 LA27.2 PJP17.2
+5V_RUN_CHG: QZ21.1(D) RZ518.2
+5V_RUN_PVDD_L: CA45.1 CA46.1 CA47.1 CA48.1 LA21.1 UA1.41(PVDD1) UA1.46(PVDD2)
+5V_RUN_PWR: CZ519.1 PJP40.2 UZ40.13(VOUT1_2) UZ40.14(VOUT1_1)
+5V_USB_PWR1: CI14.1 CI32.1 JUSB1.1(VBUS) UI1.12(VOUT)
+5V_USB_PWR2: CI1.1 CI3.1 JUSB2.1(VBUS) UI2.12(VOUT)
+5V_USB_PWR3: CI76.1 CI77.1 JUSB3.1(VBUS) UI3.12(VOUT)
+5V_VBUS1: PQ2100.5(D) UT9.13(OUT)
+5V_VBUS2: PQ2104.5(D) UT11.13(OUT)
+13.5VB_BATT: PC713.1 PC714.1 PC715.1 PC716.1 PD701.2 PL11.2 PL12.2 PR715.4
+13.5VB_BATT_C: PBATT1.1 PBATT1.2 PBATT1.3 PC25.1 PL11.1 PL12.1
+13.5VB_CHG: PC725.2 PL701.2 PQ701.1(S1) PQ701.2(S2) PQ701.3(S3) PR715.1 PR735.2
+19.5V_DC_IN: DT63.2 PC1.1 PC4.1 PL1.2 PL2.2 PQ10.1(S1) PQ10.2(S2) PQ10.3(S3) PQ12.3(S) PR1.1 PR3.1 PR2036.1
+19.5V_DC_IN_SS: PD1.2 PD700.3(1) PQ10.5(D) PQ11.5(D)
+19.5V_DCIN_JACK: PC2.1 PD2.1 PJPDC1.7 PJPDC1.8 PJPDC1.9 PJPDC1.10 PL1.1 PL2.1
+19.5V_SDC_IN: PC3.1 PC12.1 PC19.1 PC2103.1 PD1.1 PD4.1 PD6.1 PQ11.1(S1) PQ11.2(S2) PQ11.3(S3) PQ13.3(S) PQ18.1(S1) PQ18.2(S2) PQ18.3(S3) PQ20.3(S) PQ23.1(S1) PQ23.2(S2) PQ23.3(S3) PQ25.3(S) PQ700.5(D) PR2.1 PR4.1 PR26.1 PR29.1 PR44.1 PR47.1 PR706.2 PR707.1
+19.5V_SDC_IN_CR: PQ700.1(S1) PQ700.2(S2) PQ700.3(S3) PQ705.3(S) PR700.1 PR731.1 PR733.1
+19.5VB: CV13.1 FZ2.2 PC138.1 PJP100.1 PJP102.1 PJP200.1 PJP300.1 PJP500.1 PJP503.1 PJP700.2 PJP800.1 PL9.1 PL700.2 PL1200.1 PL1201.1 PQ701.5(D) PR109.2 PR510.2 PR700.4 QT10.3(S) QV1.4(S) RV4.1 RZ85.1
+19.5VB_CHARGER: PC703.1 PC704.1 PC705.1 PC710.1 PJP700.1 PL700.1 PQ702.5(D)
+19.5VB_CPU: PC1204.1(P) PC1205.1(P) PC1206.1 PC1207.1 PC1208.1 PC1209.1 PC1210.1 PC1211.1 PC1217.1 PC1218.1 PC1219.1 PC1220.1 PC1221.1 PC1222.1 PC1227.1 PC1228.1 PC1229.1 PC1230.1 PC1231.1 PC1232.1 PC1237.1 PC1238.1 PC1239.1 PC1240.1 PC1241.1 PC1242.1 PC1700.1 PC1701.1 PC1702.1 PC1703.1 PC1704.1 PC1705.1 PC1710.1 PC1711.1 PC1712.1 PC1713.1 PC1800.1 PC1801.1 PC1802.1 PC1803.1 PC1804.1 PC1805.1 PL1200.2 PL1201.2 PR1150.1 PU1200.8(VIN1) PU1200.9(VIN2) PU1201.8(VIN1) PU1201.9(VIN2) PU1202.8(VIN1) PU1202.9(VIN2) PU1203.8(VIN1) PU1203.9(VIN2) PU1700.8(VIN1) PU1700.9(VIN2) PU1800.8(VIN1) PU1800.9(VIN2)
+19.5VB_DGFF: CZ526.1 PC21.1 PC22.1 PC23.1(P) PC30.1 PL9.2 QZ19.1(S1) QZ19.2(S2) QZ19.3(S3) RZ512.1
+19VB_1.2V: PC200.1 PC202.1 PC203.1 PC204.1 PJP200.2 PQ200.5(D) PR207.1
+19VB_1V: PC800.1 PC801.1 PC802.1 PC803.1 PJP800.2 PQ800.5(D)
+19VB_3V: PC100.1 PC107.1 PC108.1 PC111.1 PJP100.2 PU100.2(IN1) PU100.3(IN2) PU100.4(IN3) PU100.5(IN4)
+19VB_3VR: PC524.1 PC528.1 PC530.1 PC532.1 PJP503.2 PU501.2(IN1) PU501.3(IN2) PU501.4(IN3) PU501.5(IN4)
+19VB_5V: PC114.1 PC116.1 PC117.1 PC118.1 PJP102.2 PU101.2(IN1) PU101.3(IN2) PU101.4(IN3) PU101.5(IN4)
+19VB_5VR: PC500.1 PC502.1 PC503.1 PC504.1 PJP500.2 PU500.2(IN1) PU500.3(IN2) PU500.4(IN3) PU500.5(IN4)
+19VB_IO: PC300.1 PC302.1 PC303.1 PC304.1 PC314.1 PJP300.2 PU300.1(VIN)
+20V_TBTA_VBUS: CT91.1 CT101.1 CT102.1 CT109.1 CT189.1 CT190.1 DT4.2(1) DT4.3(2) DT62.2 JUSBC1.A4(VBUS2) JUSBC1.A9(VBUS4) JUSBC1.B4(VBUS3) JUSBC1.B9(VBUS1) PC7.1 PC8.1 PL5.1 PL6.1 PR2019.2 PR2047.1 RT565.1 UT5.D1(VBUS_P1)
+20V_TBTB_VBUS: CT361.1 CT362.1 CT363.1 CT364.1 CT367.1 CT368.1 DT59.2(1) DT59.3(2) DT60.2 JUSBC1.1A4(VBUS2) JUSBC1.1A9(VBUS4) JUSBC1.1B4(VBUS3) JUSBC1.1B9(VBUS1) PC14.1 PC15.1 PL7.1 PL8.1 PR2020.2 PR2051.1 RT566.1 UT5.L3(VBUS_P2)
+20V_VBUS_1: PC9.1 PC10.1 PC11.1 PC2100.1 PL5.2 PL6.2 PQ17.1(S1) PQ17.2(S2) PQ17.3(S3) PQ19.3(S) PQ2100.1(S1) PQ2100.2(S2) PQ2100.3(S3) PQ2101.3(S) PR25.1 PR27.1 PR28.1 PR2100.1 PR2101.1
+20V_VBUS_2: PC16.1 PC17.1 PC18.1 PC2102.1 PL7.2 PL8.2 PQ22.1(S1) PQ22.2(S2) PQ22.3(S3) PQ24.3(S) PQ2104.1(S1) PQ2104.2(S2) PQ2104.3(S3) PQ2105.3(S) PR43.1 PR45.1 PR46.1 PR2104.1 PR2105.1
+20V_VBUS_DC_SS1: PD4.2 PD4.3 PD700.2 PQ17.5(D1) PQ17.6(D2) PQ17.7(D3) PQ17.8(D4) PQ18.5(D1) PQ18.6(D2) PQ18.7(D3) PQ18.8(D4)
+20V_VBUS_DC_SS2: PD6.2 PD6.3 PD701.3(1) PQ22.5(D1) PQ22.6(D2) PQ22.7(D3) PQ22.8(D4) PQ23.5(D1) PQ23.6(D2) PQ23.7(D3) PQ23.8(D4)
+VCC_CORE: PC1300.1 PC1301.1 PC1302.1 PC1303.1 PC1304.1 PC1305.1 PC1306.1 PC1307.1 PC1308.1 PC1309.1 PC1310.1 PC1311.1 PC1312.1 PC1313.1 PC1314.1 PC1315.1 PC1316.1 PC1317.1 PC1318.1 PC1319.1 PC1320.1 PC1321.1 PC1322.1 PC1323.1 PC1324.1 PC1325.1 PC1326.1 PC1327.1 PC1328.1 PC1329.1 PC1330.1 PC1331.1 PC1332.1 PC1333.1 PC1334.1 PC1335.1 PC1336.1 PC1337.1 PC1338.1 PC1339.1 PC1340.1 PC1341.1 PC1342.1 PC1343.1 PC1344.1 PC1345.1 PC1346.1 PC1347.1 PC1348.1 PC1349.1 PC1350.1 PC1351.1 PC1352.1 PC1353.1 PC1354.1 PC1355.1 PC1356.1 PC1357.1 PC1358.1 PC1359.1 PC1360.1 PC1361.1 PC1362.1 PC1363.1 PC1364.1 PC1365.1 PC1366.1 PC1367.1 PC1368.1 PC1369.1 PC1370.1 PC1371.1 PC1372.1 PC1373.1 PC1374.1 PC1375.1 PC1376.1 PC1377.1 PC1378.1 PC1379.1 PC1380.1 PC1381.1 PC1382.1 PC1383.1 PC1384.1 PC1385.1 PC1386.1 PC1387.1 PC1388.1 PC1389.1 PC1390.1 PC1391.1 PC1392.1 PC1393.1 PC1394.1 PC1395.1 PC1396.1 PC1397.1 PC1398.1 PC1399.1 PC1400.1 PC1401.1 PC1402.1 PC1403.1 PC1404.1 PC1405.1 PC1406.1 PC1407.1 PC1408.1 PC1409.1 PC1410.1 PC1411.1 PC1412.1 PC1413.1 PC1414.1 PC1415.1 PC1416.1 PC1417.1 PC1418.1 PC1419.1 PC1420.1 PC1421.1 PL1202.4 PL1203.4 PL1204.4 PL1205.4 PR1119.1 UC1.AA13(VCC1) UC1.AA31(VCC2) UC1.AA32(VCC3) UC1.AA33(VCC4) UC1.AA34(VCC5) UC1.AA35(VCC6) UC1.AA36(VCC7) UC1.AA37(VCC8) UC1.AA38(VCC9) UC1.AB29(VCC10) UC1.AB30(VCC11) UC1.AB31(VCC12) UC1.AB32(VCC13) UC1.AB35(VCC14) UC1.AB36(VCC15) UC1.AB37(VCC16) UC1.AB38(VCC17) UC1.AC13(VCC18) UC1.AC14(VCC19) UC1.AC29(VCC20) UC1.AC30(VCC21) UC1.AC31(VCC22) UC1.AC32(VCC23) UC1.AC33(VCC24) UC1.AC34(VCC25) UC1.AC35(VCC26) UC1.AC36(VCC27) UC1.AD13(VCC28) UC1.AD14(VCC29) UC1.AD31(VCC30) UC1.AD32(VCC31) UC1.AD33(VCC32) UC1.AD34(VCC33) UC1.AD35(VCC34) UC1.AD36(VCC35) UC1.AD37(VCC36) UC1.AD38(VCC37) UC1.AE13(VCC38) UC1.AE14(VCC39) UC1.AE30(VCC40) UC1.AE31(VCC41) UC1.AE32(VCC42) UC1.AE35(VCC43) UC1.AE36(VCC44) UC1.AE37(VCC45) UC1.AE38(VCC46) UC1.AF29(VCC47) UC1.AF30(VCC48) UC1.AF31(VCC49) UC1.AF32(VCC50) UC1.AF33(VCC51) UC1.AF34(VCC52) UC1.AF35(VCC53) UC1.AF36(VCC54) UC1.AF37(VCC55) UC1.AF38(VCC56) UC1.AG14(VCC57) UC1.AG31(VCC58) UC1.AG32(VCC59) UC1.AG33(VCC60) UC1.AG34(VCC61) UC1.AG35(VCC62) UC1.AG36(VCC63) UC1.AH13(VCC64) UC1.AH14(VCC65) UC1.AH29(VCC66) UC1.AH30(VCC67) UC1.AH31(VCC68) UC1.AH32(VCC69) UC1.AJ14(VCC70) UC1.AJ29(VCC71) UC1.AJ30(VCC72) UC1.AJ31(VCC73) UC1.AJ32(VCC74) UC1.AJ33(VCC75) UC1.AJ34(VCC76) UC1.AJ35(VCC77) UC1.AJ36(VCC78) UC1.AK31(VCC79) UC1.AK32(VCC80) UC1.AK33(VCC81) UC1.AK34(VCC82) UC1.AK35(VCC83) UC1.AK36(VCC84) UC1.AK37(VCC85) UC1.AK38(VCC86) UC1.AL13(VCC87) UC1.AL29(VCC88) UC1.AL30(VCC89) UC1.AL31(VCC90) UC1.AL32(VCC91) UC1.AL35(VCC92) UC1.AL36(VCC93) UC1.AL37(VCC94) UC1.AL38(VCC95) UC1.AM13(VCC96) UC1.AM14(VCC97) UC1.AM29(VCC98) UC1.AM30(VCC99) UC1.AM31(VCC100) UC1.AM32(VCC101) UC1.AM33(VCC102) UC1.AM34(VCC103) UC1.AM35(VCC104) UC1.AM36(VCC105) UC1.AN13(VCC106) UC1.AN14(VCC107) UC1.AN31(VCC108) UC1.AN32(VCC109) UC1.AN33(VCC110) UC1.AN34(VCC111) UC1.AN35(VCC112) UC1.AN36(VCC113) UC1.AN37(VCC114) UC1.AN38(VCC115) UC1.AP13(VCC116) UC1.AP30(VCC117) UC1.AP31(VCC118) UC1.AP32(VCC119) UC1.AP35(VCC120) UC1.AP36(VCC121) UC1.AP37(VCC122) UC1.AP38(VCC123) UC1.K13(VCC124) UC1.K14(VCC1) UC1.L13(VCC2) UC1.L14(VCC3) UC1.N13(VCC4) UC1.N14(VCC5) UC1.N30(VCC6) UC1.N31(VCC7) UC1.N32(VCC8) UC1.N35(VCC9) UC1.N36(VCC10) UC1.N37(VCC11) UC1.N38(VCC12) UC1.P13(VCC13) UC1.P14(VCC14) UC1.P29(VCC15) UC1.P30(VCC16) UC1.P31(VCC17) UC1.P32(VCC18) UC1.P33(VCC19) UC1.P34(VCC20) UC1.P35(VCC21) UC1.P36(VCC22) UC1.R13(VCC23) UC1.R31(VCC24) UC1.R32(VCC25) UC1.R33(VCC26) UC1.R34(VCC27) UC1.R35(VCC28) UC1.R36(VCC29) UC1.R37(VCC30) UC1.R38(VCC31) UC1.T29(VCC32) UC1.T30(VCC33) UC1.T31(VCC34) UC1.T32(VCC35) UC1.T35(VCC36) UC1.T36(VCC37) UC1.T37(VCC38) UC1.T38(VCC39) UC1.U29(VCC40) UC1.U30(VCC41) UC1.U31(VCC42) UC1.U32(VCC43) UC1.U33(VCC44) UC1.U34(VCC45) UC1.U35(VCC46) UC1.U36(VCC47) UC1.V13(VCC48) UC1.V14(VCC49) UC1.V31(VCC50) UC1.V32(VCC51) UC1.V33(VCC52) UC1.V34(VCC53) UC1.V35(VCC54) UC1.V36(VCC55) UC1.V37(VCC56) UC1.V38(VCC57) UC1.W13(VCC58) UC1.W14(VCC59) UC1.W29(VCC60) UC1.W30(VCC61) UC1.W31(VCC62) UC1.W32(VCC63) UC1.W35(VCC64) UC1.W36(VCC65) UC1.W37(VCC66) UC1.W38(VCC67) UC1.Y29(VCC68) UC1.Y30(VCC69) UC1.Y31(VCC70) UC1.Y32(VCC71) UC1.Y33(VCC72) UC1.Y34(VCC73) UC1.Y35(VCC74) UC1.Y36(VCC75)
+VCC_FUSEPRG: RC326.1 UC1.G30(VCCSTG1)
+VCC_GT: PC1500.1(P) PC1502.1 PC1503.1 PC1504.1 PC1505.1 PC1506.1 PC1507.1 PC1508.1 PC1509.1 PC1510.1 PC1511.1 PC1512.1 PC1513.1 PC1514.1 PC1515.1 PC1516.1 PC1517.1 PC1518.1 PC1519.1 PC1520.1 PC1521.1 PC1522.1 PC1523.1 PC1524.1 PC1525.1 PC1526.1 PC1527.1 PC1528.1 PC1529.1 PC1530.1 PC1531.1 PC1532.1 PC1533.1 PC1534.1 PC1535.1 PC1536.1 PL1700.4 PR1124.2 UC1.AT14(VCCGT1) UC1.AT31(VCCGT2) UC1.AT32(VCCGT3) UC1.AT33(VCCGT4) UC1.AT34(VCCGT5) UC1.AT35(VCCGT6) UC1.AT36(VCCGT7) UC1.AT37(VCCGT8) UC1.AT38(VCCGT9) UC1.AU14(VCCGT10) UC1.AU29(VCCGT11) UC1.AU30(VCCGT12) UC1.AU31(VCCGT13) UC1.AU32(VCCGT14) UC1.AU35(VCCGT15) UC1.AU36(VCCGT16) UC1.AU37(VCCGT17) UC1.AU38(VCCGT18) UC1.AV29(VCCGT19) UC1.AV30(VCCGT20) UC1.AV31(VCCGT21) UC1.AV32(VCCGT22) UC1.AV33(VCCGT23) UC1.AV34(VCCGT24) UC1.AV35(VCCGT25) UC1.AV36(VCCGT26) UC1.AW14(VCCGT27) UC1.AW31(VCCGT28) UC1.AW32(VCCGT29) UC1.AW33(VCCGT30) UC1.AW34(VCCGT31) UC1.AW35(VCCGT32) UC1.AW36(VCCGT33) UC1.AW37(VCCGT34) UC1.AW38(VCCGT35) UC1.AY29(VCCGT36) UC1.AY30(VCCGT37) UC1.AY31(VCCGT38) UC1.AY32(VCCGT39) UC1.AY35(VCCGT40) UC1.AY36(VCCGT41) UC1.AY37(VCCGT42) UC1.AY38(VCCGT43) UC1.BA13(VCCGT44) UC1.BA14(VCCGT45) UC1.BA29(VCCGT46) UC1.BA30(VCCGT47) UC1.BA31(VCCGT48) UC1.BA32(VCCGT49) UC1.BA33(VCCGT50) UC1.BA34(VCCGT51) UC1.BA35(VCCGT52) UC1.BA36(VCCGT53) UC1.BB13(VCCGT54) UC1.BB14(VCCGT55) UC1.BB31(VCCGT56) UC1.BB32(VCCGT57) UC1.BB33(VCCGT58) UC1.BB34(VCCGT59) UC1.BB35(VCCGT60) UC1.BB36(VCCGT61) UC1.BB37(VCCGT62) UC1.BB38(VCCGT63) UC1.BC29(VCCGT64) UC1.BC30(VCCGT65) UC1.BC31(VCCGT66) UC1.BC32(VCCGT67) UC1.BC35(VCCGT68) UC1.BC36(VCCGT69) UC1.BC37(VCCGT70) UC1.BC38(VCCGT71) UC1.BD13(VCCGT72) UC1.BD14(VCCGT73) UC1.BD29(VCCGT74) UC1.BD30(VCCGT75) UC1.BD31(VCCGT76) UC1.BD32(VCCGT77) UC1.BD33(VCCGT78) UC1.BD34(VCCGT79) UC1.BD35(VCCGT80) UC1.BD36(VCCGT81) UC1.BE31(VCCGT82) UC1.BE32(VCCGT83) UC1.BE33(VCCGT84) UC1.BE34(VCCGT85) UC1.BE35(VCCGT86) UC1.BE36(VCCGT87) UC1.BE37(VCCGT88) UC1.BE38(VCCGT89) UC1.BF13(VCCGT90) UC1.BF14(VCCGT91) UC1.BF29(VCCGT92) UC1.BF30(VCCGT93) UC1.BF31(VCCGT94) UC1.BF32(VCCGT95) UC1.BF35(VCCGT96) UC1.BF36(VCCGT97) UC1.BF37(VCCGT98) UC1.BF38(VCCGT99) UC1.BG29(VCCGT100) UC1.BG30(VCCGT101) UC1.BG31(VCCGT102) UC1.BG32(VCCGT103) UC1.BG33(VCCGT104) UC1.BG34(VCCGT105) UC1.BG35(VCCGT106) UC1.BG36(VCCGT107) UC1.BH33(VCCGT108) UC1.BH34(VCCGT109) UC1.BH35(VCCGT110) UC1.BH36(VCCGT111) UC1.BH37(VCCGT112) UC1.BH38(VCCGT113) UC1.BJ16(VCCGT114) UC1.BJ17(VCCGT115) UC1.BJ19(VCCGT116) UC1.BJ20(VCCGT117) UC1.BJ21(VCCGT118) UC1.BJ23(VCCGT119) UC1.BJ24(VCCGT120) UC1.BJ26(VCCGT121) UC1.BJ27(VCCGT122) UC1.BJ37(VCCGT123) UC1.BJ38(VCCGT124) UC1.BK16(VCCGT125) UC1.BK17(VCCGT126) UC1.BK19(VCCGT127) UC1.BK20(VCCGT128) UC1.BK21(VCCGT129) UC1.BK23(VCCGT130) UC1.BK24(VCCGT131) UC1.BK26(VCCGT132) UC1.BK27(VCCGT133) UC1.BL15(VCCGT134) UC1.BL16(VCCGT135) UC1.BL17(VCCGT136) UC1.BL23(VCCGT137) UC1.BL24(VCCGT138) UC1.BL25(VCCGT139) UC1.BL26(VCCGT140) UC1.BL27(VCCGT141) UC1.BL28(VCCGT142) UC1.BL36(VCCGT143) UC1.BL37(VCCGT144) UC1.BM15(VCCGT145) UC1.BM16(VCCGT146) UC1.BM17(VCCGT147) UC1.BM36(VCCGT148) UC1.BM37(VCCGT149) UC1.BN15(VCCGT150) UC1.BN16(VCCGT151) UC1.BN17(VCCGT152) UC1.BN36(VCCGT153) UC1.BN37(VCCGT154) UC1.BN38(VCCGT155) UC1.BP15(VCCGT156) UC1.BP16(VCCGT157) UC1.BP17(VCCGT158) UC1.BP37(VCCGT159) UC1.BP38(VCCGT160) UC1.BR15(VCCGT161) UC1.BR16(VCCGT162) UC1.BR17(VCCGT163) UC1.BR37(VCCGT164) UC1.BT15(VCCGT165) UC1.BT16(VCCGT166) UC1.BT17(VCCGT167) UC1.BT37(VCCGT168)
+VCC_SA: PC1600.1 PC1601.1 PC1602.1 PC1603.1 PC1604.1 PC1605.1 PC1606.1 PC1607.1 PC1608.1 PC1609.1 PC1610.1 PC1611.1 PC1612.1 PC1613.1 PC1614.1 PC1615.1 PC1616.1 PC1617.1 PL1800.4 PR1111.1 UC1.J30(VCCSA1) UC1.K29(VCCSA2) UC1.K30(VCCSA3) UC1.K31(VCCSA4) UC1.K32(VCCSA5) UC1.K33(VCCSA6) UC1.K34(VCCSA7) UC1.K35(VCCSA8) UC1.L31(VCCSA9) UC1.L32(VCCSA10) UC1.L35(VCCSA11) UC1.L36(VCCSA12) UC1.L37(VCCSA13) UC1.L38(VCCSA14) UC1.M29(VCCSA15) UC1.M30(VCCSA16) UC1.M31(VCCSA17) UC1.M32(VCCSA18) UC1.M33(VCCSA19) UC1.M34(VCCSA20) UC1.M35(VCCSA21) UC1.M36(VCCSA22)
+VCC_SFR_OC: CC209.2 CC210.2 CC322.1 CC334.1 CC568.1 CZ199.1 RZ119.2 UC1.BH13(VCCPLL_OC1) UC1.BJ13(VCCPLL_OC2) UC1.G11(VCCPLL_OC3) UZ26.6(VOUT)
+VCCRTCEXT: CH68.1 UH1.BF47(DCPRTC1) UH1.BG47(DCPRTC2)
+VDD_SUPPLY: CT344.1 CT345.1 CT346.1 JCCG1.1 RT517.1 RT519.1 RT521.1 RT522.1 RT525.1 RT526.2 RT534.1 RT535.1 UT5.C10(VDD_IO) UT5.D10(VDDD)
+VDDA_AVDD1: CA8.1 CA9.1 LA27.1 RA214.2 UA1.40(AVDD1)
+VSS_PLL: CE17.2 CE18.2 UE1.G1(VSS_PLL)
DV10: CR245.2 CR246.2 UR1.46(DV10)
DV33_18: CR244.2 UR1.24(DV33_18)
